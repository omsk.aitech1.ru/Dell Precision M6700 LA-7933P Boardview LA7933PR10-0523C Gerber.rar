# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_RTCX1: length 8.4
  TOP w0.127: RH15.1 14.32,114.24 14.9,113.67 15.2,113.67 15.25,113.72 17.7,113.72 UH4.A20
  TOP w0.203: RH15.1 14.16,114.49 CH2.1 12.92,113.98 11.53,113.98 11,114.51 YH1.1
PCH_RTCX2: length 5.8
  TOP w0.102: UH4.C20 18.67,113.79 18.25,113.79 18.01,113.55 17.88,113.55
  TOP w0.127: 17.88,113.55 17.82,113.49 15.35,113.49 15.17,113.31 14.72,113.31 14.71,113.3 14.41,113.3 RH15.2
  TOP w0.203: RH15.2 14.29,113.35 RH286.2
PCH_RTCX2_R: length 5.2
  TOP w0.203: YH1.2 9.63,115.13 9.88,114.87 9.88,114.17 10.7,113.35 CH3.1 11.05,113.67 12.01,113.67 RH286.1
PCH_SMB_ALERT#: length 7.5
  TOP w0.102: UH4.E12 20.33,109.65 v3(20.33,109.44)
  IN4 w0.102: 16.38,107.91 16.36,107.89 ; v3(20.33,109.44) 20.31,109.44 19.91,109.04 19.16,109.04 19.13,109.01 18.05,109.01
  IN4 w0.109: 18.05,109.01 17.48,109.01 16.38,107.91 ; 16.36,107.89 16.25,107.79 v1(15.59,107.79)
  BOTTOM w0.102: RH304.1 14.34,107.3 15.12,107.3 15.59,107.77 v1(15.59,107.79)
PCH_SPI_CLK: length 61.5
  TOP w0.102: UH4.T3 25.21,104.98 24.83,104.6 24.83,103.41 v1(25.16,103.08) ; v1(39.3,97.7) 39.71,98.11 43.58,98.11 43.86,97.83 47.93,97.83 48.37,98.26 49.49,98.26 49.95,97.8 50.91,97.8 51.08,97.98 55.09,97.98 55.35,97.73 57.16,97.73 v1(57.39,97.96)
  IN1 w0.109: v1(39.3,97.7) 37.89,97.7 35.24,100.35 34.09,100.35 33.53,100.91 28.31,100.91 26.14,103.08 v1(25.16,103.08)
  BOTTOM w0.102: JSPI1.8 49.97,107.76 50.12,107.91 51.04,107.91 RH348.2 51.63,107.33 52.96,107.33 52.98,107.32 53.4,107.32 53.72,107.64 53.72,107.91 54.14,108.33 54.79,108.33 55.36,107.76 59.75,107.76 v2(60.44,107.07) 60.72,106.79 60.72,103.32 58.6,101.19 58.6,99.38 57.39,98.17 v1(57.39,97.96)
PCH_SPI_CS0#: length 69.2
  TOP w0.102: v1(27.75,110.96) 27.75,110.97 27.4,111.32 UH4.Y14
  IN1 w0.102: v1(36.14,103.94) 35.98,104.1 32.42,104.1 v1(31.8,103.48)
  IN3 w0.102: v1(27.75,110.96) 28.82,109.89 28.82,109.64 29.2,109.26 29.2,105.74 29.61,105.33 30.57,105.33 31.37,104.53 31.37,103.91 v1(31.8,103.48)
  BOTTOM w0.102: v1(36.14,103.94) 35.01,103.94 34.89,104.06 34.89,104.31 35.01,104.43 36.02,104.43 36.14,104.56 36.14,104.8 36.02,104.93 35.08,104.93 34.95,105.05 34.95,105.35 35.15,105.55 35.15,107.05 35.28,107.18 35.52,107.18 35.65,107.05 35.65,105.6 35.77,105.47 36.02,105.47 36.14,105.6 36.14,105.83 36.27,105.96 36.52,105.96 36.65,105.83 v2(36.65,103.02) 36.65,101.36 36.78,101.23 37.64,101.23 37.77,101.36 37.77,101.63 37.64,101.75 37.26,101.75 37.14,101.88 37.14,105.86 37.26,105.98 37.53,105.98 37.65,105.86 37.65,104.75 37.79,104.61 38.91,104.61 39.04,104.49 39.04,104.23 38.91,104.11 37.8,104.11 37.79,104.1 37.65,103.96 37.65,102.39 37.78,102.26 38.1,102.26 38.23,102.39 38.23,103.42 38.35,103.54 38.58,103.54 38.71,103.42 38.71,102.62 38.84,102.49 39.05,102.49 39.18,102.62 39.18,103.43 39.3,103.56 39.53,103.56 39.66,103.43 39.66,101.66 39.53,101.54 38.62,101.54 38.49,101.41 38.49,101.11 38.62,100.98 41.77,100.98 42.54,101.75 42.54,103.72 42.85,104.03 44.05,104.03 44.3,104.27 44.3,105.39 45.01,106.1 45.01,108.17 45.6,108.76 JSPI1.10 50.67,108.76 RH349.2
PCH_SPI_CS1#: length 54.5
  TOP w0.102: UH4.T1 25.21,103.77 v1(25.26,103.72)
  IN1 w0.109: v1(25.26,103.72) 26.47,103.72 28.77,101.42 33.86,101.42 34.26,101.02 35.29,101.02 37.98,98.33 39.46,98.33 40.17,97.62 45.7,97.62 46.45,96.86 53.69,96.86 54.68,95.87 56.02,95.87 56.34,95.56 56.62,95.56 56.78,95.39 v1(56.86,95.39)
  BOTTOM w0.102: v1(56.86,95.39) 56.86,95.76 56.82,95.8 56.82,98.32 58.09,99.59 58.09,102.72 57.73,103.07 57.73,103.68 v4(57.34,104.08) 56.97,104.45 52.87,104.45 52.56,104.75 51.27,104.75 50.81,104.29 RH345.2 50.13,104.29 49.66,104.76 JSPI1.2
PCH_SPI_DIN: length 67.3
  TOP w0.102: v1(36.08,98.48) 36.33,98.73 43.78,98.73 44.17,98.34 47.19,98.34 47.62,98.77 50.23,98.77 53.71,102.25 53.71,105.66 v1(53.9,105.86) ; v1(25.74,107.01) 25.71,106.98 UH4.U3
  IN3 w0.102: 25.74,103.19 v1(25.74,107.01)
  IN3 w0.127: v1(20.06,98.24) 20.06,98.69 20.69,99.31 20.69,100.03 21.38,100.72 24.74,100.72 25.56,101.54 25.56,102.79 25.74,102.97 25.74,103.19
  BOTTOM w0.102: v1(36.08,98.48) 36.08,95.64 35.69,95.25 33.81,95.25 32.23,93.68 30.57,93.68 v2(30.08,93.19) 29.56,92.67 25.7,92.67 24.29,94.08 21.75,94.08 21.08,94.76 21.08,97.22 v1(20.06,98.24) ; v1(53.9,105.86) 53.61,105.86 52.64,106.82 51.16,106.82 RH347.2 50.41,106.58 50.41,106.72 50.25,106.88 49.72,106.88 49.6,106.76 JSPI1.6
PCH_SPI_DO: length 64
  TOP w0.102: v1(35.38,98.86) 35.48,98.96 44.02,98.96 44.41,98.57 47.04,98.57 47.47,99 49.76,99 53.31,102.55 53.31,104.79 53.14,104.97 v1(53.12,104.97) ; v1(26.68,106.41) 26.5,106.41 26.2,106.11 UH4.V4
  IN3 w0.102: 26.8,103.19 26.72,103.26 26.72,104.78 27.1,105.16 27.1,105.88 26.68,106.3 v1(26.68,106.41)
  IN3 w0.127: 26.8,103.19 27.07,102.91 27.07,101.4 25.38,99.7 24.19,99.7 22.73,98.24 21.99,98.24 21.7,98.52 v1(21.7,98.55)
  BOTTOM w0.102: v1(21.7,98.55) 22.12,98.13 22.12,97.27 v2(21.84,96.99) 21.32,96.47 21.32,94.84 21.81,94.36 24.43,94.36 25.87,92.91 29.32,92.91 30.31,93.9 32.04,93.9 33.63,95.49 35.43,95.49 35.81,95.87 35.81,97.84 35.52,98.13 35.52,98.72 v1(35.38,98.86) ; JSPI1.4 49.61,105.76 50.06,105.31 RH346.2 50.8,105.31 51.29,105.8 52.09,105.8 52.89,105 53.08,105 v1(53.12,104.97)
PCH_THRMTRIP#_R: length 8.9
  TOP w0.102: UH4.AY10 36.95,108.65 36.66,108.37 v1(36.66,108.33)
  BOTTOM w0.102: CH97.1 RH262.2 40.81,103.96 39.48,105.28 v2(38.24,105.28) 38.11,105.41 38.11,107.11 36.89,108.33 v1(36.66,108.33)
PCI_5048: length 9.8
  TOP w0.102: RH160.1 17.93,135.89 v1(17.89,135.85) ; v3(20.65,129.44) 21.18,128.91 21.18,128.23 UH4.H49
  IN1 w0.109: v1(17.89,135.85) 18.07,135.67 18.07,132.65 20.17,130.56 20.17,129.92 v3(20.65,129.44)
PCI_DOCK: length 10.1
  TOP w0.102: v1(21.61,130.23) 21.61,128.6 21.84,128.37 21.84,127.97 21.75,127.87 UH4.J48 ; v1(20.66,134.57) 19.66,135.57 RH103.1
  IN4 w0.109: v1(20.66,134.57) 20.6,134.57 20.23,134.2 20.23,132.14 21.07,131.31 21.07,130.77 v1(21.61,130.23)
  BOTTOM w0.102: v2(20.17,134.8) 20.39,134.57 v1(20.66,134.57)
PCI_GNT3#: length 6.8
  TOP w0.102: UH4.F46 20.04,126.59 19.8,126.34 v1(19.76,126.34)
  BOTTOM w0.102: RH333.1 19.78,130.53 v2(19.77,130.53) 19.85,130.45 19.85,128.35 20.22,127.98 20.22,126.8 v1(19.76,126.34)
PCI_LOOPBACKOUT: length 18.6
  TOP w0.102: v1(20.94,123.3) 20.94,123.33 21.34,123.73 UH4.H40
  IN4 w0.109: v1(17.4,135.43) 17.63,135.43 18.08,134.98 18.08,133.24 17.5,132.65 17.5,126 18.15,125.35 18.15,124.22 18.6,123.76 20.6,123.76 20.94,123.42 v1(20.94,123.3)
  BOTTOM w0.102: v1(17.4,135.43) 17.51,135.32 v2(18.22,135.32) 18.78,135.88 RH105.1
PCI_MEC: length 14.4
  TOP w0.102: UH4.H43 21.35,125.32 21.72,124.95 21.72,124.38 21.7,124.36 v3(21.7,124.18)
  IN4 w0.109: v1(20.66,135.22) 20.55,135.22 19.74,134.4 19.74,131.94 20.09,131.59 20.09,128.63 21.12,127.6 21.12,125.6 21.72,125 21.72,124.2 v3(21.7,124.18)
  BOTTOM w0.127: v1(20.66,135.22) 20.67,135.23 RH102.1
PCI_PIRQA#: length 10.9
  TOP w0.102: UH4.K40 21.68,123.48 v1(21.68,123.3)
  BOTTOM w0.102: v1(21.68,123.3) 21.68,123.57 21.46,123.79 19.42,123.79 16.8,126.41 16.8,126.67 v2(15.33,128.14) 14.88,128.59 RH324.2
PCI_PIRQB#: length 10.7
  TOP w0.102: UH4.K38 22.39,122.79 22.69,123.09 v1(22.69,123.13)
  BOTTOM w0.102: v1(22.69,123.13) 22.69,123.09 22.42,122.82 18.29,122.82 v2(17.64,123.47) 16.88,124.24 16.88,124.42 15.69,125.6 RH325.2
PCI_PIRQC#: length 10.3
  TOP w0.102: UH4.H38 21.21,122.79 20.85,122.43 v1(20.85,122.28)
  IN1 w0.109: v1(15.51,123.25) 15.75,123.01 15.75,122.86 16,122.61 18.59,122.61 19.33,121.87 20.41,121.87 20.82,122.28 v1(20.85,122.28)
  BOTTOM w0.102: v2(15.56,125.2) 14.87,125.2 14.29,124.62 RH326.2 15.51,123.39 v1(15.51,123.25)
PCI_PIRQD#: length 11.8
  TOP w0.102: v2(12.23,124.07) 12.01,124.28 v1(12.01,124.61) ; UH4.G38 20.7,122.81 20.29,123.23 v1(20.29,123.28)
  IN1 w0.109: v1(20.29,123.28) 20.29,123.38 19.91,123.76 18.63,123.76 17.49,124.91 16.37,124.91 15.87,125.4 14.59,125.4 14.26,125.07 12.47,125.07 v1(12.01,124.61)
  BOTTOM w0.102: RH329.2 11.53,125.03 11.95,124.61 v1(12.01,124.61)
PCI_REQ1#: length 6.4
  TOP w0.102: UH4.C46 18.75,126.75 19.05,126.45 19.05,126.36 v1(19.08,126.33)
  BOTTOM w0.102: v1(19.08,126.33) v2(18.42,126.98) 18.03,127.37 18.03,131.08 17.75,131.36 RH327.2
PCI_TPM_TCM: length 12.5
  TOP w0.102: UH4.K43 22.13,125.32 v1(21.76,125.68)
  TOP w0.127: v3(22.79,134.54) 22.71,134.54 22.17,135.08 22.17,135.41 RH311.2
  IN4 w0.102: 22.87,129.35 22.87,128.58 22.77,128.49 22.77,128.47 22.02,127.72 22.02,127.24 21.33,126.56 21.33,126.12 21.76,125.7 v1(21.76,125.68)
  IN4 w0.127: v3(22.79,134.54) 22.44,134.19 22.44,132.41 22.72,132.13 22.72,130.7 22.87,130.55 22.87,129.35
PCIE_CARD: length 9.7
  TOP w0.102: RH86.1 28.46,135.31 28.46,134.23 28.94,133.75 v1(28.94,132.18) 28.94,131.37 27.71,130.13 27.71,129.21 27.85,129.07 27.85,128.71 27.5,128.36 27.5,128.01 27.36,127.87 27.36,127.57 27.69,127.24 UH4.AA47
PCIE_CARD#: length 9.7
  TOP w0.102: UH4.AA48 27.86,127.89 27.86,127.98 27.76,128.08 27.76,128.25 28.12,128.6 28.12,129.18 27.98,129.32 27.98,130.02 29.21,131.26 29.21,133.86 v1(28.92,134.14) 28.73,134.34 28.73,135.64 28.8,135.71 29.08,135.71 RH85.1
PCIE_EXP: length 7.8
  TOP w0.102: UH4.Y45 27.36,125.95 v3(27.67,125.64)
  BOTTOM w0.102: RH93.1 29.81,131.67 29.4,131.26 29.4,128.71 27.39,126.7 27.39,125.77 27.52,125.64 v3(27.67,125.64)
PCIE_EXP#: length 8
  TOP w0.102: v1(26.6,125.63) 26.92,125.32 UH4.Y43
  BOTTOM w0.102: RH92.1 28.81,131.67 29.13,131.34 v1(29.13,129.67) 29.13,128.82 27.13,126.81 27.13,126.1 26.66,125.63 v1(26.6,125.63)
PCIE_LAN: length 5.8
  TOP w0.102: RH83.1 30.72,131.55 30.72,131.26 30.41,130.95 30.2,130.95 30.09,130.84 29.87,130.84 29.37,130.34 28.73,129.7 28.73,128.19 28.18,127.65 UH4.AB47
PCIE_LAN#: length 5.7
  TOP w0.102: RH82.1 30.05,131.9 30.35,131.9 30.4,131.85 30.4,131.27 30.31,131.18 30.12,131.18 30.01,131.06 29.72,131.06 v1(29.18,130.53) 28.46,129.81 28.46,128.3 28.32,128.16 UH4.AB49
PCIE_MINI1: length 11.1
  TOP w0.102: v1(27.7,123.72) 27.4,123.41 UH4.Y39
  BOTTOM w0.102: RH308.1 31.6,131.42 31.6,131.01 31.12,130.54 30.61,130.54 30.24,130.17 v1(30.24,126.87) 30.24,125.4 29.13,124.3 28.61,124.3 28.15,123.84 27.84,123.84 27.83,123.84 v1(27.7,123.72)
PCIE_MINI1#: length 11.2
  TOP w0.102: v3(27.7,124.35) 27.4,124.05 UH4.Y40
  BOTTOM w0.102: RH307.1 30.88,131.71 31.27,131.71 31.33,131.65 31.33,131.12 31.01,130.81 30.5,130.81 29.97,130.28 29.97,125.51 29.02,124.56 28.5,124.56 28.04,124.1 27.87,124.1 27.7,124.28 v3(27.7,124.35)
PCIE_MINI2: length 17.4
  TOP w0.102: v1(25.7,126.26) 25.7,126.28 25.93,126.51 26.12,126.51 UH4.V46
  IN4 w0.102: 26.34,129.35 26.35,129.34 26.35,128.38 25.87,127.9 25.87,126.44 25.7,126.28 v1(25.7,126.26)
  IN4 w0.117: v3(25.99,138.24) 26.36,137.87 26.36,137.86 26.63,137.58 27.18,137.58 27.23,137.53 27.23,136.9 28.55,135.59 28.55,133.22 26.34,131.01 26.34,129.35
  BOTTOM w0.102: RH96.1 27.37,139.08 26.46,139.08 26.11,138.73 26.11,138.36 v3(25.99,138.24)
PCIE_MINI2#: length 17.4
  TOP w0.102: UH4.V45 26.22,125.95 26.55,126.29 v1(26.72,126.29)
  IN4 w0.102: 26.63,129.35 26.62,129.34 26.62,128.27 26.14,127.79 26.14,126.85 26.69,126.29 v1(26.72,126.29)
  IN4 w0.117: v3(26.64,138.27) 26.64,137.97 26.75,137.86 27.3,137.86 27.52,137.64 27.52,137.02 28.83,135.7 28.83,133.1 26.63,130.9 26.63,129.35
  BOTTOM w0.102: v3(26.64,138.27) 26.38,138.53 26.38,138.62 26.57,138.81 27.46,138.81 27.54,138.74 RH95.1
PCIE_MINI3: length 11.8
  TOP w0.102: v1(27.7,121.68) 27.58,121.68 27.27,121.38 UH4.Y36
  BOTTOM w0.102: v1(27.7,121.68) 27.09,122.3 27.09,122.56 26.88,122.76 26.88,124.42 25.98,125.32 25.98,125.9 26.11,126.02 26.11,127.55 26.76,128.2 26.76,129.21 26.96,129.41 v1(26.96,130.61) 26.96,131.48 RH90.1
PCIE_MINI3#: length 11.8
  TOP w0.102: v3(27.7,122.32) 27.48,122.32 27.23,122.07 UH4.Y37
  BOTTOM w0.102: v3(27.7,122.32) 27.45,122.32 27.35,122.42 27.35,122.67 27.15,122.87 27.15,124.45 26.2,125.4 26.2,125.81 26.31,125.92 26.31,127.38 27.02,128.09 27.02,129.1 27.23,129.3 27.23,131.69 27.34,131.8 27.65,131.8 RH88.1
PCIE_NVR: length 12.5
  TOP w0.102: UH4.V37 26.24,122.07 26.59,121.72 26.68,121.72 v1(26.73,121.67)
  BOTTOM w0.102: RH312.1 24.94,131.47 24.94,131.31 25.31,130.94 25.57,130.94 26.05,130.45 v1(26.05,129.62) 26.05,128.42 25.96,128.33 25.96,128.31 25.72,128.07 25.44,127.79 25.08,127.43 25.08,125.92 25.16,125.84 25.16,125.36 25.69,124.83 25.79,124.83 26.12,124.5 26.12,122.28 v1(26.73,121.67)
PCIE_NVR#: length 12.6
  TOP w0.102: UH4.V38 26.38,122.75 26.68,122.45 v1(26.68,122.33)
  BOTTOM w0.102: RH310.1 25.52,131.9 25.28,131.9 25.21,131.83 25.21,131.42 25.42,131.2 25.68,131.2 26.32,130.56 26.32,128.31 26.22,128.22 26.22,128.2 v1(25.9,127.88) 25.28,127.26 25.28,126.06 25.36,125.98 25.36,125.5 25.77,125.1 25.84,125.1 26.36,124.57 26.36,122.64 v1(26.68,122.33)
PCIE_PRX_EXPTX_N3: length 128.9
  TOP w0.102: JIO1.64 37.06,26.95 37.23,26.77 37.35,26.77 37.54,26.96 v3(37.54,27.02) ; UH4.BG36 40.77,121.62 41.16,121.62 41.3,121.47 41.62,121.47 41.62,121.46 42.48,121.46 42.77,121.76 42.92,121.76 43.01,121.84 43.01,121.83 v1(43.04,121.81)
  IN3 w0.102: 42.77,122.42 42.71,122.35 42.71,122.1 42.57,121.96 42.57,121.88 42.63,121.82 42.76,121.82 42.77,121.83
  IN3 w0.127: v1(43.04,121.81) 43.01,121.83 42.77,121.83 ; v3(37.54,27.02) 37.54,26.82 37.62,26.75 37.69,26.75 37.87,26.56 38,26.56 39.51,28.08 39.85,28.08 41.78,30 41.78,35.3 45.26,38.79 50.9,38.79 57.38,45.26 58.72,45.26 59.52,46.06 59.52,68.6 61.31,70.39 61.31,80.84 61.68,81.21 62.87,81.21 63.44,81.78 63.44,83.71 64.15,84.42 64.15,91.21 62.71,92.65 62.71,93.69 59.18,97.22 59.18,97.41 58.15,98.44 57.54,98.44 51.23,104.75 51.23,105.22 50.63,105.82 50.63,113.04 45.08,118.6 45.08,122.33 44.41,122.99 44.05,122.99 43.56,122.49 42.85,122.49 42.77,122.42
PCIE_PRX_EXPTX_P3: length 128.9
  TOP w0.102: UH4.BJ36 41.48,121.94 41.62,122.07 41.92,122.07 41.97,122.02 41.97,121.91 41.93,121.87 41.86,121.87 41.82,121.83 41.82,121.73 41.87,121.68 42.39,121.68 42.61,121.9 42.61,122.26 42.48,122.39 42.42,122.39 v6(42.3,122.28) ; JIO1.66 37.04,26.35 37.22,26.53 37.39,26.53 37.49,26.43 v1(37.49,26.31)
  IN3 w0.102: v6(42.3,122.28) 42.3,122.3 42.75,122.75 42.77,122.75
  IN3 w0.127: 42.77,122.75 42.77,122.74 43.46,122.74 43.95,123.24 44.52,123.24 45.32,122.43 45.32,118.7 50.88,113.15 50.88,105.92 51.48,105.33 51.48,104.85 57.64,98.69 58.25,98.69 59.43,97.52 59.43,97.33 62.96,93.79 62.96,92.75 64.4,91.31 64.4,84.32 63.69,83.6 63.69,81.67 62.98,80.96 61.79,80.96 61.56,80.73 61.56,70.28 59.77,68.5 59.77,45.96 58.82,45.01 57.48,45.01 51.01,38.54 45.37,38.54 42.03,35.2 42.03,29.9 39.96,27.83 39.61,27.83 38.1,26.31 v1(37.49,26.31)
PCIE_PRX_GLANTX_N7: length 132.6
  TOP w0.102: v3(126.03,167.98) 126.24,167.77 126.24,167.58 C459.2 ; UH4.BG40 41,123.78 41.31,123.47 41.62,123.47 41.95,123.8 41.95,123.8 42.15,124 42.57,124 43.1,124.54 v1(43.15,124.54)
  IN1 w0.102: v1(43.15,124.54) 43.15,124.65 43.03,124.77 42.87,124.77 42.75,124.65 42.75,124.3 42.91,124.13 43.41,124.13
  IN1 w0.117: v3(126.03,167.98) 126.19,167.82 126.19,167.81 126.43,167.57 126.43,166.47 125.66,165.69 125.66,163.97 124.66,162.97 120.88,162.97 120.66,163.18 117.73,163.18 116.38,161.84 113.16,161.84 107.87,156.54 107.87,153.61 106.68,152.42 106.42,152.42 105.25,151.25 105.25,149.68 102.76,147.2 102.19,147.2 101.84,146.85 101.84,145.81 98.07,142.03 98.07,139.23 95.87,137.03 87.57,137.03 87.37,137.23 77.68,137.23 77.07,136.61 77.07,130.6 76.35,129.89 75.53,129.89 75.14,129.5 75.14,128.09 74.16,127.11 74.16,125.57 71.17,122.59 71.17,121.19 66.81,116.83 65.67,116.83 61.34,112.5 50.85,112.5 47.84,115.51 47.84,116 44.94,118.9 44.94,122.71 43.51,124.14 43.42,124.14 43.41,124.13
PCIE_PRX_GLANTX_N7_C: length 2.9
  TOP w0.102: U31.39 125.45,164.31 125.54,164.4 125.54,164.8 125.79,165.05 v1(125.83,165.09) 126.21,165.47 126.21,165.84 125.84,166.21 C459.1
PCIE_PRX_GLANTX_P7: length 132.6
  TOP w0.102: C458.2 126.46,167.55 126.46,167.77 v1(126.67,167.98) ; v6(42.34,124.56) 42.45,124.68 42.45,124.88 42.34,124.99 42.15,124.99 41.91,124.75 41.91,124.41 42.02,124.3 42.02,124.18 41.86,124.02 41.72,124.02 41.51,124.22 41.41,124.22 41.21,124.02 41.21,123.91 41.34,123.78 UH4.BJ40
  IN1 w0.102: v6(42.34,124.56) 42.51,124.4 42.51,124.21 42.81,123.9 43.41,123.9
  IN1 w0.117: 43.41,123.9 43.42,123.9 44.71,122.61 44.71,118.8 47.6,115.9 47.6,115.41 50.76,112.26 61.43,112.26 65.77,116.6 66.91,116.6 71.41,121.1 71.41,122.49 74.39,125.47 74.39,127.01 75.37,127.99 75.37,129.4 75.63,129.65 76.45,129.65 77.3,130.51 77.3,136.51 77.78,136.99 87.28,136.99 87.47,136.8 95.96,136.8 98.3,139.14 98.3,141.93 102.08,145.71 102.08,146.75 102.29,146.96 102.86,146.96 105.48,149.58 105.48,151.16 106.51,152.18 106.78,152.18 108.11,153.51 108.11,156.45 113.26,161.6 116.48,161.6 117.83,162.95 120.56,162.95 120.78,162.73 124.76,162.73 125.89,163.87 125.89,165.6 126.67,166.37 v1(126.67,167.98)
PCIE_PRX_GLANTX_P7_C: length 2.9
  TOP w0.102: U31.38 125.85,164.33 125.76,164.42 125.76,164.69 126.19,165.12 126.19,165.14 126.42,165.38 126.42,165.79 C458.1
PCIE_PRX_MMITX_N8: length 113.3
  TOP w0.102: JIO1.16 37.09,41.35 37.29,41.54 37.47,41.54 v1(37.68,41.33) ; UH4.BE38 39.32,122.79 39.6,123.06 v6(39.6,123.33)
  IN3 w0.102: 42.77,116.66 40.98,118.45 40.98,121.56 40.47,122.07 40.07,122.07 39.6,122.54 39.6,123.33 v6(39.6,123.33)
  IN3 w0.127: 42.77,116.66 43.84,116.66 45.49,115.01 45.49,112.46 46.3,111.64 46.3,108.09 47.66,106.74 47.66,105.32 48.49,104.49 48.49,103.07 50.4,101.15 51.41,101.15 53.38,99.19 53.38,97.2 54.48,96.1 54.48,95.49 57.8,92.17 58.65,92.17 61.87,88.96 61.87,85.83 56.49,80.46 56.49,67.91 56.49,67.7 55.73,66.94 55.73,66.94 55.72,66.93 55.72,50.27 55.23,49.78 55.23,46.23 50.34,41.34 40.08,41.34 39.7,41.72 38.88,41.72 38.51,41.34 38.51,41.34 38.5,41.33 v1(37.68,41.33)
PCIE_PRX_MMITX_P8: length 113.2
  TOP w0.102: UH4.BC38 38.73,122.79 38.96,123.03 v1(38.96,123.33) ; JIO1.14 37.11,41.95 37.3,41.76 37.47,41.76 v3(37.68,41.97)
  IN3 w0.102: v1(38.96,123.33) 39.02,123.33 39.37,122.98 39.37,122.45 39.97,121.85 40.38,121.85 40.76,121.47 40.76,118.34 42.69,116.41 42.77,116.41
  IN3 w0.127: 42.77,116.41 43.73,116.41 45.24,114.91 45.24,112.35 46.05,111.54 46.05,107.99 47.41,106.63 47.41,105.22 48.24,104.39 48.24,102.96 50.3,100.9 51.31,100.9 53.13,99.08 53.13,97.1 54.23,95.99 54.23,95.39 57.7,91.92 58.55,91.92 61.62,88.85 61.62,85.94 56.24,80.56 56.24,67.81 55.47,67.04 55.47,50.38 54.98,49.89 54.98,46.34 50.23,41.59 40.18,41.59 39.8,41.97 38.78,41.97 38.4,41.59 38.05,41.59 37.68,41.96 v3(37.68,41.97)
PCIE_PRX_NVRTX_N6: length 38
  TOP w0.102: UH4.BJ38 41.48,122.99 41.54,123.05 41.9,123.05 41.97,123.13 42.53,123.13 42.58,123.18 42.58,123.23 42.62,123.27 42.98,123.27 43.08,123.37 v6(43.08,123.5) ; U12.18 29.32,145.66 29.18,145.52 29.18,145.33 29.37,145.15 v1(29.37,145.13)
  IN3 w0.127: v6(43.08,123.5) 43.15,123.42 43.37,123.42 43.47,123.52 43.47,123.84 43.84,124.21 43.84,125.57 43.23,126.17 43.23,129.09 41.99,130.33 41.99,131.21 40.18,133.02 39.24,133.02 36.3,135.96 36.3,137.31 34.8,138.81 28.6,138.81 27.69,139.71 27.69,140.48 28.12,140.91 28.76,140.91 29.69,141.83 29.69,143.45 28.97,144.16 28.97,144.73 v1(29.37,145.13)
PCIE_PRX_NVRTX_P6: length 38
  TOP w0.102: UH4.BG38 40.7,122.79 40.88,122.97 41.16,122.97 41.45,123.27 41.81,123.27 41.88,123.34 42.12,123.34 v1(42.37,123.58) ; v3(28.73,145.13) 28.74,145.13 28.94,145.33 28.94,145.53 28.82,145.65 U12.17
  IN3 w0.102: 42.77,123.97 42.75,123.97 v1(42.37,123.58)
  IN3 w0.127: v3(28.73,145.13) 28.73,145.13 28.73,144.06 29.44,143.35 29.44,141.94 28.66,141.16 28.01,141.16 27.44,140.59 27.44,139.61 28.5,138.56 34.7,138.56 36.05,137.2 36.05,135.86 39.14,132.77 40.08,132.77 41.74,131.11 41.74,130.23 42.98,128.99 42.98,126.07 43.59,125.46 43.59,124.32 43.23,123.97 42.77,123.97
PCIE_PRX_WANTX_N1: length 101.5
  TOP w0.102: v1(42.64,120.58) 42.84,120.79 42.84,120.85 42.68,121.01 42.12,121.01 41.61,120.49 41.31,120.49 40.96,120.84 40.63,120.84 UH4.BG34
  IN1 w0.102: v1(42.64,120.58) 42.77,120.45
  IN1 w0.117: v3(101.35,140.55) 101.69,140.89 101.69,140.99 101.54,141.14 101.15,141.14 100.49,140.48 100.49,138.31 95.53,133.36 87.38,133.36 85.36,131.33 85.36,130.81 83.78,129.23 83.78,127.52 81.86,125.6 79.85,125.6 79.61,125.35 76.48,125.35 73.42,122.28 73.42,120.9 66.93,114.41 66.93,113.56 65.47,112.11 63.39,112.11 61.95,110.67 50.03,110.67 48.63,112.08 48.15,112.08 46,114.23 46,115.35 42.79,118.56 42.79,120.43 42.77,120.45
  BOTTOM w0.102: v3(101.35,140.55) 101.64,140.84 101.64,141.42 103.71,143.49 103.71,151.17 102.18,152.69 101.15,152.69 101.07,152.6 101.07,152.32 100.99,152.25 JMINI1.23
PCIE_PRX_WANTX_P1: length 101.5
  TOP w0.102: UH4.BJ34 41.32,120.81 41.22,120.9 41.22,121.03 41.44,121.25 41.56,121.25 41.76,121.04 41.85,121.04 42.03,121.22 42.77,121.22 43.05,120.94 43.05,120.8 v3(43.27,120.58)
  IN1 w0.117: v3(43.27,120.58) 43.03,120.34 43.03,118.66 46.24,115.44 46.24,114.33 48.25,112.31 48.72,112.31 50.13,110.91 61.86,110.91 63.29,112.34 65.37,112.34 66.69,113.66 66.69,114.51 73.18,121 73.18,122.38 76.38,125.59 79.51,125.59 79.75,125.83 81.76,125.83 83.54,127.62 83.54,129.33 85.12,130.9 85.12,131.43 87.28,133.59 95.44,133.59 100.25,138.41 100.25,140.58 101.05,141.38 101.64,141.38 101.93,141.08 101.93,140.58 v1(101.99,140.53)
  BOTTOM w0.102: v1(101.99,140.53) 101.85,140.66 101.85,141.33 103.92,143.4 103.92,151.26 102.26,152.92 101.04,152.92 100.92,153.05 JMINI1.25
PCIE_PRX_WLANTX_N2: length 239.2
  TOP w0.102: v3(183.87,137.35) 183.86,137.34 183.86,135.98 183.98,135.85 183.98,134 183.03,133.05 183.03,126.58 182.9,126.45 182.9,124.49 183.03,124.36 183.03,123.61 183.27,123.37 183.54,123.37 185.84,121.06 185.84,119.5 187.58,117.77 187.58,112.36 189.04,110.9 189.04,107.24 188.72,106.92 188.72,105.94 190.83,103.84 190.83,94.18 190.21,93.55 190.21,92.21 v1(190.21,92.21) ; UH4.BE34 39.27,120.89 38.84,121.32 v1(38.82,121.32)
  IN1 w0.102: v1(38.82,121.32) 38.91,121.32 39.05,121.18 39.05,120.83 39.56,120.32 40.04,120.32 40.87,119.49 40.87,119.35 41.71,118.5 41.71,117.12 42.3,116.53 42.3,114.75 42.77,114.28
  IN1 w0.117: v3(183.87,137.35) 183.79,137.28 183.79,136.75 182.87,135.83 181.94,135.83 179.67,133.56 167.78,133.56 167.39,133.95 164.41,133.95 162.9,135.45 161.2,135.45 158.52,138.13 133.2,138.13 126.65,144.69 126.33,144.69 123.84,147.17 119.61,147.17 116.25,143.82 116.25,137.77 110.97,132.49 108.48,132.49 108.11,132.85 107.6,132.85 106.32,134.14 98.52,134.14 96.27,131.89 88.17,131.89 86.86,130.58 86.86,130.24 86.41,129.78 86.41,126.78 86.68,126.51 86.68,122.43 83.65,119.4 83.28,119.4 82.18,118.29 81.4,118.29 79.35,116.24 77.54,116.24 77.11,115.8 70.49,115.8 69.11,114.42 69.11,112.99 67.8,111.68 67.15,111.68 66.11,110.64 65.31,110.64 64.69,110.01 63.52,110.01 62.53,109.02 61.39,109.02 60.75,108.38 55.37,108.38 55.25,108.27 52.83,108.27 52.13,108.97 49.59,108.97 47.94,110.61 47.5,110.61 44,114.11 42.94,114.11 42.77,114.28
  BOTTOM w0.102: JMINI2.23 190.29,91.51 190,91.81 190,92 v1(190.21,92.21)
PCIE_PRX_WLANTX_P2: length 239.2
  TOP w0.102: v1(183.21,137.39) 183.64,136.96 183.64,135.89 183.77,135.76 183.77,134.09 182.81,133.14 182.81,126.67 182.69,126.54 182.69,124.4 182.81,124.27 182.81,123.52 183.18,123.15 183.45,123.15 185.63,120.97 185.63,119.41 187.36,117.68 187.36,112.27 188.82,110.81 188.82,107.33 188.5,107.01 188.5,105.85 190.61,103.75 190.61,94.27 189.99,93.64 189.99,92.65 189.57,92.23 v1(189.57,92.21) ; v6(39.67,121.3) 39.66,121.29 39.66,120.87 39.72,120.81 UH4.BF34
  IN1 w0.102: 42.77,114.63 42.52,114.88 42.52,116.62 41.93,117.21 41.93,118.59 41.09,119.44 41.09,119.59 40.13,120.54 39.65,120.54 39.27,120.92 39.27,121.23 39.34,121.3 v6(39.67,121.3)
  IN1 w0.117: v1(183.21,137.39) 183.21,137.35 183.56,137 183.56,136.85 182.77,136.07 181.85,136.07 179.57,133.8 167.88,133.8 167.49,134.18 164.51,134.18 163,135.69 161.3,135.69 158.62,138.37 133.3,138.37 126.75,144.92 126.42,144.92 123.94,147.41 119.51,147.41 116.02,143.91 116.02,137.87 110.87,132.72 108.58,132.72 108.21,133.09 107.7,133.09 106.42,134.37 98.42,134.37 96.17,132.12 88.07,132.12 86.63,130.67 86.63,130.33 86.17,129.88 86.17,126.68 86.44,126.41 86.44,122.53 83.55,119.63 83.18,119.63 82.08,118.53 81.3,118.53 79.25,116.48 77.45,116.48 77.01,116.04 70.39,116.04 68.87,114.52 68.87,113.08 67.7,111.91 67.05,111.91 66.01,110.87 65.21,110.87 64.59,110.25 63.42,110.25 62.43,109.26 61.29,109.26 60.65,108.62 55.27,108.62 55.15,108.5 52.92,108.5 52.23,109.2 49.69,109.2 48.04,110.85 47.6,110.85 44.1,114.35 43.06,114.35 42.77,114.63
  BOTTOM w0.102: JMINI2.25 189.49,91.51 189.78,91.81 189.78,92 v1(189.57,92.21)
PCIE_PRX_WPANTX_N5: length 191.8
  TOP w0.102: UH4.BG37 40.29,122.29 40.47,122.48 40.71,122.48 40.87,122.63 41.17,122.63 41.32,122.48 41.62,122.48 42.04,122.9 43.36,122.9 43.81,122.44 44.14,122.44 v1(44.18,122.48)
  IN1 w0.117: v3(181.08,162.13) 181.08,162.13 181.49,161.71 181.49,161.41 180.01,159.93 176.56,159.93 174.63,161.86 173.14,161.86 171.92,163.08 159.09,163.08 151.77,155.77 149.77,155.77 149.09,155.09 144.53,155.09 143.09,153.65 142.41,153.65 141.86,154.2 136.27,154.2 136,153.94 121.47,153.94 120.3,155.12 119.29,155.12 118.67,155.74 118.67,157.63 117,159.3 111.73,159.3 108.68,156.24 108.68,153.21 107.04,151.57 107.04,149.48 104.99,147.43 104.99,146.36 103.74,145.11 103.74,144.76 101.67,142.69 101.22,142.69 99.47,140.94 99.47,138.66 95.71,134.91 87.56,134.91 84.36,131.71 84.36,131.22 82.19,129.04 82.19,127.83 81.93,127.57 79.96,127.57 79.54,127.99 76.19,127.99 75.67,127.47 75.67,125.94 72.05,122.32 72.05,121.03 67.12,116.1 66.33,116.1 65.23,115 65.23,113.99 65.04,113.8 65.04,113.4 64.71,113.08 62.97,113.08 61.57,111.67 50.59,111.67 47.06,115.2 47.06,115.73 43.76,119.02 43.76,120 44.02,120.26 44.02,121.69 44.16,121.82 44.16,122.45 v1(44.18,122.48)
  BOTTOM w0.102: v3(181.08,162.13) 181.51,162.56 181.51,162.94 182.01,163.44 182.01,163.85 181.84,164.03 JMINI3.23
PCIE_PRX_WPANTX_P5: length 191.8
  TOP w0.102: v3(43.71,122) 43.55,122 43.25,122.29 43.25,122.37 43.38,122.49 43.38,122.56 43.24,122.7 42.14,122.7 41.93,122.49 41.72,122.28 41.51,122.28 41.15,121.91 40.92,121.91 40.73,122.1 40.73,122.19 40.83,122.29 UH4.BH37
  IN1 w0.117: v1(181.73,162.1) 181.73,161.81 181.73,161.31 180.11,159.69 176.46,159.69 174.53,161.63 173.04,161.63 171.82,162.85 159.19,162.85 151.87,155.53 149.86,155.53 149.19,154.85 144.63,154.85 143.19,153.42 142.31,153.42 141.76,153.97 136.36,153.97 136.1,153.71 121.37,153.71 120.2,154.88 119.19,154.88 118.43,155.65 118.43,157.53 116.91,159.06 111.83,159.06 108.91,156.14 108.91,153.11 107.28,151.47 107.28,149.38 105.23,147.33 105.23,146.46 105.23,146.26 103.98,145.01 103.98,144.66 101.77,142.46 101.32,142.46 99.71,140.84 99.71,138.57 95.81,134.67 87.66,134.67 84.6,131.61 84.6,131.12 82.42,128.94 82.42,127.73 82.02,127.34 79.86,127.34 79.45,127.75 76.29,127.75 75.91,127.37 75.91,125.84 72.29,122.23 72.29,120.93 67.22,115.86 66.43,115.86 65.47,114.9 65.47,113.89 65.28,113.7 65.28,113.31 64.81,112.84 63.07,112.84 61.67,111.44 50.49,111.44 46.82,115.1 46.82,115.63 43.53,118.93 43.53,120.1 43.79,120.36 43.79,121.92 v3(43.71,122)
  BOTTOM w0.102: JMINI3.25 182.64,164.03 182.23,163.62 182.23,163.35 181.73,162.85 v1(181.73,162.1)
PCIE_PTX_EXPRX_N3: length 136.4
  TOP w0.102: UH4.AV34 36.07,121.05 36.36,121.34 v1(36.42,121.34) ; v1(37.6,25.05) 37.48,24.93 37.22,24.93 37.16,24.99 37.16,25.1 37.1,25.15 JIO1.70
  IN3 w0.127: v1(37.6,25.05) 37.77,24.89 38.17,24.89 39.41,26.13 39.83,26.13 42.54,28.84 42.54,34.92 45.63,38.01 51.41,38.01 56.42,43.02 57.99,43.02 60.29,45.31 60.29,68.22 62.08,70.02 62.08,78.97 63.05,79.94 63.28,79.94 64.22,80.88 64.22,83.32 64.94,84.04 64.94,87.86 65.24,88.17 65.24,92.7 63.6,94.34 63.16,94.34 60.53,96.96 60.53,97.16 58.48,99.21 57.87,99.21 52.17,104.91 52.17,105.5 51.44,106.23 51.44,113.33 46,118.77 46,120.78 46.43,121.2 46.54,121.2 v3(46.92,121.59)
  BOTTOM w0.102: v3(46.92,121.59) 46.76,121.43 45.36,121.43 45.24,121.3 42.07,121.3 41.63,120.85 36.78,120.85 36.7,120.93 36.21,120.93 36.04,121.1 36.04,121.2 36.18,121.34 v1(36.42,121.34)
PCIE_PTX_EXPRX_P3: length 136.4
  TOP w0.102: JIO1.72 37.07,24.55 37.23,24.71 37.3,24.71 v1(37.6,24.42) ; UH4.AU34 35.63,121.06 v1(35.63,121.32)
  IN3 w0.127: v3(46.94,120.96) 46.53,120.96 46.25,120.68 46.25,118.87 51.69,113.44 51.69,106.33 52.42,105.6 52.42,105.01 57.97,99.45 58.58,99.45 60.78,97.26 60.78,97.07 63.26,94.59 63.71,94.59 65.49,92.8 65.49,88.06 65.19,87.76 65.19,83.93 64.47,83.22 64.47,80.78 63.38,79.69 63.16,79.69 62.33,78.87 62.33,69.91 60.53,68.12 60.53,45.21 58.09,42.77 56.52,42.77 51.51,37.76 45.74,37.76 42.79,34.81 42.79,28.74 39.93,25.88 39.52,25.88 38.27,24.64 37.82,24.64 37.6,24.42 v1(37.6,24.42)
  BOTTOM w0.102: v1(35.63,121.32) 35.63,121.31 35.64,121.3 35.65,121.3 35.82,121.13 35.82,120.99 36.08,120.73 36.6,120.73 36.69,120.64 41.72,120.64 42.16,121.08 45.33,121.08 45.45,121.21 46.68,121.21 v3(46.94,120.96)
PCIE_PTX_GLANRX_N7: length 136.5
  TOP w0.102: C461.1 123.21,167.59 123.21,167.71 v3(123.01,167.92) ; UH4.AY40 37.37,124.2 v1(37.58,124.41)
  IN1 w0.102: v1(37.58,124.41) 37.79,124.62 37.79,124.84 38.03,125.08 38.45,125.08 38.84,124.69 40.39,124.69 41.34,125.64 42.77,125.64
  IN1 w0.117: v3(123.01,167.92) 123.1,167.82 123.1,167.82 123.21,167.71 123.21,166.76 124.35,165.61 124.35,164.06 124.02,163.72 121.3,163.72 119.18,165.84 115.98,165.84 107.13,156.99 107.13,153.93 106.45,153.25 106.07,153.25 104.51,151.69 104.51,150.02 102.85,148.36 102.32,148.36 97.25,143.29 97.25,139.65 95.41,137.82 88.39,137.82 88.25,137.96 76.35,137.96 75.78,137.39 75.78,135.37 76.33,134.83 76.33,130.91 76.06,130.64 75.2,130.64 74.36,129.8 74.36,128.52 73.42,127.58 73.42,125.97 68.19,120.74 68.19,119.25 66.52,117.58 65.36,117.58 61.07,113.3 51.12,113.3 48.58,115.84 48.58,116.36 45.68,119.25 45.68,123.05 43.09,125.64 42.77,125.64
PCIE_PTX_GLANRX_N7_C: length 3.4
  TOP w0.102: U31.42 124.25,164.34 124.34,164.43 124.34,165.02 124.02,165.34 123.51,165.34 123.24,165.61 123.24,165.76 C461.2
PCIE_PTX_GLANRX_P7: length 136.5
  TOP w0.102: v6(38.23,124.42) 38.23,124.35 38,124.12 UH4.BB40 ; C460.1 123.74,167.16 123.43,167.48 123.43,167.7 v1(123.65,167.92)
  IN1 w0.102: 42.77,125.41 42.75,125.41 42.75,125.41 42.73,125.41 42.72,125.42 42.65,125.42 42.64,125.43 41.43,125.43 40.47,124.47 38.75,124.47 38.36,124.86 38.13,124.86 38.01,124.75 38.01,124.64 v6(38.23,124.42)
  IN1 w0.117: 42.77,125.41 42.99,125.41 45.44,122.95 45.44,119.16 48.34,116.26 48.34,115.74 51.02,113.06 61.17,113.06 65.46,117.35 66.62,117.35 68.43,119.15 68.43,120.64 73.66,125.87 73.66,127.48 74.6,128.42 74.6,129.71 75.3,130.4 76.16,130.4 76.57,130.81 76.57,134.93 76.02,135.47 76.02,137.3 76.45,137.72 88.16,137.72 88.3,137.58 95.51,137.58 97.48,139.56 97.48,143.19 102.42,148.13 102.95,148.13 104.75,149.92 104.75,151.59 106.17,153.02 106.55,153.02 107.36,153.83 107.36,156.89 116.08,165.61 119.08,165.61 121.2,163.49 124.12,163.49 124.59,163.96 124.59,165.71 123.44,166.85 123.44,167.71 v1(123.65,167.92)
PCIE_PTX_GLANRX_P7_C: length 3.3
  TOP w0.102: 124.39,165.29 124.13,165.56 123.6,165.56 123.48,165.67 123.48,165.9 C460.2 ; 124.39,165.29 124.56,165.13 124.56,164.41 124.65,164.32 U31.41 ; 124.39,165.29 v1(124.39,165.29)
PCIE_PTX_MMIRX_N8: length 152.3
  TOP w0.102: JIO1.22 37.31,39.55 37.39,39.63 37.39,39.83 37.49,39.93 38.52,39.93 40,38.44 40,36.07 40.85,35.22 40.85,32.55 44.04,29.36 46.99,29.36 47.09,29.26 47.09,28.97 47.02,28.9 v1(46.7,28.9) ; UH4.AW38 36.73,123.02 37.04,123.33 v1(37.04,123.34)
  IN3 w0.127: v1(46.7,28.9) 46.9,28.7 46.9,28.52 47.23,28.19 48.17,28.19 48.5,27.86 49.8,27.86 50.41,28.47 54.32,28.47 55.22,29.38 56.7,29.38 59.12,31.79 59.12,42.47 61.98,45.33 61.98,67.69 63.93,69.64 63.93,76.64 64.74,77.45 64.74,79.98 66.56,81.8 66.56,84.3 67.13,84.87 67.13,86.65 66.94,86.85 66.94,92.48 64.07,95.35 63.57,95.35 61.9,97.02 61.9,97.24 58.54,100.6 58.02,100.6 54.02,104.61 54.02,105.08 52.49,106.62 52.49,114.89 50.16,117.22 48.98,117.22 47.54,118.66 47.54,119.85 47.97,120.27 47.97,123.81 47.45,124.33 v1(46.8,124.33)
  BOTTOM w0.102: v1(46.8,124.33) v1(45.22,124.33) 44.4,124.33 43.06,125.67 41.96,125.67 40.27,123.98 37.26,123.98 37.08,123.8 37.08,123.38 37.04,123.34 v1(37.04,123.34)
PCIE_PTX_MMIRX_P8: length 152.2
  TOP w0.102: v1(37.69,123.33) 37.69,123.3 37.37,122.98 UH4.AY38 ; JIO1.20 36.21,40.15 38.61,40.15 40.22,38.53 40.22,36.16 41.07,35.31 41.07,32.64 44.13,29.58 47.08,29.58 47.31,29.35 47.31,28.97 47.38,28.9 v1(47.6,28.9)
  IN3 w0.127: v1(47.6,28.9) 47.6,29.2 47.52,29.27 47.27,29.27 47.15,29.15 47.15,28.63 47.33,28.44 48.27,28.44 48.6,28.11 49.7,28.11 50.31,28.72 54.21,28.72 55.11,29.62 56.6,29.62 58.87,31.89 58.87,42.57 61.73,45.44 61.73,67.79 63.68,69.74 63.68,76.74 64.49,77.55 64.49,80.08 66.31,81.9 66.31,84.41 66.88,84.98 66.88,86.55 66.69,86.75 66.69,92.38 63.96,95.1 63.47,95.1 61.65,96.92 61.65,97.14 58.43,100.36 57.92,100.36 53.78,104.5 53.78,104.98 52.24,106.51 52.24,114.79 50.06,116.97 48.88,116.97 47.29,118.56 47.29,119.95 47.72,120.37 47.72,123.71 47.34,124.08 47.18,124.08 v3(46.8,123.7)
  BOTTOM w0.102: v3(46.8,123.7) 46.38,124.12 45.5,124.12 45.49,124.1 44.96,124.1 44.94,124.12 44.31,124.12 42.98,125.45 42.05,125.45 40.36,123.76 37.35,123.76 37.3,123.71 37.3,123.66 37.63,123.33 v1(37.69,123.33)
PCIE_PTX_NVRRX_N6: length 41
  TOP w0.102: C640.2 28.11,142.85 28.01,142.75 28.01,142.39 v1(28.23,142.17) ; v5(35.48,122.38) 35.38,122.28 UH4.AU36
  IN3 w0.102: 25.05,129.35 25.04,129.34 25.04,128.3 26.32,127.01 26.32,126.4 26.31,126.39 26.31,125.92 25.95,125.56 25.95,125.07 26.47,124.56 26.47,123.24 26.25,123.03 26.25,121.37 26.53,121.1 31.48,121.1 32.33,121.94 35.15,121.94 35.15,121.95 35.16,121.96 35.66,121.96 35.9,122.2 35.9,122.38 35.79,122.49 35.6,122.49 v5(35.48,122.38)
  IN3 w0.127: v1(28.23,142.17) 28.21,142.17 27.96,141.92 27.96,141.83 27.57,141.44 27.01,141.44 23.82,138.25 22.39,138.25 22.02,137.88 22.02,136.87 22.33,136.56 22.33,133.74 22.82,133.25 23.95,133.25 25.93,131.27 25.93,130.01 25.46,129.54 25.22,129.54 25.05,129.37 25.05,129.35
PCIE_PTX_NVRRX_N6_C: length 2.7
  TOP w0.102: U12.16 28.32,145.56 28.21,145.44 v1(28.21,144.97) 28.21,144.73 28,144.53 28,144.21 C640.1
PCIE_PTX_NVRRX_P6: length 41
  TOP w0.102: C641.2 27.68,142.85 27.8,142.72 27.8,142.37 27.6,142.17 v3(27.6,142.17) ; v1(36.33,122.31) 36.07,122.05 UH4.AV36
  IN3 w0.102: 24.8,129.35 24.81,129.34 24.81,128.21 26.1,126.92 26.1,126.4 26.11,126.39 26.11,126.05 25.73,125.67 25.73,124.98 26.24,124.47 26.24,123.33 26.03,123.12 26.03,121.28 26.43,120.87 31.57,120.87 32.42,121.72 35.49,121.72 35.53,121.76 35.75,121.76 36.29,122.29 36.29,122.3 36.3,122.31 v1(36.33,122.31)
  IN3 w0.127: v3(27.6,142.17) 27.6,141.83 27.45,141.69 26.9,141.69 23.72,138.5 22.29,138.5 21.77,137.99 21.77,136.77 22.08,136.45 22.08,133.63 22.72,133 23.85,133 25.68,131.16 25.68,130.11 25.36,129.79 25.11,129.79 24.8,129.48 24.8,129.35
PCIE_PTX_NVRRX_P6_C: length 2.7
  TOP w0.102: U12.15 27.82,145.61 27.99,145.44 27.99,145.25 27.98,145.24 27.98,144.81 27.79,144.62 27.79,144.18 C641.1
PCIE_PTX_WANRX_N1: length 141
  TOP w0.102: C597.1 100.8,155.91 101.16,155.91 101.37,155.71 v1(101.37,155.7) ; UH4.AV32 36.07,120.02 v3(36.33,120.28)
  IN1 w0.102: 16.89,129.18 16.9,129.17 16.91,129.17 16.96,129.12 16.98,129.12 17.36,128.74 19.33,128.74 20.46,127.61 22.86,127.61 23.11,127.35 23.11,127.25 23.13,127.23 23.13,125.3 23.6,124.83 23.81,124.83 24.12,124.52 24.12,123.99 24.57,123.54 24.89,123.54 25.29,123.14 25.29,121.23 26.34,120.19 26.8,120.19 27.3,119.69 28.79,119.69 29.52,118.96 35.34,118.96 36.21,119.83 36.21,120.16 v3(36.33,120.28)
  IN1 w0.117: 16.89,129.18 15.9,130.17 15.9,131.18 14.21,132.88 14.21,136.62 14.87,137.28 15.45,137.28 17.45,139.29 17.95,139.29 24.95,146.29 26.78,146.29 27.8,147.31 36.22,147.31 36.49,147.58 37.1,147.58 37.48,147.96 38.27,147.96 40.55,145.67 44.64,145.67 48.37,149.4 48.45,149.4 49.86,150.81 58.5,150.81 58.54,150.76 66.5,150.76 69.59,147.67 74.93,147.67 75.21,147.38 79.79,147.38 80.06,147.12 96.04,147.12 98.91,149.98 98.91,152.02 100.86,153.96 101.74,153.96 102.28,154.5 102.28,155.45 102.03,155.7 v1(101.37,155.7)
PCIE_PTX_WANRX_N1_C: length 2.7
  TOP w0.102: v1(98.46,155.68) 98.7,155.91 99.05,155.91 C597.2
  BOTTOM w0.102: JMINI1.31 98.7,155.45 v1(98.46,155.68)
PCIE_PTX_WANRX_P1: length 141
  TOP w0.102: v1(35.65,120.31) 35.63,120.31 35.38,120.06 UH4.AU32 ; C599.1 100.8,156.13 101.16,156.13 v3(101.37,156.34)
  IN1 w0.102: 17.06,129.35 17.45,128.96 19.42,128.96 20.55,127.83 22.95,127.83 23.33,127.45 23.33,125.41 23.69,125.05 23.91,125.05 24.34,124.61 24.34,124.08 24.66,123.76 24.98,123.76 25.51,123.23 25.51,121.32 26.43,120.41 26.89,120.41 27.4,119.91 28.89,119.91 29.61,119.18 35.25,119.18 35.99,119.92 35.99,120.03 35.71,120.31 v1(35.65,120.31)
  IN1 w0.117: 17.06,129.35 16.14,130.27 16.14,131.28 14.45,132.97 14.45,136.52 14.97,137.05 15.54,137.05 17.55,139.05 18.05,139.05 25.05,146.06 26.88,146.06 27.9,147.07 36.32,147.07 36.59,147.34 37.2,147.34 37.57,147.72 38.17,147.72 40.46,145.43 44.74,145.43 48.46,149.16 48.55,149.16 49.96,150.57 58.4,150.57 58.44,150.53 66.4,150.53 69.49,147.43 74.83,147.43 75.11,147.15 79.69,147.15 79.96,146.88 96.14,146.88 99.15,149.89 99.15,151.92 100.96,153.73 101.84,153.73 102.51,154.4 102.51,155.55 102.12,155.94 101.76,155.94 v3(101.37,156.34)
PCIE_PTX_WANRX_P1_C: length 2.7
  TOP w0.102: v3(98.46,156.35) 98.69,156.13 99.05,156.13 C599.2
  BOTTOM w0.102: JMINI1.33 98.57,156.25 v3(98.46,156.35)
PCIE_PTX_WLANRX_N2: length 235
  TOP w0.102: v1(182.37,135.16) 182.57,134.96 182.92,134.96 183.26,134.62 183.26,134.26 182.33,133.34 182.33,126.94 182.13,126.73 182.13,124.21 182.33,124 182.33,123.12 182.78,122.67 183.21,122.67 184.63,121.25 184.63,119.48 186.88,117.23 186.88,112.07 188.34,110.6 188.34,107.58 187.95,107.19 187.95,105.73 189.06,104.61 189.06,103.37 189.55,102.88 189.55,100.69 189.9,100.33 189.9,94.44 189.04,93.57 189.04,91.01 186.84,88.81 186.84,86.5 187.07,86.27 v1(187.11,86.27) ; v6(38.29,119.34) 38.29,119.53 UH4.BB32
  IN1 w0.102: v6(38.29,119.34) 38.16,119.22 38.16,119.11 38.34,118.94 39.94,118.94 40.17,118.71 40.76,118.71 41.44,118.03 41.44,116.97 42.04,116.37 42.04,113.89 42.26,113.67 42.77,113.15
  IN1 w0.117: 42.77,113.15 44.24,113.15 47.28,110.11 47.74,110.11 49.52,108.33 52.04,108.33 53.01,107.35 55.09,107.35 55.6,107.86 60.98,107.86 61.61,108.48 62.69,108.48 63.57,109.36 64.74,109.36 65.52,110.14 66.36,110.14 67.4,111.18 68,111.18 70.27,113.45 70.27,114.88 70.7,115.31 77.31,115.31 77.75,115.74 79.56,115.74 81.53,117.72 82.31,117.72 83.49,118.9 83.89,118.9 87.17,122.18 87.17,126.72 86.96,126.93 86.96,129.63 87.43,130.1 87.43,130.39 88.43,131.39 96.48,131.39 98.25,133.16 105.74,133.16 107.13,131.77 108.41,131.77 108.63,131.99 111.18,131.99 117.91,138.72 117.91,139.86 120.61,142.56 128.05,142.56 133.2,137.41 154.63,137.41 155.39,136.65 158.47,136.65 160.23,134.89 162.69,134.89 164.18,133.39 166.84,133.39 167.18,133.05 179.88,133.05 181.77,134.93 182.14,134.93 v1(182.37,135.16)
  BOTTOM w0.102: C596.1 186.9,86.56 186.9,86.48 v1(187.11,86.27)
PCIE_PTX_WLANRX_N2_C: length 2.8
  BOTTOM w0.102: JMINI2.31 187.09,89.21 186.8,88.92 186.8,88.42 C596.2
PCIE_PTX_WLANRX_P2: length 235
  TOP w0.102: UH4.AY32 37.37,119.62 v1(37.64,119.34) ; v1(186.47,86.27) 186.62,86.42 186.62,88.9 188.82,91.1 188.82,93.66 189.69,94.53 189.69,100.24 189.33,100.6 189.33,102.79 188.85,103.28 188.85,104.52 187.73,105.64 187.73,107.28 188.12,107.67 188.12,110.52 186.66,111.98 186.66,117.14 184.42,119.39 184.42,121.16 183.12,122.45 182.69,122.45 182.12,123.03 182.12,123.91 181.91,124.12 181.91,126.82 182.12,127.03 182.12,133.43 183.04,134.35 183.04,134.53 182.83,134.75 182.59,134.75 v3(182.37,134.53)
  IN1 w0.102: v1(37.64,119.34) 38.25,118.73 39.83,118.73 40.05,118.5 40.65,118.5 41.22,117.94 41.22,116.88 41.81,116.28 41.81,113.8 42.7,112.92 42.77,112.92
  IN1 w0.117: 42.77,112.92 44.14,112.92 47.18,109.88 47.64,109.88 49.42,108.09 51.94,108.09 52.91,107.12 55.19,107.12 55.7,107.63 61.08,107.63 61.7,108.25 62.79,108.25 63.67,109.12 64.84,109.12 65.62,109.9 66.46,109.9 67.49,110.94 68.1,110.94 70.51,113.35 70.51,114.78 70.8,115.07 77.41,115.07 77.85,115.51 79.65,115.51 81.63,117.48 82.41,117.48 83.59,118.66 83.99,118.66 87.41,122.08 87.41,126.82 87.2,127.03 87.2,129.53 87.67,130 87.67,130.29 88.53,131.15 96.58,131.15 98.35,132.92 105.64,132.92 107.03,131.53 108.51,131.53 108.72,131.75 111.28,131.75 118.15,138.62 118.15,139.76 120.7,142.32 127.95,142.32 133.1,137.18 154.53,137.18 155.29,136.41 158.38,136.41 160.14,134.65 162.59,134.65 164.09,133.15 166.74,133.15 167.08,132.81 179.98,132.81 181.87,134.7 182.2,134.7 v3(182.37,134.53)
  BOTTOM w0.102: C598.1 186.68,86.56 186.68,86.48 v1(186.47,86.27)
PCIE_PTX_WLANRX_P2_C: length 2.7
  BOTTOM w0.102: JMINI2.33 186.29,89.21 186.58,88.92 186.58,88.21 C598.2
PCIE_PTX_WPANRX_N5: length 196
  TOP w0.102: v3(184.91,160.92) 185.13,161.14 185.13,161.53 C636.1 ; v1(37.04,122.24) 37.04,122.01 37.24,121.8 UH4.AY36
  IN1 w0.102: v1(37.04,122.24) 37.25,122.45 37.25,122.68 37.44,122.87 40.47,122.87 41.62,121.73 41.62,119.58 42.03,119.16
  IN1 w0.117: v3(184.91,160.92) 185.13,160.7 185.13,158.42 183.22,156.51 172.48,156.51 171.15,155.19 168.48,155.19 167.75,154.46 166.56,154.46 166.01,155 164.01,155 162.03,153.02 158.13,153.02 157.75,152.64 156.4,152.64 154.78,151.01 154.78,149.78 153.68,148.68 151.39,148.68 150.48,149.59 146.54,149.59 146.36,149.41 129.98,149.41 128.61,150.77 118.03,150.77 116.32,152.49 113.52,152.49 111.14,150.11 111.14,145.22 108.66,142.74 108.66,139.46 104.86,135.66 98.67,135.66 95.87,132.86 87.59,132.86 85.87,131.14 85.87,130.62 85.11,129.85 85.11,127.78 81.11,123.79 81.11,122.12 82.23,121 82.23,119.73 81.96,119.46 81.19,119.46 78.95,117.21 70.46,117.21 67.56,114.32 67.56,113.11 67.15,112.7 66.78,112.7 65.69,111.61 63.62,111.61 62.04,110.03 49.93,110.03 48.38,111.58 47.91,111.58 45.45,114.03 45.45,115.08 42.43,118.1 42.43,118.77 42.03,119.16
PCIE_PTX_WPANRX_N5_C: length 2.8
  TOP w0.102: v1(184.95,163.66) 185.16,163.45 185.16,163.25 C636.2
  BOTTOM w0.102: v1(184.95,163.66) 185.2,163.92 185.2,164.06 185.04,164.22 JMINI3.31
PCIE_PTX_WPANRX_P5: length 196
  TOP w0.102: v1(185.55,160.92) 185.34,161.13 185.34,161.46 C626.1 ; UH4.BB36 37.96,121.8 37.67,122.09 v6(37.67,122.23)
  IN1 w0.102: v6(37.67,122.23) 37.47,122.44 37.47,122.59 37.53,122.65 40.38,122.65 41.4,121.64 41.4,119.49 41.8,119.08 41.8,119.07 41.87,119.01 41.87,119
  IN1 w0.117: 41.87,119 42.19,118.67 42.19,118 45.22,114.98 45.22,113.94 47.81,111.34 48.28,111.34 49.83,109.79 62.14,109.79 63.72,111.37 65.79,111.37 66.88,112.46 67.25,112.46 67.8,113.01 67.8,114.22 70.55,116.98 79.05,116.98 81.29,119.22 82.06,119.22 82.47,119.63 82.47,121.1 81.35,122.22 81.35,123.69 85.34,127.68 85.34,129.76 86.1,130.52 86.1,131.04 87.68,132.62 95.97,132.62 98.77,135.42 104.96,135.42 108.9,139.36 108.9,142.65 111.38,145.12 111.38,150.01 113.62,152.25 116.22,152.25 117.93,150.54 128.51,150.54 129.88,149.17 146.46,149.17 146.64,149.35 150.38,149.35 151.29,148.44 153.78,148.44 155.01,149.68 155.01,150.91 156.5,152.4 156.5,152.4 157.85,152.4 158.23,152.78 162.13,152.78 164.11,154.77 165.91,154.77 166.46,154.22 167.85,154.22 168.57,154.95 171.25,154.95 172.58,156.27 183.32,156.27 185.37,158.32 185.37,160.74 v1(185.55,160.92)
PCIE_PTX_WPANRX_P5_C: length 2.8
  TOP w0.102: C626.2 185.37,163.25 185.37,163.45 v1(185.58,163.66)
  BOTTOM w0.102: v1(185.58,163.66) 185.44,163.8 185.44,163.94 185.84,164.34 JMINI3.33
PCIE_SATA#: length 8
  TOP w0.102: U12.3 31.32,150.97 32,151.65 32.8,151.65 32.94,151.51 33.89,151.51 v2(34.27,151.89) 34.63,152.24 R785.2 35.66,151.93 35.01,151.28 Q322.3
PCIE_SATA_PRX_NVRTX_N6: length 17.2
  TOP w0.102: v3(21.72,155.51) 21.72,155.51 21.72,155.76 21.72,155.77 21.72,156.26 21.79,156.32 21.79,156.32 22.27,156.79 26.55,156.79 27.06,156.29 27.06,154.71 30.82,150.95 30.82,150.29 U12.4
  BOTTOM w0.102: v3(21.72,155.51) 21.91,155.69 21.91,156.33 21.64,156.6 JMINI4.23
PCIE_SATA_PRX_NVRTX_P6: length 17.3
  TOP w0.102: v1(22.59,155.51) 22.59,155.47 22.41,155.3 22.25,155.3 22.16,155.39 22.16,155.69 21.99,155.86 21.99,156.14 22.38,156.53 26.44,156.53 26.8,156.18 26.8,154.6 v1(27.94,153.45) 30.55,150.84 30.55,150.38 30.5,150.33 30.37,150.33 30.32,150.29 U12.5
  BOTTOM w0.102: JMINI4.25 22.44,156.6 22.17,156.33 22.17,155.93 v1(22.59,155.51)
PCIE_SATA_PTX_NVRRX_N6: length 15.2
  TOP w0.102: U12.6 29.82,150.2 29.73,150.29 29.73,150.74 25.83,154.64 23.96,154.64 23.6,155 23.6,155.5 23.82,155.73 24.42,155.73 24.51,155.64 24.51,155.07 24.38,154.94 24.14,154.94 24.06,155.02 v3(24.06,155.25)
  BOTTOM w0.102: JMINI4.31 24.84,156.76 25.13,156.46 25.13,156.21 25.02,156.1 24.74,156.1 24.4,155.75 24.4,155.55 24.09,155.25 v3(24.06,155.25)
PCIE_SATA_PTX_NVRRX_P6: length 15.2
  TOP w0.102: U12.7 29.32,150.17 29.46,150.31 29.46,150.63 v1(28.37,151.72) 25.72,154.37 23.85,154.37 23.33,154.89 23.33,155.61 23.71,155.99 24.53,155.99 24.78,155.75 24.78,155.4 v1(24.95,155.23)
  BOTTOM w0.102: JMINI4.33 25.64,156.81 25.4,156.57 25.4,156.1 25.13,155.83 24.85,155.83 24.66,155.64 24.66,155.51 v1(24.95,155.23)
PCIE_WAKE#: length 540.1
  TOP w0.102: R1972.2 208.55,159.18 v1(208.08,159.65) ; v1(163.5,143.51) 163.22,143.24 U54.B19 ; JIO1.52 v1(34.9,30.55)
  IN2 w0.127: v1(158.39,134.94) 158.34,134.94 158.27,134.86 157.5,134.86 156.3,136.07 154.85,136.07 153.08,137.83 151.61,137.83 150.75,136.97 115.3,136.97 114.21,138.06 108.62,138.06 107.1,139.59 106.72,139.59 105.81,140.49 104.9,140.49 104.33,141.06 100.96,141.06 100.72,140.82 100.72,139.94 100.86,139.8 v1(101.09,139.8) ; v1(212.74,105.78) 212.91,105.96 212.91,113.12 212.96,113.17 212.96,116.78 212.14,117.6 212.14,128.72 213,129.59 213,156.27 212.16,157.11 210.62,157.11 v1(208.08,159.65)
  IN3 w0.127: 206.22,102.93 206.22,103.44 204.84,104.83 203.92,104.83 203.27,104.18 202.44,104.18 201.62,103.36 201.62,101.94 201.72,101.84 201.72,101.26 201.97,101.01 201.97,100.3 202.07,100.19 202.07,97.37 201.99,97.28 201.99,96.99 201.73,96.73 201.72,96.73 201.38,96.39 201.38,96.28 200.73,95.62 198.55,95.62 197.81,94.88 197.81,94.36 197.18,93.73 197.18,90.2 197.12,90.14 197.12,85.03 198.32,83.82 198.32,79.32 197.6,78.6 197.6,63.68 198.6,62.68 v1(198.6,61.98) ; 206.22,102.93 207.78,102.93 208.88,104.03 208.88,104.9 208.79,104.99 208.79,105.84 209.17,106.22 209.9,106.22 210.35,106.67 211.85,106.67 v1(212.74,105.78) ; 206.22,102.93 206.22,96.49 204.28,94.55 204.28,94.43 204.08,94.23 204.08,94.21 204.06,94.14 204.06,94.13 204.06,93.82 204.06,93.82 204.06,93.78 204.39,93.45 204.39,92.19 203.35,91.15 202.43,91.15 201.47,92.11 v1(201.47,93.51) ; v1(184.81,148.83) 182.15,151.49 182.15,156.69 182.78,157.32 182.78,163.72 178.87,167.63 175.37,167.63 v1(174.92,167.17)
  IN4 w0.109: v1(34.9,30.55) 35.22,30.23 35.22,22.8 34.83,22.42 34.52,22.42 34.24,22.14 34.24,20.54 33.12,19.41 33.12,13.4 37.6,8.92 103.53,8.92 105.81,11.2 107.9,11.2 108.55,11.85 110.08,11.85 114.27,16.04 117.56,16.04 118.69,14.91 150.71,14.91 152.47,16.68 154.52,16.68 154.86,17.02 156.75,17.02 163.12,23.38 163.12,31.88 163.12,38.65 175.29,50.82 177.75,50.82 180.7,53.77 183.7,53.77 184.36,54.43 191.71,54.43 192.42,55.14 192.42,56.07 195.46,59.12 196.66,59.12 198.49,60.95 198.49,61.86 v1(198.6,61.98) ; v1(208.08,159.65) 208.08,159.78 206.91,160.94 206.91,163.83 205.91,164.83 201.33,164.83 199.95,163.45 198.39,163.45 195.96,165.88 179.28,165.88 177.58,167.58 175.32,167.58 v1(174.92,167.17) ; v1(163.5,143.51) 163.5,143.78 164.49,144.77 165.78,144.77 166.51,145.49 166.93,145.49 168.12,146.69 170.89,146.69 171.11,146.9 171.11,148.72 172.35,149.96 173.34,149.96 173.58,149.72 173.58,149.16 173.8,148.95 175.58,148.95 177.1,147.42 177.99,147.42 178.62,148.06 180.8,148.06 181.2,147.65 183.63,147.65 v1(184.81,148.83)
  BOTTOM w0.102: v1(201.47,93.51) 201.61,93.37 201.61,91.96 202.29,91.28 JMINI2.1 ; JMINI1.1 100.65,140.25 v1(101.09,139.8) ; v1(158.39,134.94) 158.39,134.99 158.48,135.08 158.48,135.71 v2(156.96,137.23) 156.61,137.58 156.61,138.63 156.74,138.76 157.72,138.76 158.22,139.26 R759.2 161.4,139.26 162.11,139.97 162.11,142.16 163.46,143.51 v1(163.5,143.51) ; JMINI3.1 169.84,166.04 170.37,166.57 170.96,166.57 171.8,167.41 174.67,167.41 v1(174.92,167.17)
PCIECLKRQ6#: length 12.6
  TOP w0.102: UH4.T13 25.21,110.63 24.9,110.33 24.79,110.33 24.75,110.36 v1(24.7,110.36)
  BOTTOM w0.102: RH101.2 15.1,110.3 15.89,109.51 v2(16.36,109.51) 17.98,109.51 18.54,108.94 21.03,108.94 21.37,109.27 21.37,109.62 21.6,109.86 23.01,109.86 23.18,110.02 23.84,110.02 23.99,109.87 24.29,109.87 24.7,110.27 v1(24.7,110.36)
PCLK_80H: length 209.2
  TOP w0.102: RH314.1 19.37,132.91 19.37,133.58 18.87,134.07 18.09,134.07 v2(18.05,134.12) 17.47,134.12 17.42,134.18 v1(17.38,134.18)
  IN1 w0.109: v1(17.38,134.18) 17.38,134.43 16.85,134.96 16.85,135.79 17.81,136.75 18.6,136.75 18.92,137.07 18.92,138.34 25.82,145.24 27.04,145.24 27.82,146.03 31.25,146.03 31.89,145.39 37.62,145.39 38,145.01 39.75,145.01 40.33,144.42 44.43,144.42 46.9,146.9 47.78,146.9 48.54,147.66 48.54,148.44 50.17,150.08 51.33,150.08 51.98,149.43 59.73,149.43 60.04,149.74 66.48,149.74 69.3,146.93 73.72,146.93 74.11,146.54 78.72,146.54 79.08,146.18 80.45,146.18 83.04,143.59 85.43,143.59 86.05,142.96 92.47,142.96 94.45,144.95 94.92,144.95 99.66,149.68 99.66,151.7 101.15,153.2 102.46,153.2 103.17,153.91 103.17,156.35 107.36,160.54 107.81,160.54 116.26,168.99 127.33,168.99 127.81,168.51 127.81,160.78 129.47,159.12 131.29,159.12 131.67,158.74 132.99,158.74 134.24,157.49 136.51,157.49 136.8,157.2 143.94,157.2 144.32,156.82 148.39,156.82 148.7,157.14 151.61,157.14 158.62,164.15 172.45,164.15 173.71,162.89 175.04,162.89 175.12,162.81 176.07,162.81 176.19,162.7 v1(180.21,162.7)
  BOTTOM w0.102: v1(180.21,162.7) 180.24,162.73 JMINI3.19
PECI_EC: length 178.9
  TOP w0.089: v1(67.33,73.88) 67.41,73.8 67.41,73.8 67.76,73.45 JCPU1.AN33
  TOP w0.102: v1(176.64,118.44) 177.54,119.34 v2(177.54,122.39) 177.54,129.86 177.81,130.12 177.81,131.29 177.65,131.46 177.65,132.64 176.91,133.38 v1(176.91,135.2) ; v1(177.32,152.6) 176.95,152.97 R863.2
  IN1 w0.109: v1(180.07,143.61) 180.07,145.49 178.56,147 178.56,150.52 178.05,151.03 178.05,151.87 v1(177.32,152.6)
  IN3 w0.127: v1(176.64,118.44) 167.79,118.44 167.21,117.86 163.9,117.86 159.59,113.54 120.57,113.54 119.67,112.64 119.65,112.64 118.08,111.06 97.56,111.06 87.24,100.75 83.95,100.75 81.06,97.86 77.75,97.86 76.49,96.61 73.2,96.61 70.52,93.93 70.52,91.92 68.26,89.66 68.26,88.81 67.65,88.2 67.65,87.43 v1(67.89,87.19)
  BOTTOM w0.102: v1(180.07,143.61) 178.89,142.43 178.89,140.89 177.68,139.69 177.68,137.2 176.88,136.4 176.88,135.23 v1(176.91,135.2) ; v1(67.89,87.19) 67.66,87.19 67.23,86.75 67.23,86.06 66.61,85.43 66.61,83.43 66.9,83.13 66.9,78.35 66.44,77.89 66.44,75.98 65.9,75.44 65.9,74.73 66.14,74.49 66.56,74.49 67.17,73.88 v1(67.33,73.88)
