# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS1: length 81.2
  TOP w0.089: JCPU1.F6 94.9,46.42 v3(94.4,45.92)
  TOP w0.14: v1(139.26,27.5) 139.3,27.53 139.3,27.71 139.22,27.79 139.03,27.79 138.71,28.11 138.71,28.49 138.98,28.77 140.33,28.77 140.6,28.49 140.6,28.35 140.7,28.25 140.98,28.25 141.08,28.35 141.08,28.61 141.38,28.9 JDIMM1.29
  IN1 w0.089: 101.4,40.12 101.4,42.78 100.6,43.58 100.36,43.58 99.41,44.53 99.41,44.54 98.85,45.1 97.99,45.1 97.39,45.71 97.2,45.71 96.59,46.33 94.5,46.33 94.41,46.42 94.33,46.42 94.21,46.29 94.21,46.12 v3(94.4,45.92)
  IN1 w0.147: v1(139.26,27.5) 139.45,27.68 139.45,27.86 139.31,28.01 137.08,28.01 134.68,25.61 132.49,25.61 131.74,24.86 128.27,24.86 127.97,25.16 126.9,25.16 126.45,24.71 113.51,24.71 109.56,28.66 100.69,28.66 99.6,29.75 99.6,32.47 99.19,32.87 99.19,37.22 101.26,39.28 101.26,39.98 101.4,40.12
  BOTTOM w0.14: v1(139.26,27.5) 139.43,27.5 139.56,27.37 139.56,27.14 139.43,27.01 137.51,27.01 136.77,27.75 136.77,28.29 136.51,28.56 136.51,28.77 136.38,28.9 JDIMM2.29
DDR_A_DQS2: length 70.4
  TOP w0.089: v3(97.4,49.93) 97.9,50.43 JCPU1.K3
  TOP w0.14: v1(139.57,32.74) 139.58,32.74 139.65,32.8 139.65,32.81 139.65,33.15 139.55,33.25 139.4,33.25 139.1,33.55 139.1,34 139.4,34.3 140.62,34.3 140.92,34 140.92,33.62 141.04,33.49 141.31,33.49 141.4,33.58 141.4,33.97 141.73,34.3 JDIMM1.47
  IN1 w0.089: v3(97.4,49.93) 97.41,49.92 97.77,49.92 97.87,49.81 97.87,49.59 98.13,49.33 98.62,49.33 98.81,49.13 98.81,48.5 99.03,48.27 99.9,48.27 100.2,47.97 100.76,47.97 101.87,46.86 101.87,44.91 103.41,43.37 103.41,42.36 104.49,41.28
  IN1 w0.147: 104.49,41.28 110.63,35.14 110.63,33.11 113.06,30.68 118.85,30.68 119.26,30.27 122.28,30.27 122.88,29.67 124.62,29.67 124.83,29.88 129.05,29.88 129.61,30.44 134.01,30.44 135.87,32.3 137.76,32.3 138.65,33.19 139.61,33.19 139.74,33.06 139.74,32.91 v1(139.57,32.74)
  BOTTOM w0.14: v1(139.57,32.74) 139.65,32.74 139.74,32.65 139.74,32.51 139.4,32.17 138.31,32.17 137.93,32.55 137.93,32.94 137.34,33.54 136.39,33.54 136.17,33.76 136.17,34.23 136.09,34.3 JDIMM2.47
DDR_A_DQS3: length 71.7
  TOP w0.089: JCPU1.N6 94.9,53.44 v3(94.39,52.93)
  TOP w0.14: v1(140.16,38.32) 140,38.48 140,38.77 139.71,39.07 138.35,39.07 138.04,38.76 136.53,38.76 135.89,39.4 JDIMM1.64
  IN1 w0.089: 104.49,47.19 104.18,47.51 104.18,47.71 102.7,49.18 102.7,49.94 102.71,49.95 102.71,50.95 101.12,52.53 94.4,52.53 94.32,52.62 94.32,52.86 v3(94.39,52.93)
  IN1 w0.147: v1(140.16,38.32) 140.12,38.37 140.12,38.98 139.82,39.28 138.45,39.28 138.02,38.85 138.02,38.45 137.54,37.97 136.17,37.97 134.66,36.46 131.67,36.46 130.7,35.49 130.5,35.49 130.38,35.6 130.38,35.71 130.1,36 129.51,36 129.22,35.71 129.22,35.45 129.09,35.32 128.67,35.32 128.54,35.45 128.54,35.71 128.26,36 127.64,36 127.35,35.71 127.35,35.41 127.23,35.28 123.86,35.28 123.15,36 120.69,36 120.25,36.44 115.25,36.44 104.49,47.19
  BOTTOM w0.14: JDIMM2.64 141.79,39.4 141.67,39.28 141.67,39.05 141.43,38.81 141.43,37.96 140.98,37.52 139.98,37.52 139.83,37.67 139.83,37.78 139.91,37.87 140.33,37.87 140.47,38.01 140.47,38.19 140.34,38.32 v1(140.16,38.32)
DDR_A_DQS4: length 68.4
  TOP w0.089: v3(96.4,70.92) 95.9,71.42 JCPU1.AL5
  TOP w0.14: JDIMM1.137 140.97,63.7 140.43,64.24 140.43,64.53 139.58,65.38 138.11,65.38 137.73,65 137.73,64.83 v1(137.5,64.6)
  IN1 w0.089: 101.17,74.52 101,74.36 100.12,74.36 99.98,74.21 99.98,73.67 99.63,73.32 98.22,73.32 98.01,73.11 98.01,72.61 97.74,72.33 97.21,72.33 97,72.13 97,71.62 96.7,71.31 96.21,71.31 95.86,70.95 95.86,70.73 95.99,70.6 96.28,70.6 96.4,70.73 v3(96.4,70.92)
  IN1 w0.147: v1(137.5,64.6) 137.59,64.68 137.59,64.82 137.18,65.22 136.7,65.22 136.42,64.94 135.96,64.94 132.81,68.09 130.11,68.09 121.71,76.49 116.3,76.49 116.14,76.33 115.23,76.33 115.07,76.49 109.95,76.49 109.26,75.8 103.12,75.8 103.01,75.69 103.01,74.86 102.72,74.57 102.13,74.57 101.84,74.86 101.84,75.89 101.72,76.02 101.35,76.02 101.22,75.89 101.22,74.57 101.17,74.52
  BOTTOM w0.14: JDIMM2.137 135.97,63.7 136.05,63.62 136.05,63.44 136.12,63.37 136.33,63.37 136.46,63.5 136.46,63.79 136.73,64.06 137.29,64.06 137.67,63.68 138.63,63.68 138.68,63.73 138.68,63.82 138.36,64.14 138.07,64.14 137.61,64.6 v1(137.5,64.6)
DDR_A_DQS5: length 71
  TOP w0.102: JCPU1.AM9 91.93,72.45 v1(92.4,72.92)
  TOP w0.14: v1(137.97,70.25) 138.43,69.79 138.43,69.62 138.35,69.53 137.25,69.53 136.94,69.84 136.42,69.84 136.16,69.58 136.16,68.79 136.05,68.67 135.95,68.67 135.82,68.8 JDIMM1.154
  IN1 w0.089: v1(92.4,72.92) 92.33,72.92 92.18,72.77 92.18,72.47 92.25,72.4 92.44,72.4 92.44,72.4 92.64,72.4 92.81,72.57 92.81,73.19 93.48,73.86 93.48,74.07 93.95,74.54 94.54,74.54 94.97,74.97 94.97,75.17 95.26,75.46 95.52,75.46 95.93,75.88 95.93,76.49 95.77,76.66 95.77,77.18 96.25,77.66 96.94,77.66 97.13,77.86 97.89,77.86 98.58,78.55
  IN1 w0.147: 98.58,78.55 99.99,79.96 107.43,79.96 109.93,82.47 115.03,82.47 116.35,81.15 122.93,81.15 127.84,76.25 128.44,76.25 132.44,72.25 134.54,72.25 137.02,69.77 138.19,69.77 138.31,69.89 138.31,70.03 138.09,70.25 v1(137.97,70.25)
  BOTTOM w0.14: v1(137.97,70.25) 138.29,70.57 138.29,70.59 138.69,70.99 140.06,70.99 142.25,68.8 JDIMM2.154
DDR_A_DQS6: length 78.9
  TOP w0.102: v1(89.4,74.94) 89.9,75.44 JCPU1.AR11
  TOP w0.14: JDIMM1.171 142.18,73.9 141.1,74.98 141.1,75.1 139.65,76.54 138.54,76.54 138.07,76.08 v1(138.07,75.67)
  IN1 w0.089: v1(89.4,74.94) 88.76,75.57 88.76,76.39 88.97,76.59 89.67,76.59 89.8,76.73 89.8,77.2 90.66,78.06 90.76,78.06
  IN1 w0.147: v1(138.07,75.67) 138.07,75.65 138.27,75.46 138.27,75.27 138.11,75.11 137.18,75.11 135.9,76.39 135.72,76.39 132.96,79.14 132.38,79.14 129.66,81.86 129.66,82.71 129.23,83.14 128.29,83.14 125.21,86.23 123.36,86.23 122.52,87.06 108.99,87.06 105.8,83.87 101.49,83.87 101.34,84.02 101.34,85.19 101.06,85.48 100.35,85.48 100.06,85.19 100.06,84.02 99.91,83.87 97.63,83.87 93.22,79.46 92.77,79.46 91.86,78.54 91.25,78.54 90.76,78.06
  BOTTOM w0.14: v1(138.07,75.67) 138.56,75.18 138.75,75.18 138.83,75.1 138.83,74.7 138.78,74.65 137.73,74.65 137.3,75.08 136.87,75.08 136.37,74.59 136.37,73.81 136.2,73.64 136.01,73.64 135.96,73.69 135.96,73.81 135.88,73.9 JDIMM2.171
DDR_A_DQS7: length 91.3
  TOP w0.089: v1(86.4,72.96) 86.9,72.46 JCPU1.AM14
  TOP w0.14: JDIMM1.188 135.78,79 136.02,78.77 136.15,78.77 136.26,78.87 136.26,79.45 136.76,79.95 137.62,79.95 137.78,79.78 138.92,79.78 139,79.86 139,80.07 138.94,80.14 138.49,80.14 138.35,80.28 138.35,80.44 138.51,80.6 v1(138.6,80.6)
  IN1 w0.089: v1(86.4,72.96) 86.4,72.94 86.28,72.81 86.03,72.81 85.81,73.03 85.81,73.17 85.47,73.51 85.07,73.51 85,73.58 85,77.32 85.22,77.54 85.22,77.74 85.8,78.32
  IN1 w0.147: v1(138.6,80.6) 138.82,80.83 138.82,81.03 138.75,81.1 136.11,81.1 135.35,81.86 135.35,83.17 135.47,83.29 135.47,84.39 133.12,86.73 131.77,86.73 129.71,88.79 129.71,89.57 128.88,90.4 127.75,91.52 122.07,91.52 121.54,92.05 114.36,92.05 114.05,92.36 114.05,92.68 113.92,92.8 113.44,92.8 113.31,92.68 113.31,92.34 113.03,92.05 112.32,92.05 112.03,92.34 112.03,92.68 111.9,92.8 111.42,92.8 111.29,92.68 111.29,92.36 110.98,92.05 110.31,92.05 110.01,92.36 110.01,93.2 109.21,94 100.56,94 96.99,90.42 96.99,89.55 85.8,78.36 85.8,78.32
  BOTTOM w0.14: JDIMM2.188 142.04,79 141.87,79.17 141.87,79.64 140.97,80.54 140.97,80.85 140.27,81.55 139.24,81.55 138.8,81.11 138.8,80.8 v1(138.6,80.6)
DDR_A_DQS#0: length 78.4
  TOP w0.102: JCPU1.C4 96.9,43.45 v1(96.4,42.96)
  TOP w0.14: v1(139.38,22.64) 139.24,22.49 139.24,22.16 138.94,21.86 137.49,21.86 136.15,23.2 JDIMM1.10
  IN1 w0.089: v1(96.4,42.96) 96.4,43.09 96.62,43.31 96.76,43.31 96.8,43.26 96.8,41.25 96.32,40.77 96.32,39.89 96.29,39.86
  IN1 w0.147: 96.29,39.86 94.36,37.94 94.36,36.07 94.15,35.85 94.15,27.84 97.38,24.61 105.92,24.61 107.06,23.46 108.91,23.46 111.85,20.52 121.75,20.52 121.99,20.28 123.7,20.28 123.74,20.25 134.91,20.25 136.57,21.91 138.74,21.91 138.98,22.15 138.98,22.23 v1(139.38,22.64)
  BOTTOM w0.14: JDIMM2.10 142.11,23.2 142.02,23.11 142.02,22.99 141.95,22.91 141.79,22.91 141.72,22.99 141.72,23.14 141.66,23.2 141.53,23.2 141.1,22.77 140.66,22.77 140.24,23.19 139.19,23.19 138.99,22.99 138.99,22.9 139.25,22.64 v1(139.38,22.64)
DDR_A_DQS#1: length 81.3
  TOP w0.089: JCPU1.G6 94.9,47.44 v1(94.4,46.94)
  TOP w0.14: JDIMM1.27 142.04,28.3 141.97,28.37 141.97,28.52 141.89,28.61 141.5,28.61 141.37,28.49 141.37,28.23 141.1,27.95 140.58,27.95 140.31,28.23 140.31,28.37 140.21,28.47 139.1,28.47 139,28.37 139,28.19 139.11,28.08 139.34,28.08 139.69,27.74 139.69,27.66 139.85,27.5 v1(140.02,27.5)
  IN1 w0.089: 101.59,39.93 101.6,39.94 101.6,39.98 101.64,40.02 101.64,40.22 101.61,40.25 101.61,42.87 100.69,43.79 100.45,43.79 99.64,44.6 99.64,44.64 98.93,45.34 98.08,45.34 97.48,45.94 97.31,45.94 96.7,46.54 94.59,46.54 94.4,46.73 v1(94.4,46.94)
  IN1 w0.147: v1(140.02,27.5) 139.72,27.8 139.72,27.98 139.42,28.28 136.97,28.28 134.57,25.88 132.37,25.88 131.63,25.14 128.38,25.14 128.09,25.43 126.79,25.43 126.34,24.99 113.62,24.99 109.68,28.93 100.81,28.93 99.87,29.87 99.87,32.58 99.46,32.99 99.46,37.11 101.53,39.17 101.53,39.87 101.59,39.93
  BOTTOM w0.14: JDIMM2.27 136.36,28.3 136.48,28.17 136.48,27.63 137.39,26.72 139.55,26.72 139.85,27.02 139.85,27.28 140.02,27.45 v1(140.02,27.5)
DDR_A_DQS#2: length 70.4
  TOP w0.089: v1(98.4,49.94) 97.92,49.45 JCPU1.J3
  TOP w0.14: JDIMM1.45 142.1,33.7 142.04,33.77 142.04,33.87 141.94,33.97 141.81,33.97 141.69,33.85 141.69,33.46 141.43,33.2 140.92,33.2 140.63,33.5 140.63,33.88 140.5,34 139.52,34 139.39,33.88 139.39,33.67 139.52,33.54 139.67,33.54 139.94,33.27 139.94,33 140.02,32.92 140.02,32.8 140.08,32.74 v1(140.33,32.74)
  IN1 w0.089: v1(98.4,49.94) 98.19,49.94 98.1,49.85 98.1,49.69 98.25,49.53 98.74,49.53 99,49.27 99,48.63 99.13,48.5 99.99,48.5 100.3,48.2 100.86,48.2 102.09,46.97 102.09,45 103.63,43.46 103.63,42.53 104.49,41.66
  IN1 w0.147: 104.49,41.66 110.91,35.25 110.91,33.22 113.18,30.95 118.96,30.95 119.37,30.54 122.39,30.54 122.99,29.94 124.5,29.94 124.71,30.15 128.94,30.15 129.5,30.71 133.9,30.71 135.76,32.57 137.65,32.57 138.54,33.47 139.72,33.47 140.01,33.18 140.01,32.93 140.21,32.74 v1(140.33,32.74)
  BOTTOM w0.14: v1(140.33,32.74) 140.33,32.69 139.52,31.88 138.19,31.88 137.64,32.43 137.64,32.82 137.22,33.25 136.27,33.25 135.82,33.7 JDIMM2.45
DDR_A_DQS#3: length 71.1
  TOP w0.089: v1(94.39,51.93) 94.9,52.43 JCPU1.M6
  TOP w0.14: v1(139.4,38.32) 139.59,38.32 139.71,38.44 139.71,38.65 139.59,38.78 138.47,38.78 138.17,38.47 136.41,38.47 136.08,38.8 JDIMM1.62
  IN1 w0.089: 104.49,46.81 103.97,47.34 103.97,47.62 102.49,49.09 102.49,49.94 102.48,49.95 102.48,50.85 101,52.33 94.16,52.33 94.04,52.21 94.04,52.07 94.19,51.93 v1(94.39,51.93)
  IN1 w0.147: v1(139.4,38.32) 139.5,38.32 139.84,38.66 139.84,38.87 139.71,39 138.57,39 138.3,38.73 138.3,38.34 137.65,37.69 136.29,37.69 134.78,36.18 131.78,36.18 130.82,35.22 130.38,35.22 130.11,35.49 130.11,35.6 129.98,35.72 129.62,35.72 129.5,35.6 129.5,35.33 129.21,35.04 128.56,35.04 128.27,35.33 128.27,35.6 128.14,35.72 127.76,35.72 127.63,35.6 127.63,35.29 127.34,35 123.75,35 123.03,35.72 120.58,35.72 120.13,36.17 115.13,36.17 104.49,46.81
  BOTTOM w0.14: v1(139.4,38.32) 139.53,38.19 139.53,37.5 139.81,37.22 141.13,37.22 141.73,37.82 141.73,38.65 141.88,38.8 JDIMM2.62
DDR_A_DQS#4: length 68.2
  TOP w0.089: JCPU1.AL6 94.9,71.42 v1(95.4,70.92)
  TOP w0.14: JDIMM1.135 141.97,63.1 141.9,63.18 141.9,63.35 141.84,63.41 140.9,63.41 140.14,64.17 140.14,64.41 139.46,65.09 138.25,65.09 138.02,64.86 138.02,64.72 138.15,64.6 v1(138.27,64.6)
  IN1 w0.089: 100.97,74.7 100.97,74.67 100.87,74.57 100.03,74.57 99.76,74.3 99.76,73.76 99.53,73.52 98.12,73.52 97.81,73.21 97.81,72.73 97.6,72.52 97.09,72.52 96.8,72.23 96.8,71.72 96.79,71.71 96.59,71.51 96.11,71.51 95.52,70.92 v1(95.4,70.92)
  IN1 w0.147: 100.97,74.7 100.95,74.72 100.95,76 101.23,76.29 101.83,76.29 102.12,76 102.12,74.97 102.25,74.85 102.6,74.85 102.73,74.97 102.73,75.8 103,76.08 109.15,76.08 109.84,76.77 115.18,76.77 115.34,76.61 116.03,76.61 116.19,76.77 121.82,76.77 130.22,68.36 132.93,68.36 136.08,65.21 136.31,65.21 136.59,65.5 137.29,65.5 138.2,64.6 v1(138.27,64.6)
  BOTTOM w0.14: JDIMM2.135 136.47,63.1 136.75,63.38 136.75,63.67 136.85,63.77 137.2,63.77 137.58,63.39 138.81,63.39 138.99,63.56 138.99,63.9 138.29,64.6 v1(138.27,64.6)
DDR_A_DQS#5: length 71.3
  TOP w0.102: JCPU1.AM8 92.9,72.42 v1(92.4,71.92)
  TOP w0.14: JDIMM1.152 135.99,68.2 136.46,68.67 136.46,69.46 136.58,69.59 136.8,69.59 137.15,69.24 138.47,69.24 138.75,69.52 138.75,70.23 v1(138.73,70.25)
  IN1 w0.089: 98.97,78.55 98.06,77.64 97.22,77.64 97.01,77.43 96.34,77.43 96,77.09 96,76.75 96.16,76.58 96.16,75.78 95.63,75.25 95.35,75.25 95.2,75.1 95.2,74.87 94.66,74.33 94.07,74.33 93.71,73.97 93.71,73.77 93.64,73.7 93.26,73.32 93.03,73.08 93.03,72.48 92.73,72.19 92.49,72.19 92.4,72.1 v1(92.4,71.92)
  IN1 w0.147: 98.97,78.55 100.11,79.69 107.54,79.69 110.05,82.19 114.92,82.19 116.23,80.88 122.82,80.88 127.72,75.97 128.33,75.97 132.33,71.98 134.43,71.98 136.9,69.5 138.3,69.5 138.58,69.77 138.58,70.1 v1(138.73,70.25)
  BOTTOM w0.14: v1(138.73,70.25) 138.58,70.4 138.58,70.47 138.81,70.7 139.94,70.7 141.79,68.85 141.79,68.63 141.73,68.57 141.62,68.57 141.55,68.5 141.55,68.4 141.76,68.2 JDIMM2.152
DDR_A_DQS#6: length 78.9
  TOP w0.102: v3(89.4,75.96) 88.9,75.46 JCPU1.AR12
  TOP w0.14: v1(138.75,75.67) 138.71,75.67 138.44,75.93 138.44,76.04 138.66,76.25 139.53,76.25 140.8,74.97 140.8,74.86 141.74,73.92 141.74,73.47 141.91,73.3 JDIMM1.169
  IN1 w0.089: v3(89.4,75.96) 89.4,75.66 89.32,75.58 89.09,75.58 88.96,75.71 88.96,76.28 89.07,76.39 89.77,76.39 90.01,76.63 90.01,77.1 90.4,77.49 90.55,77.49 91.13,78.07
  IN1 w0.147: v1(138.75,75.67) 138.54,75.46 138.54,75.16 138.22,74.84 137.06,74.84 135.79,76.11 135.6,76.11 132.85,78.86 132.27,78.86 129.38,81.75 129.38,82.6 129.12,82.87 128.18,82.87 125.09,85.95 123.24,85.95 122.41,86.78 109.1,86.78 105.91,83.6 101.38,83.6 101.07,83.91 101.07,85.08 100.94,85.2 100.46,85.2 100.33,85.08 100.33,83.91 100.02,83.6 97.74,83.6 93.33,79.19 92.89,79.19 91.97,78.27 91.33,78.27 91.13,78.07
  BOTTOM w0.14: v1(138.75,75.67) 138.75,75.6 139.13,75.22 139.13,74.55 138.97,74.4 137.57,74.4 137.18,74.79 136.99,74.79 136.68,74.48 136.68,73.64 136.34,73.3 JDIMM2.169
DDR_A_DQS#7: length 91.1
  TOP w0.089: v3(85.41,72.91) 85.47,72.91 85.9,72.47 JCPU1.AM15
  TOP w0.14: v1(139.36,80.6) 139.29,80.53 139.29,79.74 139.04,79.49 137.66,79.49 137.49,79.65 136.88,79.65 136.55,79.32 136.55,78.75 136.2,78.4 JDIMM1.186
  IN1 w0.089: 85.54,78.45 84.97,77.88 84.97,77.61 84.79,77.44 84.79,73.48 84.98,73.29 85.38,73.29 85.53,73.14 85.53,73.03 v3(85.41,72.91)
  IN1 w0.147: v1(139.36,80.6) 139.1,80.86 139.1,81.15 138.87,81.38 136.23,81.38 135.63,81.98 135.63,83.06 135.74,83.17 135.74,84.5 133.23,87.01 131.88,87.01 129.98,88.9 129.98,89.68 129.15,90.51 127.87,91.8 122.18,91.8 121.66,92.33 114.47,92.33 114.32,92.47 114.32,92.79 114.04,93.08 113.33,93.08 113.04,92.79 113.04,92.45 112.91,92.33 112.43,92.33 112.3,92.45 112.3,92.79 112.02,93.08 111.3,93.08 111.02,92.79 111.02,92.47 110.87,92.33 110.43,92.33 110.28,92.47 110.28,93.32 109.32,94.27 100.45,94.27 96.71,90.54 96.71,89.66 85.54,78.49 85.54,78.45
  BOTTOM w0.14: JDIMM2.186 142.22,78.4 141.62,79.01 141.62,79.48 140.69,80.41 140.69,80.71 140.15,81.26 139.36,81.26 139.13,81.02 139.13,80.73 139.26,80.6 v1(139.36,80.6)
DDR_A_MA0: length 70.4
  TOP w0.089: v1(91.39,63.95) 90.9,64.44 JCPU1.AD10
  TOP w0.102: v1(140.94,50.78) 140,51.71 136.22,51.71 135.93,52 JDIMM1.98
  IN1 w0.089: 104.49,60.62 101.35,60.62 100.64,61.33 100.3,61.33 99.94,60.97 99.94,60.89 99.57,60.52 99.14,60.52 98.76,60.14 98.76,59.86 98.41,59.52 97.24,59.52 96.89,59.87 96.89,60 96.57,60.32 96.24,60.32 95.81,59.89 95.81,59.76 95.57,59.52 95.24,59.52 94.92,59.84 94.92,59.96 94.36,60.52 93.26,60.52 92.82,60.96 92.82,62.06 92.37,62.52 92.24,62.52 92,62.76 92,63.12 91.39,63.72 v1(91.39,63.95)
  IN1 w0.267: 104.49,60.62 112.85,60.62 117.65,55.82 118.79,55.82 118.98,55.82 120.39,54.41 121.47,54.41 122.6,53.29 123.71,52.17 125.11,52.17 125.62,51.66 129.76,51.66 130.28,52.17 133.05,52.17 133.32,51.9 139.9,51.9 140.94,50.87 v1(140.94,50.78)
  BOTTOM w0.102: v1(140.94,50.78) 140.94,51.19 140.81,51.32 140.56,51.32 140.44,51.45 140.44,51.75 140.56,51.87 141.53,51.87 141.65,52 JDIMM2.98
DDR_A_MA1: length 69.5
  TOP w0.089: v3(100.4,59.92) 99.93,59.45 JCPU1.W1
  TOP w0.102: JDIMM1.97 141.98,51.7 141.73,51.95 141.26,51.95 141.06,51.76 141.06,51.3 141.41,50.95 141.41,50.65 141.12,50.35 138.85,50.35 138.77,50.43 138.74,50.43 v1(138.4,50.78)
  IN1 w0.089: v3(100.4,59.92) 100.58,60.09 100.75,60.09 100.87,59.97 100.87,59.8 101,59.67 101.54,59.67 101.91,59.29 101.91,59.06 102.14,58.84 102.34,58.84 102.41,58.92 102.41,59.2 102.54,59.32 102.66,59.32 102.78,59.2 102.78,58.94 102.91,58.81 103.09,58.81 103.21,58.94 103.21,59.16 103.33,59.27 103.49,59.27 103.6,59.16 103.6,58.83 103.46,58.68 103.46,58.58 103.56,58.48 103.8,58.48 103.91,58.59 103.91,59.09 103.96,59.14 104.21,59.14 104.42,58.94 104.49,58.94
  IN1 w0.267: 104.49,58.94 107.78,58.94 108.86,57.86 113.24,57.86 113.64,57.46 113.64,56.82 114.07,56.39 114.71,56.39 115.14,55.96 115.14,55.31 115.48,54.97 116.07,54.97 116.28,54.76 116.28,54.29 116.43,54.15 118.29,54.15 119.97,52.46 120.24,52.46 120.5,52.72 120.71,52.72 120.95,52.48 120.95,52.16 121.15,51.96 121.51,51.96 121.7,51.77 121.7,50.87 121.53,50.71 121.53,50.33 121.9,49.96 122.2,49.96 122.6,50.36 123.52,50.36 123.65,50.23 123.65,48.96 123.77,48.83 124.46,48.83 124.59,48.96 124.59,49.71 124.71,49.84 125.3,49.84 125.42,49.71 125.42,48.63 125.55,48.5 126.1,48.5 126.22,48.63 126.22,49.71 126.35,49.84 127.16,49.84 127.29,49.71 127.29,48.58 127.42,48.45 127.99,48.45 128.12,48.58 128.12,48.83 128.24,48.96 128.88,48.96 129.01,48.83 129.01,48.58 129.13,48.45 129.81,48.45 129.94,48.58 129.94,48.86 130.06,48.98 132.07,48.98 133.07,49.98 134.71,49.98 134.96,50.22 137.64,50.22 137.68,50.27 137.97,50.27 138.4,50.69 v1(138.4,50.78)
  BOTTOM w0.102: JDIMM2.97 136.06,51.7 136.1,51.75 136.1,51.89 136.2,51.99 139.17,51.99 139.29,51.86 139.29,51.63 139.17,51.5 138.52,51.5 138.4,51.37 v1(138.4,50.78)
DDR_A_MA2: length 68.7
  TOP w0.089: v1(99.4,59.92) 98.93,59.45 JCPU1.W2
  TOP w0.102: JDIMM1.96 135.9,51.4 136.09,51.21 139.23,51.21 v1(139.67,50.78)
  IN1 w0.089: v1(99.4,59.92) 99.18,59.7 98.99,59.7 98.94,59.75 98.94,60.06 99.21,60.34 99.65,60.34 99.91,60.6 100.23,60.6 100.3,60.53 101.07,60.53 101.17,60.43 101.17,60.24 101.36,60.06 101.67,60.06 101.76,60.15 101.76,60.34 101.85,60.42 102.03,60.42 102.12,60.34 102.12,59.81 102.22,59.71 102.37,59.71 102.47,59.81 102.47,60.34 102.56,60.42 102.74,60.42 102.83,60.34 102.83,59.8 102.93,59.7 103.08,59.7 103.18,59.8 103.18,60.34 103.27,60.42 103.45,60.42 103.54,60.34 103.54,59.83 103.67,59.7 103.78,59.7 103.9,59.83 103.9,60.27 104.01,60.38 104.17,60.38 104.28,60.27 104.28,60.19 104.41,60.06 104.49,60.06
  IN1 w0.267: v1(139.67,50.78) 139.73,50.84 139.73,51.21 139.6,51.34 134.38,51.34 134.13,51.09 133.34,51.09 133.1,51.34 133.09,51.34 132.82,51.61 131.44,51.61 131.31,51.49 131.31,50.23 131.19,50.1 130.45,50.1 130.32,50.23 130.32,50.72 130.19,50.85 129.6,50.85 129.47,50.72 129.47,50.31 129.34,50.19 128.66,50.19 128.54,50.31 128.54,50.96 128.41,51.09 124.56,51.09 124.04,51.61 123.48,51.61 122.07,53.02 121.24,53.85 120.16,53.85 118.75,55.26 117.42,55.26 113.65,59.03 113.24,59.03 113.07,59.2 113.07,59.61 112.62,60.06 112.25,60.06 112.12,59.93 112.12,59.11 111.99,58.98 111.27,58.98 111.15,59.11 111.15,59.93 111.02,60.06 110.24,60.06 110.12,59.93 110.12,59.11 109.99,58.98 109.36,58.98 109.23,59.11 109.23,59.93 109.11,60.06 104.49,60.06
  BOTTOM w0.102: JDIMM2.96 141.65,51.4 141.53,51.27 141.53,50.39 141.4,50.27 139.72,50.27 139.6,50.39 139.6,50.71 v1(139.67,50.78)
DDR_A_MA3: length 74.2
  TOP w0.089: JCPU1.W7 93.88,59.45 v3(93.4,59.92)
  TOP w0.102: v1(137.13,50.78) 137.95,49.95 141.28,49.95 141.86,50.53 141.86,50.69 142.27,51.1 JDIMM1.95
  IN1 w0.089: 104.49,59.5 101.95,59.5 101.61,59.85 101.3,59.85 100.83,60.32 100.24,60.32 99.88,59.96 99.88,59.83 99.57,59.52 99.18,59.52 99,59.34 97.04,59.34 96.87,59.51 95.86,59.51 95.69,59.34 92.13,59.34 92,59.47 92,59.86 91.87,59.98 89.68,59.98 89.55,60.11 89.55,60.9 89.66,61.01 90.1,61.01 90.19,60.92 90.19,60.54 90.24,60.49 92.98,60.49 93.4,60.06 v3(93.4,59.92)
  IN1 w0.267: 104.49,59.5 108.01,59.5 109.09,58.42 113.47,58.42 117.19,54.71 118.52,54.71 119.93,53.3 121.01,53.3 122.44,51.86 122.44,51.32 122.71,51.05 123.81,51.05 124.33,50.53 127.77,50.53 127.94,50.36 127.94,49.64 128.05,49.54 131.77,49.54 131.9,49.67 131.9,50.41 132.03,50.53 134.37,50.53 134.61,50.78 v1(137.13,50.78)
  BOTTOM w0.102: JDIMM2.95 135.96,51.1 136.09,50.97 136.09,50.42 136.22,50.29 136.41,50.29 136.54,50.42 136.54,51.47 136.66,51.59 137.88,51.59 138,51.47 138,51.32 137.9,51.22 137.39,51.22 137.13,50.96 v1(137.13,50.78)
DDR_A_MA4: length 68.5
  TOP w0.089: v1(98.39,58.91) 97.93,58.45 JCPU1.V3
  TOP w0.102: JDIMM1.92 137.1,50.2 137.82,49.48 138.55,49.48 138.66,49.37 140.47,49.37 v1(140.96,48.88)
  IN1 w0.089: 104.28,58.38 104.26,58.38 104.15,58.27 104.11,58.23 103.48,58.23 103.35,58.23 103,58.58 102.05,58.58 101.62,59.01 101.62,59.15 101.28,59.49 99.81,59.49 99.66,59.34 99.25,59.34 98.99,59.08 98.56,59.08 v1(98.39,58.91)
  IN1 w0.267: 104.28,58.38 107.55,58.38 108.63,57.3 112.36,57.3 116.09,53.57 118.05,53.57 119.81,51.82 119.81,51.2 121.63,49.38 122.36,49.38 123.47,48.27 124.14,48.27 124.62,47.79 130.22,47.79 130.86,48.42 132.31,48.42 133.3,49.42 134.94,49.42 135.19,49.66 137.87,49.66 137.91,49.71 138.21,49.71 138.65,50.15 144.53,50.15 144.65,50.03 144.65,49.01 144.53,48.88 v1(140.96,48.88)
  BOTTOM w0.102: JDIMM2.92 141.93,50.2 141.53,49.8 140.89,49.8 140.77,49.67 140.77,49.01 140.89,48.88 v1(140.96,48.88)
DDR_A_MA5: length 70.3
  TOP w0.089: v3(99.39,58.91) 99.38,58.92 98.91,58.45 JCPU1.V2
  TOP w0.102: v1(139.69,48.88) 139.69,48.55 139.92,48.32 140.21,48.32 140.33,48.44 140.67,48.44 140.79,48.32 141.02,48.32 141.48,48.78 141.48,49.16 141.43,49.21 141.31,49.21 141.2,49.31 141.2,49.46 141.27,49.53 141.83,49.53 141.88,49.58 141.88,49.77 142.01,49.9 JDIMM1.91
  IN1 w0.089: v3(99.39,58.91) 99.38,58.9 99.03,58.9 98.91,58.78 98.91,58.62 98.84,58.56 98.59,58.56 98.5,58.47 98.5,58.34 98.59,58.25 99.05,58.25 99.17,58.37 99.17,58.47 99.21,58.51 99.52,58.51 99.57,58.46 99.57,58.29 99.61,58.25 100.18,58.25 100.27,58.35 100.27,58.48 100.18,58.58 99.92,58.58 99.83,58.67 99.83,58.78 99.97,58.92 99.97,58.99 99.83,59.13 99.83,59.23 99.91,59.31 101.21,59.31 101.45,59.07 101.45,58.71 101.5,58.66 101.7,58.66 101.79,58.57 101.79,58.45 101.7,58.36 101.45,58.36 101.35,58.27 101.35,58.14 101.45,58.04 101.94,58.04 101.98,58.08 101.98,58.31 102.03,58.36 102.18,58.36 102.23,58.31 102.23,57.67 102.32,57.58 102.5,57.58 102.58,57.67 102.58,58.25 102.69,58.36 102.84,58.36 102.94,58.25 102.94,57.67 103.03,57.58 103.21,57.58 103.3,57.67 103.3,57.95 103.38,58.04 103.56,58.04 103.65,57.95 103.65,57.67 103.74,57.58 103.92,57.58 103.99,57.65 103.99,57.87 104.04,57.93 104.39,57.93 104.49,57.82
  IN1 w0.267: 104.49,57.82 107.32,57.82 108.4,56.74 112.13,56.74 116.36,52.52 116.81,52.52 117.18,52.89 117.93,52.89 119.16,51.65 119.16,51.05 121.42,48.79 122.01,48.79 122.27,48.53 122.27,47.94 122.5,47.71 123.91,47.71 124.39,47.23 130.45,47.23 131.09,47.87 132.54,47.87 133.53,48.86 135.17,48.86 135.42,49.1 138.15,49.1 138.18,49.14 138.33,49.14 138.34,49.15 138.85,49.15 138.96,49.26 138.96,49.42 139.14,49.59 139.75,49.59 139.9,49.44 139.9,49.24 139.69,49.02 v1(139.69,48.88)
  BOTTOM w0.102: JDIMM2.91 136.32,49.9 136.88,49.34 137.13,49.34 137.26,49.47 137.26,49.72 137.39,49.85 137.9,49.85 138.02,49.72 138.02,49.47 138.15,49.34 138.53,49.34 138.66,49.47 138.66,49.72 138.78,49.85 139.42,49.85 139.69,49.58 v1(139.69,48.88)
DDR_A_MA6: length 72
  TOP w0.089: v3(97.4,58.91) 97.87,58.91 97.99,59.04 97.99,59.08 98.02,59.1 98.02,59.33 JCPU1.W3
  TOP w0.102: JDIMM1.90 136.05,49.6 136.18,49.47 136.18,48.59 136.31,48.46 136.55,48.46 136.68,48.59 136.68,49.49 136.8,49.62 137.05,49.62 137.17,49.49 137.17,49.17 137.3,49.05 138.29,49.05 138.42,48.92 v1(138.42,48.58)
  IN1 w0.089: 104.16,56.7 103.81,56.35 103.81,55.83 103.67,55.7 103.46,55.7 103.36,55.79 103.36,56.32 103.31,56.38 103.1,56.38 102.98,56.25 102.98,55.69 102.86,55.58 102.7,55.58 102.59,55.69 102.59,56.32 102.5,56.41 102.41,56.41 102.32,56.5 102.32,56.68 102.41,56.77 102.5,56.77 102.59,56.86 102.59,57.04 102.5,57.12 102.03,57.12 101.57,57.58 101.4,57.58 100.93,58.05 98.4,58.05 97.97,58.49 97.97,59.02 97.84,59.14 97.53,59.14 97.4,59.02 v3(97.4,58.91)
  IN1 w0.267: v1(138.42,48.58) 138.55,48.44 138.55,48.35 138.84,48.06 139.27,48.06 139.53,48.32 140.1,48.32 140.4,48.02 140.4,47.72 140.18,47.5 140.18,47.5 140.05,47.37 139.91,47.37 139.9,47.39 139.43,47.39 139.42,47.37 138.74,47.37 138.16,47.95 135.85,47.95 135.64,47.74 133.99,47.74 133,46.75 131.55,46.75 130.92,46.11 129.14,46.11 128.66,45.63 123.92,45.63 123.55,45.99 121.89,45.99 121.64,46.25 121.64,46.42 121.51,46.55 120.75,46.55 118.03,49.26 116.71,49.26 116.09,49.89 116.09,50.57 115.92,50.74 115.42,50.74 115.16,50.99 115.16,50.99 115.16,51.19 115.44,51.48 115.44,51.85 115.28,52.02 114.66,52.02 114.5,52.17 114.5,52.79 111.81,55.48 111.42,55.48 111.15,55.21 110.84,55.21 110.43,55.63 107.93,55.63 106.86,56.7 104.16,56.7
  BOTTOM w0.102: JDIMM2.90 141.97,49.6 141.58,49.21 141.58,48.58 141.15,48.15 138.86,48.15 138.43,48.58 v1(138.42,48.58)
DDR_A_MA7: length 69.7
  TOP w0.089: v1(94.39,58.91) 94.39,58.91 94.9,59.42 JCPU1.W6
  TOP w0.102: JDIMM1.86 135.81,48.4 136.54,47.67 139.36,47.67 139.5,47.54 140.48,47.54 v5(140.74,47.27)
  IN1 w0.089: v1(94.39,58.91) 94.26,58.78 94.26,58.71 94.44,58.53 94.88,58.53 95.05,58.36 95.75,58.36 95.97,58.15 95.97,57.73 96.19,57.5 97.65,57.5 97.82,57.34 100.63,57.34 101.15,56.83 101.15,56 102.97,54.18 104.05,54.18 104.34,54.47 104.49,54.47
  IN1 w0.267: 104.49,54.47 105.93,54.47 107.01,53.39 107.9,53.39 116,45.29 116.49,45.29 116.77,45.58 117.19,45.58 119.01,43.76 122.62,43.76 122.99,43.39 132.87,43.39 134.99,45.5 136.56,45.5 136.77,45.71 140.99,45.71 141.12,45.83 141.12,46.89 v5(140.74,47.27)
  BOTTOM w0.102: JDIMM2.86 142.03,48.4 141.35,47.72 139.65,47.72 139.52,47.59 139.52,47.39 139.65,47.27 140.73,47.27 v5(140.74,47.27)
DDR_A_MA8: length 67.8
  TOP w0.089: v1(100.4,58.91) 99.94,58.45 JCPU1.V1
  TOP w0.102: v1(137.13,48.52) 137.58,48.07 139.52,48.07 139.66,47.93 141.18,47.93 141.89,48.64 141.89,48.83 142.36,49.3 JDIMM1.89
  IN1 w0.089: v1(100.4,58.91) 100.46,58.85 100.46,58.34 100.57,58.23 100.73,58.23 100.84,58.34 100.84,58.43 100.93,58.53 101.07,58.53 101.16,58.43 101.16,58.07 101.37,57.86 101.85,57.86 101.96,57.75 101.96,57.48 102.08,57.35 102.64,57.35 102.76,57.23 102.76,56.65 102.87,56.54 103.02,56.54 103.12,56.65 103.12,57.27 103.22,57.37 103.37,57.37 103.47,57.27 103.47,56.63 103.58,56.52 103.73,56.52 103.83,56.63 103.83,57.16 103.93,57.26 104.49,57.26
  IN1 w0.267: v1(137.13,48.52) 137.13,48.51 135.62,48.51 135.41,48.3 133.76,48.3 132.77,47.31 131.32,47.31 130.69,46.67 128.69,46.67 128.56,46.54 128.56,46.32 128.43,46.19 127.81,46.19 127.68,46.32 127.68,46.54 127.55,46.67 126.92,46.67 126.8,46.54 126.8,46.31 126.67,46.18 126.02,46.18 125.89,46.31 125.89,46.54 125.76,46.67 125.1,46.67 124.97,46.54 124.97,46.31 124.84,46.18 124.15,46.18 124.03,46.31 124.03,46.8 123.77,47.06 123.18,47.06 123.06,46.93 123.06,46.8 122.93,46.67 122.39,46.67 122.24,46.81 122.24,47.18 121.92,47.5 121.51,47.5 121.21,47.2 121.03,47.2 120.52,47.71 120.52,47.89 120.93,48.31 120.93,48.49 120.45,48.97 120.27,48.97 119.78,48.49 119.61,48.49 119.03,49.07 119.03,49.25 119.51,49.73 119.51,49.91 118.94,50.48 118.76,50.48 118.27,50 117.04,50 116.85,50.19 116.85,50.56 117.35,51.06 117.95,51.06 118.27,51.39 118.27,51.69 117.76,52.21 117.54,52.21 116.9,51.57 116.51,51.57 111.9,56.18 108.17,56.18 107.09,57.26 104.49,57.26
  BOTTOM w0.102: JDIMM2.89 135.94,49.3 136.03,49.39 136.19,49.39 136.28,49.3 136.28,49.14 136.07,48.93 136.07,48.59 136.16,48.49 136.52,48.49 136.59,48.56 136.59,48.9 136.64,48.95 137.06,48.95 137.18,48.82 137.18,48.57 v1(137.13,48.52)
DDR_A_MA9: length 70.5
  TOP w0.089: v3(95.4,58.91) 95.4,58.91 95.9,59.4 JCPU1.W5
  TOP w0.102: JDIMM1.85 142.37,48.1 142.13,47.86 142.12,47.86 141.91,47.65 141.91,47.64 140.67,46.4 138.83,46.4 v1(138.4,46.83)
  IN1 w0.089: 104.44,56.15 104.07,56.15 104.04,56.11 104.04,55.74 103.88,55.59 103.88,55.16 103.81,55.08 103.4,55.08 103.35,55.13 103.35,55.41 103.27,55.49 103.1,55.49 103.01,55.4 102.6,55.4 102.41,55.6 102.41,56.12 102.15,56.38 102.15,56.74 101.47,57.41 101.33,57.41 100.86,57.87 98.33,57.87 97.69,58.51 97.24,58.51 97,58.75 97,59.13 96.8,59.33 95.93,59.33 95.81,59.21 95.81,58.57 95.77,58.53 95.41,58.53 95.29,58.66 95.29,58.8 v3(95.4,58.91)
  IN1 w0.267: v1(138.4,46.83) 138.27,46.95 138.27,47.05 137.93,47.39 136.08,47.39 135.87,47.18 134.29,47.18 133.3,46.19 131.78,46.19 131.15,45.55 129.37,45.55 128.89,45.07 123.69,45.07 123.32,45.43 121.07,45.43 117.88,48.62 116.52,48.62 114.6,50.54 114.6,51.2 114.36,51.44 114.17,51.44 114.06,51.32 113.82,51.32 113.35,51.79 113.35,51.99 113.8,52.45 113.8,52.7 113.27,53.23 113,53.23 112.55,52.77 112.36,52.77 111.78,53.35 111.78,53.53 112.29,54.04 112.29,54.21 111.84,54.66 111.61,54.66 111.14,54.19 110.94,54.19 110.07,55.07 107.7,55.07 106.62,56.15 104.44,56.15
  BOTTOM w0.102: JDIMM2.85 136.37,48.1 136.5,47.97 136.5,47.44 136.63,47.31 136.88,47.31 137.01,47.44 137.01,47.94 137.13,48.07 137.39,48.07 137.51,47.94 137.51,47.44 137.64,47.31 137.9,47.31 138.02,47.44 138.02,47.69 138.15,47.82 138.4,47.82 138.53,47.69 138.53,46.96 138.4,46.83 v1(138.4,46.83)
DDR_A_MA10: length 67.9
  TOP w0.089: v3(92.4,63.92) 92.9,64.42 JCPU1.AD8
  TOP w0.102: JDIMM1.107 142.37,54.7 142.12,54.46 142.12,54.46 141.91,54.25 141.91,54.24 141.87,54.2 141.87,54.1 141.27,53.51 138.68,53.51 138.27,53.92 137.56,53.92 v1(137.13,54.35)
  IN1 w0.089: v3(92.4,63.92) 92.4,64.06 92.28,64.19 91.93,64.19 91.83,64.1 91.83,63.53 92.04,63.32 93.68,63.32 93.77,63.41 93.77,63.94 93.92,64.09 94.82,64.09 94.95,63.96 94.95,63.59 95.07,63.46 95.55,63.46 95.73,63.64 95.99,63.64 96.17,63.46 96.7,63.46 97,63.76 97.43,63.76 98.35,64.69 98.58,64.69 99.24,65.34 104.22,65.34 104.38,65.5 104.49,65.5
  IN1 w0.267: v1(137.13,54.35) 137.06,54.42 132.56,54.42 132.49,54.49 131.86,54.49 131.1,55.24 129.97,55.24 129.27,55.94 126.35,55.94 117.67,64.63 113.9,64.63 113.03,65.5 112.34,65.5 112.34,65.5 104.49,65.5
  BOTTOM w0.102: v1(137.13,54.35) 137.22,54.35 137.35,54.48 137.35,54.78 137.22,54.91 136.84,54.91 136.69,54.75 136.69,53.07 136.56,52.95 136.36,52.95 136.23,53.07 136.23,54.85 136.18,54.9 136.07,54.9 135.88,54.7 JDIMM2.107
DDR_A_MA11: length 71.2
  TOP w0.089: JCPU1.V4 96.9,58.43 97.41,57.92 v1(97.41,57.91)
  TOP w0.102: v5(139.67,46.83) 139.36,47.14 139.33,47.14 139.2,47.27 136.37,47.27 135.85,47.8 JDIMM1.84
  IN1 w0.089: v1(97.41,57.91) 97.42,57.9 97.51,57.9 97.89,57.52 100.71,57.52 101.33,56.9 101.33,56.08 102.96,54.44 103.73,54.44 104.31,55.03 104.49,55.03
  IN1 w0.267: v5(139.67,46.83) 139.67,46.39 139.54,46.27 136.54,46.27 136.33,46.06 134.76,46.06 133.76,45.07 132.25,45.07 131.95,44.77 131.95,44.17 131.73,43.95 130.75,43.95 130.26,44.44 129.84,44.44 129.35,43.95 123.22,43.95 122.86,44.32 119.24,44.32 117.17,46.39 116.79,46.39 116.33,45.93 116.15,45.93 115.58,46.5 115.58,46.68 116.14,47.24 116.14,47.42 115.56,47.99 115.38,47.99 114.82,47.44 114.64,47.44 114.07,48.01 114.07,48.19 114.63,48.75 114.63,48.93 114.05,49.5 113.87,49.5 113.32,48.95 113.14,48.95 112.56,49.52 112.56,49.7 113.12,50.26 113.12,50.44 112.54,51.01 112.36,51.01 111.81,50.45 111.63,50.45 111.05,51.03 111.05,51.21 111.61,51.77 111.61,51.95 111.03,52.52 110.86,52.52 110.3,51.96 110.12,51.96 109.54,52.54 109.54,52.72 110.02,53.19 110.02,53.37 109.44,53.95 109.26,53.95 109.02,53.7 108.38,53.7 108.13,53.95 107.24,53.95 106.16,55.03 104.49,55.03
  BOTTOM w0.102: JDIMM2.84 142.09,47.8 141.72,47.43 141.72,46.71 141.25,46.24 139.66,46.24 139.53,46.37 139.53,46.71 139.66,46.83 v5(139.67,46.83)
DDR_A_MA12: length 71
  TOP w0.089: v5(96.46,58.94) 96.46,58.95 96.9,59.38 JCPU1.W4
  TOP w0.102: JDIMM1.83 142.36,47.5 140.87,46.01 138.66,46.01 138.27,46.4 137.56,46.4 v1(137.13,46.83)
  IN1 w0.089: v5(96.46,58.94) 96.45,58.96 96.45,58.96 96.26,59.14 96.06,59.14 95.99,59.07 95.99,58.38 96.02,58.34 96.43,58.34 96.75,58.66 96.82,58.66 96.95,58.54 96.95,58.42 96.75,58.22 96.75,58.1 96.85,58 96.92,58 97.26,58.33 97.58,58.33 97.89,58.02 97.89,57.77 97.96,57.7 100.79,57.7 101.25,57.23 101.4,57.23 101.5,57.13 101.5,56.96 101.63,56.83 101.8,56.83 101.9,56.73 101.9,56.64 101.77,56.52 101.59,56.52 101.5,56.43 101.5,56.15 101.62,56.03 101.75,56.03 101.93,56.21 102.07,56.21 102.23,56.05 102.23,55.93 102.16,55.86 102.03,55.86 101.97,55.79 101.97,55.69 102.59,55.07 102.7,55.07 102.79,55.16 102.97,55.16 103.11,55.02 103.11,54.85 103.07,54.81 103.07,54.68 103.13,54.62 103.43,54.62 103.5,54.7 103.5,54.78 103.59,54.87 103.9,54.87 104.18,55.15 104.18,55.28 104.49,55.59
  IN1 w0.267: 104.49,55.59 106.39,55.59 107.47,54.51 109.84,54.51 116.78,47.56 117.19,47.56 117.31,47.68 117.31,47.93 117.44,48.06 117.64,48.06 117.96,47.75 117.96,47.18 117.7,46.93 117.7,46.65 118,46.35 118.18,46.35 118.68,46.85 118.86,46.85 119.42,46.29 119.42,46.11 118.91,45.61 118.91,45.43 119.37,44.97 119.55,44.97 119.99,45.41 120.3,45.41 120.84,44.88 123.09,44.88 123.46,44.51 129.12,44.51 129.61,45 130.5,45 130.98,44.51 131.25,44.51 131.39,44.64 131.39,45 132.02,45.63 133.53,45.63 134.52,46.62 136.1,46.62 136.3,46.83 136.36,46.83 136.36,46.83 v1(137.13,46.83)
  BOTTOM w0.102: JDIMM2.83 135.78,47.5 136.5,46.78 136.5,46.09 136.63,45.96 137.9,45.96 138.02,46.09 138.02,46.29 137.91,46.4 137.25,46.4 137.13,46.53 v1(137.13,46.83)
DDR_A_MA13: length 72.9
  TOP w0.089: JCPU1.AF8 92.87,66.45 92.43,66.89 v1(92.43,66.95)
  TOP w0.102: v1(137.89,56.64) 139.12,57.88 141.67,57.88 142.09,58.3 JDIMM1.119
  IN1 w0.089: 104.49,67.74 102.9,66.14 98.56,66.14 97.94,65.52 94.05,65.52 94.01,65.56 91.94,65.56 91.81,65.69 91.81,66.08 91.64,66.26 91.64,66.59 92.01,66.95 v1(92.43,66.95)
  IN1 w0.267: 104.49,67.74 113.96,67.74 114.82,66.87 115.97,66.87 116.09,66.99 116.09,67.14 116.22,67.27 116.89,67.27 117.02,67.14 117.02,67 117.15,66.87 117.88,66.87 118,67 118,67.14 118.13,67.27 118.95,67.27 119.07,67.14 119.07,66.46 119.2,66.34 119.58,66.34 119.84,66.59 120.01,66.59 120.59,66.02 120.59,65.84 120.23,65.48 120.23,65.3 120.81,64.73 120.99,64.73 121.34,65.08 121.52,65.08 122.1,64.51 122.1,64.33 121.74,63.98 121.74,63.8 122.32,63.22 122.5,63.22 122.85,63.58 123.03,63.58 123.61,63 123.61,62.82 123.25,62.47 123.25,62.29 123.83,61.71 124.01,61.71 124.36,62.07 124.54,62.07 125.12,61.49 125.12,61.31 124.86,61.06 124.86,60.68 125.25,60.28 125.94,60.28 126.3,59.92 126.3,59.24 126.74,58.8 127.23,58.8 127.46,59.02 128.09,59.02 128.32,58.79 128.32,58.42 128.56,58.18 130.2,58.18 130.9,57.48 132.75,57.48 133.52,56.71 137.83,56.71 v1(137.89,56.64)
  BOTTOM w0.102: v1(137.89,56.64) 137.89,57.53 137.76,57.66 137.41,57.66 137.29,57.53 137.29,56.73 137.16,56.61 136.75,56.61 136.63,56.73 136.63,57.31 135.64,58.3 JDIMM2.119
DDR_A_MA14: length 71.9
  TOP w0.089: v1(95.39,57.77) 95.39,57.79 95.9,58.3 JCPU1.V5
  TOP w0.102: v1(138.43,45.14) 138.52,45.14 138.58,45.19 138.58,45.41 138.35,45.63 138.17,45.63 138.05,45.76 138.05,45.88 137.92,46.01 137.63,46.01 137.5,45.88 137.5,45.7 137.37,45.57 137.13,45.57 137.01,45.7 137.01,46.19 136.6,46.6 JDIMM1.80
  IN1 w0.089: v1(95.39,57.77) 95.39,57.84 95.26,57.97 94.91,57.97 94.78,57.84 94.78,57.49 94.96,57.31 94.96,56.99 95.08,56.87 95.24,56.87 95.36,56.99 95.36,57.23 95.48,57.35 95.71,57.35 95.77,57.29 95.77,56.87 96.13,56.51 96.61,56.51 96.66,56.55 96.66,56.65 96.79,56.78 96.98,56.78 97.11,56.65 97.11,56.38 97.17,56.32 97.54,56.32 97.6,56.38 97.6,56.56 97.67,56.63 97.87,56.63 97.93,56.57 97.93,56.4 97.99,56.34 100.04,56.34 100.15,56.23 100.15,56.08 100.04,55.97 99.9,55.97 99.8,55.88 99.8,55.74 99.9,55.65 101,55.65 102.89,53.76 103.3,53.76 103.38,53.68 103.38,53.27 103.68,52.97 104.11,52.97 104.49,53.35
  IN1 w0.267: 104.49,53.35 105.47,53.35 106.76,52.05 107.21,52.05 107.33,51.93 107.33,51.52 107.46,51.39 108.32,51.39 110.18,49.53 110.18,49.34 110.05,49.21 110.04,49.21 109.92,49.09 109.92,48.9 110.33,48.49 110.51,48.49 110.73,48.7 111.01,48.7 111.53,48.18 111.53,47.94 111.32,47.73 111.32,47.5 111.79,47.03 112.07,47.03 112.28,47.24 112.47,47.24 115.39,44.32 115.39,43.51 115.58,43.32 116.32,43.32 116.43,43.43 116.43,43.76 116.56,43.88 117.3,43.88 117.43,43.76 117.43,42.77 117.55,42.64 122.16,42.64 122.53,42.27 133.34,42.27 135.45,44.39 138.44,44.39 138.66,44.6 138.66,44.81 138.44,45.02 138.44,45.13 v1(138.43,45.14)
  BOTTOM w0.102: JDIMM2.80 142.36,46.6 140.97,45.22 140.97,45.2 140.47,44.7 138.86,44.7 v1(138.43,45.14)
DDR_A_MA15: length 69.6
  TOP w0.089: v5(93.4,58.1) 93.74,58.45 JCPU1.V7
  TOP w0.102: v1(137.16,45.14) 137.14,45.14 137.57,44.7 138.02,44.7 138.14,44.59 138.14,44.42 138.02,44.3 136.97,44.3 136.13,45.14 136.13,45.35 136.26,45.48 136.49,45.48 136.61,45.61 136.61,45.87 136.49,46 JDIMM1.78
  IN1 w0.089: v5(93.4,58.1) 93.39,58.11 93.39,58.48 93.19,58.68 93.19,59.04 93.32,59.16 93.73,59.16 93.86,59.04 93.86,58.43 93.93,58.35 94.8,58.35 94.97,58.18 95.68,58.18 95.79,58.07 95.79,57.64 96.11,57.32 96.25,57.32 96.56,57.32 96.75,57.14 96.98,57.14 97.16,57.32 97.57,57.32 97.99,56.9 97.99,56.76 98.23,56.52 100.22,56.52 100.33,56.41 100.33,55.94 100.44,55.83 101.07,55.83 102.96,53.94 103.4,53.94 103.55,53.79 103.55,53.53 103.56,53.53 103.56,53.39 103.79,53.15 103.97,53.15 104.13,53.31 104.13,53.75 104.29,53.91
  IN1 w0.267: v1(137.16,45.14) 137.15,45.14 136.96,44.95 135.22,44.95 133.1,42.83 122.76,42.83 122.39,43.2 118.23,43.2 118.1,43.33 118.1,43.88 117.24,44.73 115.77,44.73 107.67,52.83 106.78,52.83 105.7,53.91 104.29,53.91
  BOTTOM w0.102: JDIMM2.78 142.33,46 140.64,44.31 137.99,44.31 137.16,45.14 v1(137.16,45.14)
DDR_A_RAS#: length 71.1
  TOP w0.089: JCPU1.AD9 91.9,64.47 v3(91.41,64.96)
  TOP w0.102: JDIMM1.110 139.01,55.6 139.72,54.89 140.4,54.89 v1(140.94,54.35)
  IN1 w0.089: 104.49,67.18 104.49,67.18 103.26,65.95 98.67,65.95 98.07,65.34 93.83,65.34 93.79,65.39 91.84,65.39 v3(91.41,64.96)
  IN1 w0.267: 104.49,67.18 113.72,67.18 114.59,66.31 118.44,66.31 126.51,58.24 127.69,58.24 128.31,57.62 129.96,57.62 130.67,56.92 132.52,56.92 133.29,56.15 137.6,56.15 137.66,56.09 141.06,56.09 141.52,55.62 141.52,54.93 v1(140.94,54.35)
  BOTTOM w0.102: JDIMM2.110 142.11,55.6 141.88,55.83 141.56,55.83 141.43,55.7 141.43,55.46 141.31,55.33 141.14,55.33 141.02,55.45 141.02,55.71 140.88,55.85 140.7,55.85 140.58,55.73 140.58,55.4 140.45,55.27 139.86,55.27 139.74,55.14 139.74,54.91 139.86,54.78 140.81,54.78 140.94,54.65 v1(140.94,54.35)
DDR_A_WE#: length 69.8
  TOP w0.089: JCPU1.AF9 91.9,66.45 91.4,66.94 v3(91.4,66.97)
  TOP w0.102: JDIMM1.113 141.88,56.5 141.37,55.99 141.37,55.09 141.25,54.97 140.88,54.97 140.75,55.09 140.75,55.55 140.62,55.68 140.04,55.68 139.91,55.8 139.91,56.01 140.04,56.13 140.69,56.13 140.82,56.26 140.82,56.52 140.69,56.64 v1(140.56,56.64)
  IN1 w0.089: v3(91.4,66.97) 91.79,67.35 93.55,67.35 93.8,67.1 93.8,66.95 94.22,66.54 95.04,66.54 95.06,66.52 100.6,66.52 101.55,67.47 103.11,67.47 104.49,68.85
  IN1 w0.267: 104.49,68.85 114.42,68.85 114.89,68.39 119.8,68.39 126.86,61.33 126.86,60.94 127.65,60.15 129.47,60.15 130.32,59.3 130.66,59.3 131.36,58.6 133.21,58.6 133.98,57.82 139.5,57.82 140.56,56.77 v1(140.56,56.64)
  BOTTOM w0.102: v1(140.56,56.64) 139.73,55.82 136.34,55.82 135.66,56.5 JDIMM2.113
DDR_B_BS0: length 92.8
  TOP w0.089: v5(91.38,60.96) 91.87,61.45 JCPU1.AA9
  TOP w0.102: v1(150.95,55.12) 151.39,55.55 155.88,55.55 156.13,55.3 JDIMM3.109
  IN3 w0.089: v5(91.38,60.96) 91.38,61.1 91.64,61.36 92.57,61.36 92.81,61.11 92.81,60.45 92.94,60.32 97.74,60.32 97.86,60.45 97.86,62.18 97.99,62.31 98.88,62.31 99,62.44 99,63.15 98.88,63.28 98.58,63.28 98.45,63.4 98.45,63.86 98.88,64.3 98.88,64.98 99.24,65.34 101.27,65.34 101.47,65.55 102.49,65.55 102.75,65.81 104.49,65.81
  IN3 w0.229: v1(150.95,55.12) 150.83,55.12 150.74,55.21 144.1,55.21 143.97,55.33 143.97,55.83 143.85,55.95 143.19,55.95 143.06,55.83 143.06,55.33 142.93,55.21 142.6,55.21 141.75,56.05 136.88,56.05 136.75,56.18 136.75,56.63 136.62,56.76 132.33,56.76 131.78,56.21 126.3,56.21 126.17,56.34 126.17,57.07 126.05,57.2 125.39,57.2 125.26,57.07 125.26,56.34 125.13,56.21 124.47,56.21 124.34,56.34 124.34,57.07 124.22,57.2 123.51,57.2 123.39,57.08 123.07,57.08 122.95,57.2 122.95,57.2 122.67,57.48 122.67,57.85 122.77,57.95 122.77,58.13 122.31,58.6 122.13,58.6 121.92,58.39 121.74,58.39 121.27,58.85 121.27,59.03 121.48,59.24 121.48,59.42 121.01,59.89 120.83,59.89 120.62,59.68 120.44,59.68 119.98,60.15 119.98,60.33 120.19,60.54 120.19,60.72 119.72,61.18 119.54,61.18 119.12,60.76 118.94,60.76 118.41,61.29 118.41,61.47 118.83,61.89 118.83,62.07 118.23,62.68 118.05,62.68 117.35,61.98 114.21,61.98 114.08,62.1 114.08,63.12 113.9,63.3 112.71,63.3 110.2,65.81 104.49,65.81
  BOTTOM w0.102: v1(150.95,55.12) 151.01,55.12 151.14,55.24 151.14,55.5 151.27,55.63 152.3,55.63 152.42,55.75 152.42,55.96 152.3,56.08 150.4,56.08 150.28,55.96 150.28,55.43 150.15,55.3 JDIMM4.109
DDR_B_BS1: length 90.7
  TOP w0.089: JCPU1.AA7 93.87,61.45 93.36,60.94 v1(93.4,60.94)
  TOP w0.102: JDIMM3.108 149.85,55 151.26,53.59 152.36,53.59 153.87,55.11 v1(153.87,55.12)
  IN3 w0.089: v1(93.4,60.94) 93.29,60.94 93.16,61.07 93.16,61.21 93.29,61.34 95.87,61.34 96,61.47 96,62.17 96.34,62.52 97.68,62.52 97.8,62.64 97.8,63.74 98.53,64.46 98.53,65.13 99.14,65.75 101.17,65.75 101.32,65.9 101.79,65.9 102.61,66.72 104.49,66.72
  IN3 w0.229: 104.49,66.72 110.58,66.72 111.66,65.65 111.99,65.65 112.57,66.22 112.75,66.22 113.28,65.69 113.28,65.51 112.64,64.87 112.64,64.69 113.12,64.21 113.3,64.21 113.66,64.58 113.66,64.59 113.9,64.83 114.14,64.83 114.76,64.21 117.98,64.21 123.22,58.98 124.32,58.98 124.52,58.78 124.52,58.24 124.65,58.12 125.31,58.12 125.44,58.24 125.44,58.92 125.57,59.04 126.23,59.04 126.35,58.92 126.35,58.24 126.48,58.12 127.14,58.12 127.27,58.24 127.27,58.92 127.39,59.04 128.26,59.04 128.38,58.92 128.38,57.25 128.51,57.13 129.3,57.13 129.43,57.25 129.43,57.56 129.62,57.75 142.71,57.75 142.84,57.62 142.84,57.01 142.96,56.88 145.76,56.88 146.52,56.12 151.93,56.12 152.16,55.89 153.94,55.89 154.07,55.77 154.07,55.24 153.94,55.12 v1(153.87,55.12)
  BOTTOM w0.102: JDIMM4.108 156.16,55 155.59,55.58 155.59,55.92 155.46,56.05 155.29,56.05 155.17,55.92 155.17,55.61 155.04,55.49 154.87,55.49 154.75,55.61 154.75,56.03 154.62,56.16 154.44,56.16 154.34,56.06 154.34,55.68 154.21,55.55 153.87,55.55 153.74,55.42 153.74,55.24 153.87,55.12 v1(153.87,55.12)
DDR_B_BS2: length 92.7
  TOP w0.089: v1(94.41,54.92) 94.41,54.96 JCPU1.R6
  TOP w0.102: JDIMM3.79 156.44,46.3 154.41,44.27 152.1,44.27 v1(151.66,44.71)
  IN3 w0.089: v1(94.41,54.92) 94.84,54.92 95.24,55.32 95.67,55.32 95.76,55.23 101.2,55.23 101.83,54.6 102.82,54.6 104.17,55.95 104.49,55.95
  IN3 w0.229: v1(151.66,44.71) 151.03,44.71 150.99,44.74 147.73,44.74 146.28,43.29 143.51,43.29 141.81,41.6 136.09,41.6 134.51,40.02 133.54,40.02 133.41,39.9 133.41,39.32 133.29,39.2 132.63,39.2 132.5,39.32 132.5,39.44 132.37,39.57 131.71,39.57 131.58,39.44 131.58,39.32 131.46,39.2 127.96,39.2 127.83,39.07 127.83,38.57 127.71,38.44 127.04,38.44 126.91,38.32 126.91,37.88 126.78,37.75 126.11,37.75 125.98,37.88 125.98,39.15 125.85,39.28 125.19,39.28 125.07,39.15 125.07,37.89 124.94,37.76 123.11,37.76 122.99,37.89 122.99,38.32 123.11,38.44 124.19,38.44 124.32,38.57 124.32,39.15 124.19,39.28 123.2,39.28 122.91,39.57 122.91,41.73 121.63,43.02 120.76,43.02 116.5,47.28 116.23,47.28 116.01,47.07 115.78,47.07 115.34,47.51 115.34,47.69 115.66,48.01 115.66,48.14 115.16,48.64 114.98,48.64 114.75,48.41 114.44,48.41 114.31,48.54 114.31,48.54 106.9,55.95 104.49,55.95
  BOTTOM w0.102: v1(151.66,44.71) 151.66,44.96 151.84,45.14 153.09,45.14 153.21,45.26 153.21,45.42 153.09,45.54 150.46,45.54 150.33,45.67 150.33,46.08 150.1,46.3 JDIMM4.79
DDR_B_CAS#: length 92
  TOP w0.089: v1(90.38,61.92) 90.85,61.45 JCPU1.AA10
  TOP w0.102: v1(154.13,57.44) 154.06,57.44 153.94,57.57 153.94,57.75 154.06,57.87 155.32,57.87 155.39,57.95 155.39,58.27 155.51,58.38 155.67,58.38 155.78,58.27 155.78,57.98 155.88,57.89 155.98,57.89 156.11,57.76 156.11,57.23 156.23,57.1 JDIMM3.115
  IN3 w0.089: v1(90.38,61.92) 89.89,61.92 89.76,61.79 89.76,61.64 89.88,61.52 91.57,61.52 91.8,61.75 91.8,62.39 91.93,62.52 93.78,62.52 93.96,62.34 95.64,62.34 96.25,62.95 96.51,62.95 98.17,64.61 98.17,65.28 99.02,66.13 100.9,66.13 101.07,66.29 101.54,66.29 102.88,67.64 104.17,67.64
  IN3 w0.229: v1(154.13,57.44) 154.28,57.44 154.41,57.31 154.41,56.93 154.28,56.81 152.54,56.81 152.31,57.03 147.35,57.03 146.56,57.82 143.93,57.82 142.38,59.38 135.87,59.38 135.59,59.11 135.34,59.11 135.22,58.98 135.22,58.79 135.09,58.67 134.43,58.67 134.3,58.79 134.3,59.07 134.17,59.2 133.49,59.2 133.36,59.07 133.36,58.79 133.23,58.67 132.57,58.67 132.45,58.79 132.45,59 132.32,59.12 131.61,59.12 131.48,59 131.48,58.79 131.35,58.67 130.61,58.67 130.48,58.79 130.48,59.83 130.35,59.96 128.62,59.96 128.5,60.08 128.5,60.27 128.37,60.4 127.87,60.4 127.75,60.27 127.75,60.08 127.62,59.96 127.15,59.96 127.02,60.08 127.02,60.99 126.9,61.11 126.33,61.11 126.2,60.99 126.2,60.08 126.07,59.96 125.4,59.96 125.27,60.08 125.27,60.53 125.14,60.66 124.39,60.66 124.27,60.53 124.27,60.08 124.14,59.96 123.53,59.96 123.3,60.19 123.3,60.47 123.16,60.61 122.88,60.61 118.36,65.13 115.14,65.13 112.63,67.64 104.17,67.64
  BOTTOM w0.102: v1(154.13,57.44) 154,57.44 153.54,56.99 150.24,56.99 150.13,57.1 JDIMM4.115
DDR_B_D0: length 95
  TOP w0.089: v3(91.4,42.96) 91.4,42.92 91.9,43.42 JCPU1.C9
  TOP w0.14: JDIMM3.4 150.18,21.4 150.35,21.23 150.7,21.23 150.82,21.11 150.82,20.92 v1(150.75,20.84)
  IN3 w0.089: 94.1,39.69 93.98,39.8 93.98,41.16 93.62,41.52 92.28,41.52 91.4,42.4 v3(91.4,42.96)
  IN3 w0.127: 94.1,39.69 95.22,38.56 95.22,29.91 101.04,24.09 102.92,24.09 103.59,23.42 107.16,23.42 111.29,19.29 118.72,19.29 118.87,19.14 119.97,19.14 120.61,18.5 125.51,18.5 125.56,18.46 131.19,18.46 131.66,17.99 132.36,17.99 132.87,17.48 136.19,17.48 137.48,16.19 140.88,16.19 143.1,18.42 145.71,18.42 145.84,18.29 145.84,17.79 145.97,17.67 146.22,17.67 146.35,17.79 146.35,18.29 146.47,18.42 146.89,18.42 147,18.3 147,17.64 147.92,16.73 148.1,16.73 148.35,16.99 148.35,17.17 147.67,17.85 147.67,18.03 147.85,18.21 148.03,18.21 148.71,17.52 148.89,17.52 149.07,17.71 149.07,17.88 148.38,18.57 148.38,18.75 148.56,18.93 148.74,18.93 149.43,18.24 149.61,18.24 149.79,18.42 149.79,18.6 149.1,19.29 149.1,19.47 149.28,19.65 149.46,19.65 150.01,19.11 150.18,19.11 150.36,19.29 150.36,19.47 149.88,19.96 149.88,20.13 150.09,20.35 150.27,20.35 150.41,20.2 150.59,20.2 150.9,20.51 150.9,20.69 v1(150.75,20.84)
  BOTTOM w0.14: JDIMM4.5 150.6,21.7 150.85,21.45 150.85,20.94 v1(150.75,20.84)
DDR_B_D1: length 93.6
  TOP w0.089: v1(94.4,40.92) 93.9,41.42 JCPU1.A7
  TOP w0.14: v1(153.8,20.84) 153.8,20.85 153.8,21.1 155,22.3 JDIMM3.7
  IN3 w0.089: v1(94.4,40.92) 94.6,40.72 94.6,39.69
  IN3 w0.127: 94.6,39.69 95.57,38.73 95.57,30.03 100.24,25.35 101.93,25.35 102.04,25.25 102.04,24.59 102.17,24.46 102.42,24.46 102.55,24.59 102.55,25.25 102.66,25.35 102.95,25.35 103.06,25.25 103.06,24.58 103.18,24.46 103.44,24.46 103.56,24.58 103.56,25.25 103.67,25.35 103.96,25.35 104.07,25.25 104.07,24.58 104.2,24.45 104.45,24.45 104.58,24.58 104.58,25.25 104.69,25.35 104.98,25.35 105.09,25.25 105.09,24.53 105.21,24.4 105.47,24.4 105.6,24.53 105.6,25.18 105.72,25.3 106.04,25.3 106.17,25.18 106.17,25.05 106.38,24.84 106.59,24.84 106.92,25.17 107.1,25.17 107.28,24.99 107.28,24.82 107.07,24.61 107.07,24.43 111.88,19.62 118.86,19.62 119.01,19.47 120.11,19.47 120.75,18.83 125.64,18.83 125.69,18.79 131.33,18.79 131.8,18.32 132.5,18.32 133.01,17.81 136.33,17.81 137.61,16.52 140.46,16.52 142.69,18.75 147.29,18.75 149.83,21.29 153.42,21.29 153.8,20.92 v1(153.8,20.84)
  BOTTOM w0.14: JDIMM4.6 154.65,22 153.8,21.15 153.8,20.85 v1(153.8,20.84)
DDR_B_D2: length 93.5
  TOP w0.089: JCPU1.D10 90.9,44.42 90.4,43.92 v3(90.4,43.95)
  TOP w0.14: v1(150.91,24.59) 150.94,24.62 150.94,24.92 150.86,25 JDIMM3.16
  IN3 w0.089: 98.54,39.69 97.05,41.17 97.05,41.88 96.42,42.52 96.27,42.52 96,42.79 96,42.92 95.52,43.41 95.11,43.41 94.98,43.54 94.98,45.18 94.64,45.52 92.16,45.52 91.8,45.16 91.8,44.77 91.44,44.41 90.51,44.41 90.4,44.3 v3(90.4,43.95)
  IN3 w0.127: 98.54,39.69 99.02,39.21 100.26,37.96 100.26,31.5 104.32,27.45 108.64,27.45 110.65,25.44 110.65,24.54 113.47,21.72 119.77,21.72 119.91,21.58 125.84,21.58 126.23,21.18 128.5,21.18 128.62,21.06 128.62,21.01 128.75,20.88 129.08,20.88 129.21,21.01 129.21,21.35 129.34,21.48 129.6,21.48 129.73,21.35 129.73,21 129.86,20.88 130.11,20.88 130.24,21 130.24,21.35 130.36,21.48 130.62,21.48 130.74,21.35 130.74,21 130.87,20.88 131.13,20.88 131.25,21 131.25,21.35 131.38,21.48 131.63,21.48 131.76,21.35 131.76,21 131.88,20.88 132.15,20.88 132.27,21 132.27,21.35 132.4,21.48 132.73,21.48 132.85,21.35 132.85,20.54 132.98,20.41 133.63,20.41 133.75,20.54 133.75,21.27 133.88,21.4 134.07,21.4 134.2,21.27 134.2,20.77 134.33,20.64 134.55,20.64 134.68,20.77 134.68,21.72 134.81,21.84 135.09,21.84 135.22,21.72 135.22,21.48 135.34,21.35 135.58,21.35 135.71,21.48 135.71,21.95 135.84,22.07 136.09,22.07 136.22,21.95 136.22,21.55 136.35,21.43 136.56,21.43 136.69,21.55 136.69,21.63 136.82,21.76 137.03,21.76 137.16,21.63 137.16,21.55 137.29,21.43 140.78,21.43 141.37,22.02 145.74,22.02 146.01,22.29 146.28,22.29 146.54,22.02 147.58,22.02 147.7,22.14 147.7,22.43 148.47,23.2 148.76,23.2 150.54,24.98 150.81,24.98 150.91,24.89 v1(150.91,24.59)
  BOTTOM w0.14: JDIMM4.15 150.17,24.7 150.41,24.93 150.89,24.93 150.98,24.84 150.98,24.66 v1(150.91,24.59)
DDR_B_D3: length 97.4
  TOP w0.089: JCPU1.C8 92.89,43.45 92.4,42.96 v1(92.38,42.96)
  TOP w0.14: v1(153.95,24.59) 154.67,25.3 JDIMM3.17
  IN3 w0.089: v1(92.38,42.96) 92,43.33 92,44.11 92.41,44.53 93.64,44.53 93.99,44.17 93.99,42.8 94.24,42.55 94.72,42.55 94.91,42.37 95.56,42.37 95.8,42.13 95.8,41.47 97.59,39.69
  IN3 w0.127: 97.59,39.69 99.6,37.67 99.6,30.75 99.97,30.38 99.97,30.2 99.55,29.78 99.55,29.6 99.73,29.42 99.91,29.42 100.33,29.84 100.51,29.84 100.69,29.66 100.69,29.48 100.02,28.81 100.02,28.63 100.2,28.45 100.38,28.45 101.05,29.12 101.23,29.12 101.41,28.94 101.41,28.76 100.74,28.09 100.74,27.91 100.92,27.73 101.1,27.73 101.77,28.4 101.95,28.4 102.13,28.22 102.13,28.04 101.53,27.44 101.53,27.26 101.71,27.08 101.89,27.08 102.49,27.68 102.67,27.68 103.57,26.78 108.15,26.78 109.99,24.94 109.99,24.26 113.2,21.06 119.48,21.06 119.63,20.9 125.58,20.9 126.27,20.22 131.97,20.22 132.44,19.75 133.1,19.75 133.61,19.24 136.56,19.24 137.5,20.18 146.67,20.18 150.29,23.8 153.17,23.8 v1(153.95,24.59)
  BOTTOM w0.14: v1(153.95,24.59) 154.97,25.6 JDIMM4.18
