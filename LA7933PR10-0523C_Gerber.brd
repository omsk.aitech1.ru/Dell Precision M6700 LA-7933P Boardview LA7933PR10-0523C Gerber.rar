# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Nets (continued)
SW_LVDS_B0+: JLVDS1.31 U13.9
SW_LVDS_B0-: JLVDS1.32 U13.10
SW_LVDS_B1+: JLVDS1.33 U13.7
SW_LVDS_B1-: JLVDS1.34 U13.8
SW_LVDS_B2+: JLVDS1.35 U13.2
SW_LVDS_B2-: JLVDS1.36 U13.3
SW_LVDS_BCLK+: C1186.1 JLVDS1.38 U13.36
SW_LVDS_BCLK-: C1185.1 JLVDS1.39 U13.1
SYS_LED_MASK#: Q321.2 R775.2 U46.B48 U58.1
SYS_PWROK: RC11.1 RH116.1 RH321.2 U46.B57
SYS_PWROK_R: RH116.2 UH4.P12
SYS_PWROK_XDP: JXDP1.13 RC3.2 RC11.2
SYS_RESET#: RH359.2 UC3.4 UH4.K3
SYSTEM_ID: C742.1 R871.2 U54.A10
TCM_BA0: R658.2 R660.1 U37.9 U39.9
TCM_BA1: R657.2 R659.1 U37.3 U39.3
TEMP_ALERT#: R741.2 RH18.1 RH266.1 UH4.V3
TEMP_ALERT#_R: R741.1 U46.B11
TEST: R41.2 R86.1 U26.18
THERM_STP#: PR118.1 R390.1 U18.25
THERMATRIP1#: C327.1 Q28.1 R396.2 U18.22
THERMATRIP2#: C350.1 R398.2 U18.23
THERMATRIP3#: C343.1 Q115.1 R397.2 U18.24
THERMB3: Q115.2 R401.2
TMDS_DDCBUF: R66.2 R68.2 U9.2
TMDS_PRE: R65.2 R67.2 U9.20
TMDS_RT: R57.2 R71.2 U9.23
TMDSE_CON_CLK: C1333.1 JHDMI1.10 L19.3(B) R451.2
TMDSE_CON_CLK#: C1334.1 JHDMI1.12 L19.2(B) R452.2
TMDSE_CON_N0: C1335.1 JHDMI1.9 L23.2(B) R454.2
TMDSE_CON_N1: C1337.1 JHDMI1.6 L24.2(B) R456.2
TMDSE_CON_N2: C1339.1 JHDMI1.3 L25.2(B) R458.2
TMDSE_CON_P0: C1336.1 JHDMI1.7 L23.3(B) R453.2
TMDSE_CON_P1: C1338.1 JHDMI1.4 L24.3(B) R455.2
TMDSE_CON_P2: C1340.1 JHDMI1.1 L25.3(B) R459.2
TMDSE_RP_CLK: L19.4(A) R451.1 U9.16
TMDSE_RP_CLK#: L19.1(A) R452.1 U9.15
TMDSE_RP_N0: L23.1(A) R454.1 U9.18
TMDSE_RP_N1: L24.1(A) R456.1 U9.21
TMDSE_RP_N2: L25.1(A) R458.1 U9.24
TMDSE_RP_P0: L23.4(A) R453.1 U9.19
TMDSE_RP_P1: L24.4(A) R455.1 U9.22
TMDSE_RP_P2: L25.4(A) R459.1 U9.25
TOUCH_SCREEN_PD#: JCAM1.7 R419.2 U46.B55
TP_LAN_JTAG_TCK: R546.2 U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: R545.2 U31.33
TPM_ID0: RH267.1 RH270.2 UH4.N2
TPM_ID1: RH268.2 RH271.1 UH4.M3
TRIP_+V1.05S_VCCPP: PR503.2 PU501.2
TRIP_+V1.05SP: PR403.2 PU401.2
UG_3V: PQ101.4 PU101.10
UG_5V: PQ102.4 PU101.21
UG_+V1.05S_VCCPP: PQ501.4 PU501.9
UG_+V1.05SP: PQ401.4 PU401.9
UGATE1: PQ705.2 PQ706.2 PU702.21
UGATE1G: PQ708.2 PU702.32
UGATE2: PQ703.2 PQ704.2 PU702.29
UGATE2G: PQ707.2 PU703.1
UGATE3: PQ701.2 PQ702.2 PU701.1
UIM_CLK: C628.1 JMINI1.12 JSIM1.3 U40.3
UIM_DATA: C631.1 JMINI1.10 JSIM1.7 U40.4
UIM_RESET: C629.1 JMINI1.14 JSIM1.2 U40.1
UIM_VPP: C630.1 JMINI1.16 JSIM1.6 U40.6
USB1_A_DE0: R23.2 R104.2 U625.16
USB1_A_DE1: R25.2 R809.2 U625.18
USB1_A_EQ0: R24.2 R106.2 U625.17
USB1_A_EQ1: R22.2 R108.2 U625.15
USB1_B_DE0: R16.2 R103.2 U625.3
USB1_B_DE1: R21.2 R773.2 U625.6
USB1_B_EQ0: R18.2 R105.2 U625.2
USB1_B_EQ1: R15.2 R107.2 U625.4
USB1_TEST: R12.2 U625.14
USB2_A_DE0: R32.2 R113.2 U626.16
USB2_A_DE1: R34.2 R826.2 U626.18
USB2_A_EQ0: R33.2 R114.2 U626.17
USB2_A_EQ1: R31.2 R111.2 U626.15
USB2_B_DE0: R28.2 R112.2 U626.3
USB2_B_DE1: R30.2 R813.2 U626.6
USB2_B_EQ0: R29.2 R110.2 U626.2
USB2_B_EQ1: R27.2 R109.2 U626.4
USB2_TEST: R26.2 U626.14
USB3_RX1_N_D-: D14.5 D14.6 JUSB1.5 L40.4(A) R746.2
USB3_RX1_P_D+: D14.4 D14.7 JUSB1.6 L40.1(A) R745.2
USB3_RX2_N_D-: D16.5 D16.6 JUSB2.5 L43.1(A) R752.2
USB3_RX2_P_D+: D16.4 D16.7 JUSB2.6 L43.4(A) R753.2
USB3_TX1_N_D-: D14.2 D14.9 JUSB1.8 L42.4(A) R743.2
USB3_TX1_P_D+: D14.1 D14.10 JUSB1.9 L42.1(A) R744.2
USB3_TX2_N_D-: D16.2 D16.9 JUSB2.8 L44.1(A) R750.2
USB3_TX2_P_D+: D16.1 D16.10 JUSB2.9 L44.4(A) R751.2
USB3RN1: C487.1 UH4.BE28
USB3RN1_C: C487.2 U625.23
USB3RN1_RP: L40.3(B) R746.1 R830.1
USB3RN1_RP_R: R830.2 U625.8
USB3RN2: C491.1 UH4.BC30
USB3RN2_C: C491.2 U626.23
USB3RN2_RP: L43.2(B) R752.1 R832.1
USB3RN2_RP_R: R832.2 U626.8
USB3RN4: JDOCK1.84 UH4.BJ32
USB3RP1: C465.1 UH4.BC28
USB3RP1_C: C465.2 U625.22
USB3RP1_RP: L40.2(B) R745.1 R831.1
USB3RP1_RP_R: R831.2 U625.9
USB3RP2: C490.1 UH4.BE30
USB3RP2_C: C490.2 U626.22
USB3RP2_RP: L43.3(B) R753.1 R833.1
USB3RP2_RP_R: R833.2 U626.9
USB3RP4: JDOCK1.86 UH4.BG32
USB3TN1: C452.2 UH4.AV26
USB3TN1_C: C452.1 U625.20
USB3TN1_RP: C488.1 L42.3(B) R743.1
USB3TN1_RP_C: C488.2 U625.11
USB3TN2: C456.2 UH4.BB26
USB3TN2_C: C456.1 U626.20
USB3TN2_RP: C492.1 L44.2(B) R750.1
USB3TN2_RP_C: C492.2 U626.11
USB3TN4: JDOCK1.90 UH4.AY30
USB3TP1: C454.2 UH4.AU26
USB3TP1_C: C454.1 U625.19
USB3TP1_RP: C489.1 L42.2(B) R744.1
USB3TP1_RP_C: C489.2 U625.12
USB3TP2: C457.2 UH4.AY26
USB3TP2_C: C457.1 U626.19
USB3TP2_RP: C493.1 L44.3(B) R751.1
USB3TP2_RP_C: C493.2 U626.12
USB3TP4: JDOCK1.92 UH4.AW30
USB_OC0#: RH339.2 U45.6 U45.10
USB_OC0#_R: RH51.1 RH339.1 RPH1.4 UH4.A14
USB_OC1#: JIO1.51 RH341.2
USB_OC1#_R: RH7.1 RH341.1 RPH1.3 UH4.K20
USB_OC2#: RH16.1 RPH2.1 UH4.B17
USB_OC3#: JIO1.53 RH5.1 RPH1.2 UH4.C16
USB_OC4#: RH356.2 U48.6 U48.10
USB_OC4#_R: RH6.1 RH356.1 RPH1.1 UH4.L16
USB_OC5#: RH14.1 RPH2.4 UH4.A16
USB_OC6#: RH8.1 RPH2.3 UH4.D14
USB_PWR_SHR_EN#: R776.2 R1626.1 U46.B2
USB_PWR_SHR_VBUS_EN: R778.2 R784.1 U46.B50
USB_SIDE_EN#: JIO1.69 Q90.2 R768.2 U45.5 U46.A33
USBP0+: L39.2 R748.1 UH4.A24
USBP0-: L39.3 R749.1 UH4.C24
USBP0_D+: D15.2 JUSB1.3 L39.1 R748.2
USBP0_D-: D15.3 JUSB1.2 L39.4 R749.2
USBP1+: U2.6 UH4.B25
USBP1-: U2.7 UH4.C25
USBP1_D+: L41.2 R764.1 U2.3
USBP1_D-: L41.3 R754.1 U2.2
USBP1_R_D+: D17.2 JUSB2.3 L41.1 R764.2
USBP1_R_D-: D17.3 JUSB2.2 L41.4 R754.2
USBP2+: JIO1.59 UH4.A26
USBP2-: JIO1.57 UH4.C26
USBP3+: JDOCK1.72 UH4.H28
USBP3-: JDOCK1.74 UH4.K28
USBP4+: JDOCK1.66 UH4.D28
USBP4-: JDOCK1.68 UH4.E28
USBP5+: JMINI1.38 UH4.A28
USBP5-: JMINI1.36 UH4.C28
USBP6+: JIO1.65 UH4.B29
USBP6-: JIO1.63 UH4.C29
USBP7+: JUSH1.3 UH4.M28
USBP7-: JUSH1.2 UH4.N28
USBP8+: JMINI2.38 UH4.K30
USBP8-: JMINI2.36 UH4.L30
USBP9+: L51.1 R736.1 UH4.E30
USBP9-: L51.4 R742.1 UH4.G30
USBP9_D+: D73.3 JESA1.3 L51.2 R736.2
USBP9_D-: D73.2 JESA1.2 L51.3 R742.2
USBP10+: JIO1.44 UH4.A30
USBP10-: JIO1.42 UH4.C30
USBP11+: JBT1.12 UH4.K32
USBP11-: JBT1.11 UH4.L32
USBP12+: L10.4(A) R428.1 UH4.E32
USBP12-: L10.1(A) R427.1 UH4.G32
USBP12_D+: D87.2 JCAM1.19 L10.3(B) R428.2
USBP12_D-: D87.3 JCAM1.17 L10.2(B) R427.2
USBP13+: L11.1(A) R430.1 UH4.A32
USBP13-: L11.4(A) R429.1 UH4.C32
USBP13_D+: D86.2 JCAM1.3 L11.2(B) R430.2
USBP13_D-: D86.3 JCAM1.1 L11.3(B) R429.2
USBRBIAS: RH151.1 UH4.B33 UH4.C33
USH_DET#: JUSH1.20 RH164.2 UH4.A42
USH_PWR_ON: T117.1(TP-1) U46.A18
USH_PWR_STATE#: JUSH1.16 R102.2 U46.A34
USH_SMBCLK: JUSH1.5 R589.2 U54.A50
USH_SMBDAT: JUSH1.6 R585.2 U54.B53
VAXG_VAL_SENSE: JCPU1.AJ31 RC54.2 RC55.1
VCI_IN1#: R1156.1 U54.A63
VCP2: R388.1 U18.45
VFB: PR926.1 PU901.15 PU901.16
VGA_ID: R800.2 R803.1 U46.B59
VIDALERT_N: PR725.1 RC63.2 RC64.2
VIDSCLK: JCPU1.AJ30 PR722.1
VIDSOUT: JCPU1.AJ28 PR727.1 RC65.2
VOL_DOWN: JIO1.75 R887.2 R1197.1
VOL_MUTE: JIO1.77 R884.2 R1177.1
VOL_UP: JIO1.73 R886.2 R1118.1
VR_EN: PR730.2 PR731.2 PU702.9
VR_HOT#: PR729.2 PU702.8
VSB_N_001: PC7.2 PQ4.2 PR15.2 PR17.2
VSB_N_002: PC16.1 PQ7.2 PR21.2 PR23.2
VSB_N_003: PQ7.1 PR17.1
VSET_4002: C333.1 R406.1 U18.42
VSUM+: PC750.1 PC751.1 PC752.1 PR724.1 PR746.1 PR753.1 PR754.1 PR761.1 PU702.14
VSUM-: PC738.2 PC739.2 PC742.2 PC750.2 PC751.2 PC752.2 PC755.1 PH704.2 PR728.2 PR751.2 PR754.2 PR757.2 PR760.1 PR763.2
VSUMG+: PC707.1 PC708.1 PC709.1 PR706.1 PR708.1 PR767.2 PR772.1 PU702.1
VSUMG-: PC707.2 PC708.2 PC709.2 PC718.1 PC719.2 PC720.2 PH701.2 PR708.2 PR710.1 PR712.1 PR768.1 PR773.2
VSYNC: RH124.2 UH4.M49
VSYNC_BUF: R44.1 U19.36
VSYNC_DOCK: JDOCK1.67 U19.27
VSYNC_L: C18.1 JCRT1.14 L5.2 R50.2
VTT_SENSE: JCPU1.B10 PR509.2 RC70.2
WIGI_RADIO_DIS#: D29.1 R690.1 R692.2 U46.A1
WIGI_RADIO_DIS#_R: D29.2 JMINI2.32 R690.2
WIMAX_LED#: JMINI2.42 Q124.4 R705.1 R706.1
WIRELESS_LED#: Q77.1 Q78.4 Q124.3 Q124.6 R944.2 U46.A47
WIRELESS_ON#/OFF: JWL1.3 R766.2 R2158.2 U46.B13
WLAN_LAN_DISB#: U15.4 U46.A64
WLAN_LED: JIO1.94 R939.2
WLAN_LED#: JMINI2.44 Q124.1 R718.1
WLAN_RADIO_DIS#: D31.1 R700.1 U46.A48
WLAN_RADIO_DIS#_R: D31.2 JMINI2.20 R700.2
WWAN_RADIO_DIS#: JMINI1.20 R774.2 U46.A53
WWAN_SMBCLK: JMINI1.30 R1157.1 R1159.2
WWAN_SMBDAT: JMINI1.32 R1158.1 R1160.2
XCLK_RCOMP: RH100.1 UH4.Y47
XDP_DBRESET#: JXDP1.18 JXDP2.48 RC28.2 RC30.1 RH359.1 UC3.1
XDP_DBRESET#_R: JCPU1.AL35 RC28.1
XDP_FN0: JXDP2.9 RH51.2
XDP_FN1: JXDP2.11 RH7.2
XDP_FN2: JXDP2.15 RH16.2
XDP_FN3: JXDP2.17 RH5.2
XDP_FN4: JXDP2.27 RH6.2
XDP_FN5: JXDP2.29 RH14.2
XDP_FN6: JXDP2.33 RH8.2
XDP_FN7: JXDP2.35 RH9.2
XDP_FN8: JXDP2.10 RH10.2
XDP_FN9: JXDP2.12 RH12.2
XDP_FN10: JXDP2.16 RH13.2
XDP_FN11: JXDP2.18 RH26.2
XDP_FN12: JXDP2.28 RH20.2
XDP_FN13: JXDP2.30 RH34.2
XDP_FN14: JXDP2.34 RH17.2
XDP_FN15: JXDP2.36 RH18.2
XDP_FN16: JXDP2.4 RH19.2
XDP_FN17: JXDP2.6 RH53.2
XDP_HOOK2: JXDP1.12 RC10.2
XDP_OBS0_R: JCPU1.AT28 T73.1(TP-1)
XDP_OBS1_R: JCPU1.AR29 T74.1(TP-1)
XDP_OBS2_R: JCPU1.AR30 T75.1(TP-1)
XDP_OBS3_R: JCPU1.AT30 T76.1(TP-1)
XDP_OBS4_R: JCPU1.AP32 T77.1(TP-1)
XDP_OBS5_R: JCPU1.AR31 T78.1(TP-1)
XDP_OBS6_R: JCPU1.AT31 T79.1(TP-1)
XDP_OBS7_R: JCPU1.AR32 T80.1(TP-1)
XDP_PRDY#: JCPU1.AP29 JXDP1.2
XDP_PREQ#: JCPU1.AP27 JXDP1.1 RC42.1
XDP_RST#_R: JXDP1.17 RC21.2
XDP_TCLK: JCPU1.AR26 JXDP1.26 RC44.1
XDP_TDI: JXDP1.22 RC33.2
XDP_TDI_R: JCPU1.AR28 RC33.1 RC41.1
XDP_TDO: JXDP1.20 RC37.2 RC43.1
XDP_TDO_R: JCPU1.AP26 RC37.1
XDP_TMS: JCPU1.AR27 JXDP1.23 RC38.1
XDP_TRST#: JCPU1.AP30 JXDP1.21 RC45.1
XTAL25_IN: RH99.1 RH309.2 UH4.V47
XTAL25_OUT: CH18.2 RH99.2 UH4.V49 YH2.3
XTALI: C471.1 U31.10 Y3.3
XTALO: R1144.1 U31.9
XTALO_R: C470.1 R1144.2 Y3.1
Z2805: R574.1 T156.22
Z2806: R573.1 T156.16
Z2807: R572.1 T156.21
Z2808: R571.1 T156.15
Z4012: PD1.2 PR1.2
Z4304: PBATT1.3 PD2.2 PR3.1
Z4305: PBATT1.4 PD2.3 PR5.1
Z4306: PBATT1.5 PD3.2 PR4.1
ZODD_WAKE#: R792.1 R796.2 U46.A59
N17063765: PC9.1 PQ5.4 PR16.2 PR20.1 PR22.1
N17075402: PQ2.3 PR7.2 PR9.1
N17083694: PC116.1 PR112.1 PR113.1 PU101.13
N17132539: PC1001.2 PQ907.4 PR1002.2
N17319754: PC1004.1 PQ1003.4 PR1004.1
N17684555: PC1005.1 PR1005.2
N17708032: PC5.1 PQ1.2 PR6.2
N17708061: PD5.2 PQ1.1
N20966390: PL3.1 PQ2.1 PR7.1 PR10.2
N20966408: PQ3.2 PR10.1 PR12.2
N20966410: PQ2.2 PQ3.1 PR11.2 PR13.1
N21585007: PQ1002.4 PR1006.1
N21631508: PQ1004.4 PR1009.1
N21631518: PR1024.1 PU1001.19
N21750145: PQ204.6 PR211.1
N21752779: PQ205.6 PR218.2
N22506578: PR1008.1 PU1001.28
N27932189: PR604.2 PR614.1 PU601.14
N27941874: PR601.2 PR613.1 PU601.15
N27967271: PC601.1 PR605.1 PU601.17
N27995579: PR612.1 PU601.3
N27996731: PC617.1 PC618.2 PU601.2
N28024997: PR610.2 PR611.1 PU601.5
N28058271: PC619.2 PU601.4
N31942683: QC1.1 RC7.2
N31979527: JCPU1.J15 T49.1(TP-1)
N31979574: JCPU1.W8 T6.1(TP-1)
N31979576: JCPU1.AT26 T8.1(TP-1)
N31979578: JCPU1.AM33 T10.1(TP-1)
N31979580: JCPU1.AJ27 T12.1(TP-1)
N31979582: JCPU1.T8 T14.1(TP-1)
N31979584: JCPU1.J16 T15.1(TP-1)
N31979586: JCPU1.H16 T16.1(TP-1)
N31979588: JCPU1.G16 T17.1(TP-1)
N31979600: JCPU1.AJ26 T18.1(TP-1)
N31979608: JCPU1.J20 T47.1(TP-1)
N31979610: JCPU1.B18 T48.1(TP-1)
N31979614: JCPU1.AH27 T1.1(TP-1)
N31979616: JCPU1.AR1 T52.1(TP-1)
N31979618: JCPU1.B1 T53.1(TP-1)
N31979620: JCPU1.AT1 T51.1(TP-1)
N31979622: JCPU1.AT2 T50.1(TP-1)
N31979624: JCPU1.AR35 T19.1(TP-1)
N31979626: JCPU1.AT34 T20.1(TP-1)
N31979628: JCPU1.AT33 T21.1(TP-1)
N31979630: JCPU1.AP35 T22.1(TP-1)
N31979632: JCPU1.AJ32 T42.1(TP-1)
N31979634: JCPU1.AK32 T44.1(TP-1)
N31979636: JCPU1.AR34 T23.1(TP-1)
N31979642: JCPU1.AE7 T4.1(TP-1)
N31979644: JCPU1.AG7 T3.1(TP-1)
N31979646: JCPU1.L7 T2.1(TP-1)
N31979648: JCPU1.AK2 T5.1(TP-1)
N31979665: JCPU1.F25 T24.1(TP-1)
N31979667: JCPU1.C30 T37.1(TP-1)
N31979669: JCPU1.D23 T35.1(TP-1)
N31979671: JCPU1.F23 T26.1(TP-1)
N31979673: JCPU1.F24 T25.1(TP-1)
N31979675: JCPU1.B30 T39.1(TP-1)
N31979677: JCPU1.A31 T38.1(TP-1)
N31979679: JCPU1.C29 T46.1(TP-1)
N31979681: JCPU1.G25 T29.1(TP-1)
N31979683: JCPU1.D24 T27.1(TP-1)
N31979685: JCPU1.E23 T33.1(TP-1)
N31979687: JCPU1.G24 T31.1(TP-1)
N31979689: JCPU1.B29 T40.1(TP-1)
N31979691: JCPU1.D30 T41.1(TP-1)
N31979693: JCPU1.B31 T43.1(TP-1)
N31979695: JCPU1.A30 T45.1(TP-1)
N31979738: JCPU1.A33 T30.1(TP-1)
N31979740: JCPU1.B34 T28.1(TP-1)
N31979742: JCPU1.A34 T32.1(TP-1)
N31979746: JCPU1.B35 T34.1(TP-1)
N31979748: JCPU1.C35 T36.1(TP-1)
N32023073: QC5.2 RC82.2 RC83.2
N32165635: JMXM1.55 R1970.2
N32221714: CH19.2 RH309.1 YH2.1
N32267992: T104.1(TP-1) UH4.K10
N32810427: CE3.1 RE5.2
N32810638: CE4.1 RE6.2
N32854162: C704.1 R756.2
N32854418: CE8.1 RE11.2
N32854492: CE9.1 RE12.2
N32893408: PR609.2 PU601.6
N32893413: PC618.1 PR612.2
N32894918: Q297.5 Q297.6 R565.2
N32916170: R804.1 U46.B19
N32916205: R771.1 U46.B66
N32917438: R802.2 U46.B18
N32917691: C713.1 R795.2
N32917698: R797.2 U46.B49
N32917710: C712.1 R794.2
N32931897: R886.1 U54.B8
N32932223: C747.1 R885.2
N32933688: R884.1 U54.B2
N32934056: JDEG2.1 R864.2
N32934332: R887.1 U54.B18
N33080426: Q22.1 R423.2
N33080469: C293.1 Q18.3 Q19.3 R412.2 R1632.1
N33080491: Q19.2 Q19.5 Q20.1 R414.2
N34390933: Q300.2 R505.1 R1621.2 R1624.2
N34391004: Q29.5 Q29.6 R513.2
N34391411: Q300.5 Q300.6 R500.2
N34658970: Q28.2 R399.2
N34659507: R395.2 R402.2 U18.19
N35298388: Q304.2 R762.2 R781.2
N35432705: Q79.1 R939.1
N35432718: D60.2 D63.2 Q78.1 R937.2
N35432724: Q78.6 Q79.2
N35432750: Q75.1 R934.1
N35432775: D59.1 Q74.3
N35432783: D59.2 D62.2 Q74.1 Q321.1 R932.2
N35432801: Q74.6 Q75.2
N35674348: Q73.1 R723.2
N35825115: JMINI3.3 R724.2
N35825195: JMINI3.22 R730.1
N36347564: L4.1 R43.2
N36347682: L5.1 R44.2
N38414754: R747.1 U45.7
N38606908: R783.1 U48.7
N38645812: R1207.2 U625.7
N38645839: R2200.2 U625.24
N38691992: R1191.2 U626.7
N38692019: R2202.2 U626.24
N39332507: R867.2 U54.B62
N39801641: JMXM1.57 R1971.2
N39900137: JMXM1.40 R1972.1
N41278453: PC217.1 PQ205.5 PR223.2 PR225.1
N41278459: PC215.1 PQ204.5 PR219.2 PR220.1
N41278463: PC214.1 PQ204.2 PQ204.3 PR213.2 PR217.1
N41278649: PC216.1 PQ205.2 PQ205.3 PR221.2 PR224.1
N41343073: PC218.1 PR208.1 PR211.2 PR215.1 PR218.1 PU201.6
N47450571: PQ902.1 PR901.3
N47460076: PQ503.3 PR510.1 PR511.1 PR515.1
N47645618: PQ105.1 PQ106.2 PQ106.5 PR117.1
N47645638: PC119.1 PQ105.2 PR115.2 PR118.2
N47645648: PD100.2 PR113.2
N47912464: PH703.2 PR733.2 PR735.2
N47912533: PC712.2 PR711.1
N47912632: PC734.1 PR738.1
N47912886: PC754.1 PR755.1
N47912908: PC722.1 PR726.2 PU702.25
N47912912: PR709.2 PU701.7
N47912959: PH702.2 PR714.2 PR717.2
N47913215: PC743.1 PR752.2
N47913217: PC735.1 PC736.2 PR748.1 PR749.2 PR752.1 PU702.17
N47913253: PC704.1 PC705.1 PR701.2 PR702.1 PR703.2 PU702.38
N47913259: PC704.2 PR704.1
N47913269: PC702.1 PC705.2 PR705.1 PU702.37
N47913277: PC702.2 PR703.1
N47913281: PC701.2 PR701.1
N47913307: PH701.1 PR706.2
N47913353: PC711.1 PR710.2
N47913357: PC711.2 PR712.2 PU702.40
N47913473: PC735.2 PR744.1
N47913489: PC741.2 PR749.1
N47913553: PC756.1 PR760.2
N47913557: PC756.2 PR757.1 PU702.15
N47928002: PC764.1 PR764.1
N47928569: PC771.1 PR775.1
N47928632: PR776.2 PU703.7
N47933880: PQ908.3 PQ908.6 PR935.1
N47933890: PQ910.1 PR945.2 PU903.1
N47935180: PQ908.2 PR931.1 PR936.2 PU902.7
N47935188: PQ909.1 PR943.2
N47935257: PQ908.5 PU903.4
N47935265: PC901.2 PQ902.2 PQ903.2 PR903.2
N47935277: PC934.2 PC935.1 PR928.2 PU901.17
N47935283: PC918.2 PC920.2 PC921.2 PC926.1 PR920.2 PU901.5
N47935329: PC921.1 PC923.1 PR922.2
N47935331: PR920.1 PR922.1 PU901.6
N47935337: PC917.1 PR919.2 PU901.23
N47935378: PQ904.1 PQ904.3 PR907.2 PR908.2 PR910.1
N47935380: PC905.2 PC906.1 PR906.2 PU901.27
N47935394: PR930.2 PR934.2 PR938.1 PR942.1 PU902.1
N47935396: PC904.2 PC905.1 PR905.2 PU901.28
N47935402: PC928.1 PR924.2 PU901.7
N47935428: PC940.1 PR936.1 PR939.2 PU902.5
N47935438: PC920.1 PC927.1 PR921.2 PU901.4
N47935442: PC909.1 PR913.1 PR914.1 PU901.2
N47935444: PR915.2 PU901.13
N47935488: PC918.1 PR921.1
N47935534: PC933.2 PC934.1 PR927.2 PU901.18
N47935814: PR923.3 PR927.1
N47935820: PQ903.1 PR901.2
N47935824: PR923.2 PR928.1
N47935848: PC938.1 PR930.1 PR932.2 PR940.1 PU902.3
N47935871: PC939.1 PR933.2 PR941.1 PU902.2
N47935873: PQ901.4 PR902.1
N47935901: PC941.1 PR937.2 PR943.1 PR944.1 PU902.6
N47992771: D60.1 Q78.3
N48118603: Q318.6 R941.1
N48565658: Q80.1 R942.1
N51303709: Q13.2 Q13.5 Q23.1 R162.2
N51303757: Q13.6 R161.2
N52004528: D34.2 U47.4
N53105221: Q86.1 R943.1
N53105229: Q86.2 Q321.6
N56200651: JMINI2.3 R707.2
N56200655: JMINI2.5 R702.2
N57447894: JODD1.11 R792.2
N60710877: JMINI1.22 R704.1
N63560596: Q303.2 R806.2 R808.2
N66037766: JLOM1.11 R1167.2
N66058065: JLOM1.10 R1170.2
N66078140: JLOM1.13 R1171.2
N66740706: JMINI4.22 R713.1
N72273015: JMXM1.80 R1976.2
N72829707: C761.1 R910.1
N72859551: C764.1 R913.1
N75612423: JLVDS1.3 R207.2
N75638681: JEDP1.3 R208.1
N83636251: Q110.3 Q113.2 Q113.5 R1537.2
N83636398: Q113.6 R1538.1 R1539.2
N83636400: Q113.3 R1523.1 R1530.2
N83636428: Q110.5 Q110.6 R1532.2
N85750543: PC405.2 PR402.2
N85751867: PC511.2 PR508.1 PR509.1
N85751870: PC505.2 PR502.2
N85751946: PQ503.1 PR512.2
N91647401: JMINI2.49 R709.2
N91785218: JMINI2.22 R703.2
N92711302: R1633.1 U7.4
N94639990: D68.2 U3.4
N95930610: PR206.2 PU201.5
N96028042: PBATT1.7 PD3.3
N97449521: Q84.6 R956.1
N97693169: Q335.6 R2151.2 R2156.1
N97693171: Q335.3 R2155.1 R2157.2
N97693199: Q336.5 Q336.6 R2152.2
N101024776: Q337.6 R2154.2 R2162.1
N101024778: Q337.3 R2161.2 R2163.1
N101696083: PR28.1 U59.6
N101696144: PQ1005.6 PR30.1
N101696146: PQ1005.2 PR29.2 PR31.1 PU2.1
N101696169: PC19.1 PR28.2 PR29.1 PU2.3
N101696187: PC20.1 PR26.1 PR27.2 PU2.2
N101982336: PR24.1 PR25.2
N101986272: PR14.1 PR25.3
N104675424: R2181.2 U60.2
N104675428: R2180.2 U60.1
N109035766: Q340.3 R2190.2
N109035794: Q339.5 Q339.6 R2192.2
N109035808: Q340.6 R2191.2
N110700389: R2201.2 U625.5
N110731646: R2203.2 U626.5
N141046134: PJP204.1 PU201.19
N141046260: PC205.2 PR201.1
N141046431: PR209.2 PU201.9
N1098609670: PH704.1 PR753.2

Pads without a net: D9 3; D11 2; D12 3; FD1 1; FD2 1; FD3 1; FD4 1; JBT1 2; JCPU1 B16 C15 C16 C17 C18 D15 D16 E16 F15 F16 G15; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JDIMM3 77 122 125 198; JDIMM4 77 122 125 198; JHDMI1 14; JIO1 8 100; JMINI1 3 5 17 19 40 44 45 46 47 49; JMINI2 8 10 12 30 37 40; JMINI3 5 20 30 32 36 37 38 40 42 44 45 46 47 49 51; JMINI4 1 3 5 8 10 12 14 16 17 19 20 30 32 36 37 38 40 42 44 45 46 47 49; JMXM1 46 48 50 52 60 62 64 65 66 67 74 75 76 77 78 79 81 189 191 193 195 197 205 207 210 212 257 259 261 263 265 266 267 269 271 273 275 277 279; JPB1 3; JSATA1 20 21 22; JSATA2 20 21 22; JSIM1 4 8; JSPI1 13 14 15; JWL1 2; JXDP1 4 5 7 8 24; JXDP2 3 5 21 22 23 24 40 42 45 47 54 55; PJPDC1 1; PQ1005 3 4 5; PU2 5 6 7; PU101 18 25; PU301 1 7; PU302 1 7; PU1001 31 36; Q84 3 4 5; Q321 3 4 5; Q326 3 4 5; U9 11 46; U11 32 33 34; U12 2 8; U13 4 5 6 12 13 14 32 33 34; U18 1 2 7 8 29 30 34 39 48; U19 12; U21 1; U22 8 15 21 26 37 43 46; U31 6; U32 5; U37 6 12; U39 6 12; U46 A15 A23 A44 A57 B1 B16 B51 B68; U54 A2 A21 A24 A57 A59 A64 B17 B20 B23 B24 B27 B28 B34 B36 B37 B38 B61 B68; U88 2 3; UC2 1; UH4 A34 AB40 AB42 AB45 AB46 AF36 AF43 AF45 AH12 AH37 AH38 AJ47 AJ48 AK43 AK45 AM4 AM5 AM12 AM13 AM40 AM42 AP39 AP40 AP43 AP45 AP47 AP49 AT1 AT3 AT4 AT5 AT8 AT10 AT12 AT38 AT40 AT43 AT45 AT47 AT49 AU2 AU3 AU16 AU28 AU47 AU48 AV1 AV3 AV5 AV7 AV10 AV28 AV40 AV42 AV45 AV46 AV47 AV49 AY3 AY5 AY7 AY16 AY34 AY43 AY45 AY47 AY49 B21 BA2 BA3 BA47 BA48 BB1 BB3 BB5 BB7 BB34 BB43 BB45 BB47 BB49 BC8 BD4 BE8 BE32 BE36 BE42 BE44 BF3 BF6 BF32 BF36 BF42 BF44 BG4 BG16 BG26 BG42 BG46 BH25 BH41 BJ16 BJ26 BJ42 C18 C34 E36 E42 G34 H3 K24 K42 L24 M20 M36 M39 M43 N30 N32 P38 P39 P42 P46 T45 V40 V42 Y13

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 7266 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 1096 vias
v3: diameter 0.508, hole 0.229, TOP to BOTTOM, 541 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 105 vias
v5: diameter 0.483, hole 0.229, TOP to BOTTOM, 310 vias
v6: diameter 0.508, hole 0.203, TOP to BOTTOM, 18 vias
v7: diameter 0.483, hole 0.203, TOP to BOTTOM, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.75V_DDR_VTT_ON: length 37.3
  TOP w0.102: v1(244.11,69.89) 244.21,69.79 244.21,69.32 244.78,68.75 244.78,61.34 244.49,61.04 244.49,59.55 243.46,58.52 243.46,48.35 v2(242.29,47.18) 241.15,46.04 236.46,46.04 236,46.49 236,48.02 v1(236.56,48.58)
  BOTTOM w0.102: U46.A60 244.71,70.45 R790.1 244.74,70.39 244.33,69.99 244.21,69.99 v1(244.11,69.89) ; PR214.1 v1(236.56,48.58)
1.05V_0.8V_PWROK: length 183
  TOP w0.102: v1(19.8,75.31) 20.27,74.84 21.06,74.84 PR731.1 ; RH283.1 66.52,112.76 66.95,113.2 66.95,113.61 65.2,115.37 62.19,115.37 57.99,111.17 57.99,107.68 60.91,104.76 60.91,99.35 59.79,98.24 58.25,98.24 58.02,98.01 v1(58.02,97.93) ; R883.2 26.52,11.06 26.37,11.2 U50.4 26.37,12.78 v1(26.15,13.01)
  IN2 w0.127: v1(57.69,94.96) 57.69,94.89 56.46,93.66 38.44,93.66 37.68,92.9 36.71,92.9 35.31,91.5 26.67,91.5 24.65,93.52 21.32,93.52 20.99,93.19 20.51,93.19 v1(19.99,93.71)
  BOTTOM w0.102: v1(58.02,97.93) 58.02,97.54 57.68,97.19 57.68,95 57.69,94.98 v1(57.69,94.96) ; v1(26.15,13.01) 26.59,13.45 30.13,13.45 31.59,14.91 32.58,14.91 33.41,15.74 33.41,16.45 33.41,19.32 33.92,19.83 33.92,35.01 35.83,36.91 35.83,46.19 31.14,50.87 31.14,57.29 21.52,66.91 19.07,66.91 16.5,69.48 16.5,72.82 16.29,73.03 16.29,74.05 17.83,75.59 18.41,75.59 18.58,75.76 19.34,75.76 19.79,75.31 v1(19.8,75.31) 19.8,76.68 16.2,80.28 v2(16.2,86.74) 16.2,86.91 17.24,87.95 18.59,87.95 19.23,88.58 20.32,88.58 21.69,89.95 21.69,91.63 19.99,93.33 v1(19.99,93.71)
1.05V_0.8V_PWROK_R: length 5.5
  TOP w0.102: v2(66.55,113.49) 66.04,112.98 66.04,112.09 RH283.2 67.06,111.06 JXDP2.39
1.05V_A_PWRGD: length 207.8
  TOP w0.254: v1(152.36,145.85) 152.36,147.81 151.29,148.87 151.29,151.3 v2(152.96,152.97) 153.43,153.43 153.43,157.04 153.97,157.58 153.97,161.87 v1(152.03,163.82) ; U54.A14 160.63,144.38 160.16,143.9 v1(160.16,143.73) ; v1(11.03,154.88) 9.57,154.88 8.84,155.61 7.92,155.61 7.24,154.93 PR401.2 6.89,155.26 5.94,155.26 5.71,155.03 PU401.1
  IN1 w0.254: v1(152.03,163.82) 151.14,164.71 147.75,164.71 146.16,163.12 137.32,163.12 128.83,171.62 107.81,171.62 99.43,163.24 99.43,160.34 96.26,157.18 96.26,154.39 93.19,151.32 81.6,151.32 77.15,155.77 77.15,161.58 v1(77.43,161.86)
  IN2 w0.254: v1(77.43,161.86) 76.99,162.31 76.99,163.28 76.31,163.96 56.53,163.96 55.14,162.57 48.56,162.57 47.62,161.63 39.3,161.63 35.94,158.27 30.39,158.27 29.2,157.07 13.23,157.07 v1(11.03,154.88)
  IN3 w0.254: v1(160.16,143.73) 160.15,143.73 159.59,144.29 157.54,144.29 156.83,145 153.21,145 v1(152.36,145.85)
1.5V_B+: length 27.9
  TOP w0.254: v1(218.82,31.41) 220.32,29.91 226.4,29.91 235.66,39.17 235.66,41.25 236.46,42.05 236.46,44.29 v1(236.69,44.51)
  BOTTOM w0.254: v1(236.69,44.51) PR209.1
  vias: v4(214.76,37.48)
1.5V_RUN_PWRGD: length 36.9
  IN3 w0.254: v1(233.83,68.3) 233.81,68.3 233.32,67.81 232.85,67.81 231.83,68.83 225.42,68.83 224.28,69.96 218.65,69.96 217.18,68.49 211.73,68.49 210.12,70.1 210.12,74.51 v1(209.41,75.22)
  BOTTOM w0.102: v2(210.4,78.7) 210.4,77.24 PR308.2
  BOTTOM w0.127: v1(233.83,68.3) U46.B15
  BOTTOM w0.254: PU302.4 209.58,75.05 v1(209.41,75.22) 209.37,75.26 209.37,76.21 PR308.2
1.5V_SUS_PWRGD: length 191.4
  TOP w0.127: v1(161.85,137.02) 162.05,136.82 162.05,133.53 162.28,133.3 162.28,111.58 v2(161.82,111.13) 161.06,110.36 161.06,102.72 160.35,102.02 160.35,91.92 163,89.27 170.31,89.27 177.1,82.47 178.92,82.47 186.08,75.32 186.08,65.76 184.88,64.57 182.32,64.57 180.96,63.2 180.96,52.98 182.65,51.28 185.95,51.28 187.7,49.53 v1(188.7,49.53) ; v1(162.83,147.09) 162.79,147.09 162.75,147.13 U54.B9
  IN1 w0.127: v1(162.83,147.09) 162.83,146.94 161.97,146.09 161.97,137.21 161.85,137.08 v1(161.85,137.02)
  IN3 w0.254: v1(234.94,42.77) 230.49,38.32 210.02,38.32 208.37,39.97 208.37,51.56 206.25,53.68 204.21,53.68 202.67,52.13 193.64,52.13 191.06,49.56 188.72,49.56 v1(188.7,49.53)
  BOTTOM w0.203: PR205.2 234.44,43.5 233.21,44.73 PU201.10
  BOTTOM w0.254: PR205.2 v1(234.94,42.77)
1.05V_VTTPWRGD: length 63.2
  TOP w0.127: v1(28.48,14.54) 27.86,14.54 27.67,14.35 U50.1
  IN1 w0.254: v1(28.48,14.54) 28.73,14.54 29.34,15.15 29.34,18.2 28.56,18.97 28.56,21.46 28.14,21.88 28.14,24.17 27.61,24.7 27.61,27 28.45,27.84 28.45,32.52 28.78,32.86 29.81,32.86 29.84,32.83 35.66,32.83 36.78,33.95 39.9,33.95 41.24,32.61 41.24,31 45.15,27.08 45.15,24.87 v1(45.69,24.32)
  IN3 w0.254: v1(45.69,24.32) 46.56,23.46 48.49,23.46 50.24,21.7 56.53,21.7 v1(57.77,20.46)
  BOTTOM w0.102: v1(57.77,20.46) 58.55,20.46 v2(58.82,20.18)
  BOTTOM w0.254: v1(57.77,20.46) PR501.2 57.5,21.39 57.5,22.42 57.94,22.85 PU501.1 ; PR606.2 v1(45.69,24.32)
1.5VSP_FB: length 5.8
  BOTTOM w0.102: v2(216.19,74.65) 215.86,74.98 214.78,74.98 PR313.1
  BOTTOM w0.254: PU302.6 214.21,75.55 PR313.1 PC308.2 PR310.2
1.5VSP_LX:
  vias: v2(206.46,71.45)
1.5VSP_VIN:
  vias: v2(213.76,72.54)
1.8V_RUN_PWRGD: length 211.5
  TOP w0.254: v1(107.01,9.35) 107.01,9 106.5,8.5 97.56,8.5 97.26,8.8 97.26,21.5 97.72,21.97 103.44,21.97 103.78,21.63 v1(103.78,20.93)
  IN3 w0.127: v1(107.01,9.35) 107.21,9.55 108.95,9.55 109.52,10.12 110.97,10.12 111.2,10.35 111.2,12.29 114.43,15.52 117.28,15.52 119.16,13.64 122.17,13.64 122.58,13.23 122.58,12.19 122.86,11.91 124.57,11.91 125.98,13.33 126.61,13.33 127.85,12.09 157.32,12.09 158.37,13.14 158.37,15.94 162.95,20.52 162.95,41.84 175.74,54.62 183.77,54.62 184.31,55.17 184.31,56.06 186.23,57.98 192.93,57.98 194,59.04 199.43,59.04 202.66,62.27 203.21,62.27 206.13,65.19 228.33,65.19 230.01,66.87 233.69,66.87 234.41,67.58 235.18,67.58 235.61,68.01 235.94,68.01 236.27,68.34 236.27,68.74 v1(235.81,69.2)
  BOTTOM w0.102: PR301.2 v2(102.62,22.05)
  BOTTOM w0.127: U46.B10 236.33,67.95 236.28,68 236.28,68.73 v1(235.81,69.2)
  BOTTOM w0.254: PR301.2 103.78,21.89 v1(103.78,20.93) 103.78,20.51 104.47,19.82 PU301.4
1.8VSP_FB: length 4.2
  BOTTOM w0.254: PR306.1 PR303.2 PC302.2 108.75,20.89 v2(108.37,20.52) 108.18,20.32 PU301.6
1.8VSP_LX:
  vias: v2(103.78,19.1)
1.8VSP_VIN:
  vias: v2(108.43,17.29)
2VREF_6182: length 191.5
  TOP w0.254: v1(276.2,63.31) 277.15,62.36 v2(277.15,61.71) v1(277.15,57.15)
  IN1 w0.254: v1(276.2,63.31) 272.85,66.66 271.98,66.66 268.39,70.26 251.99,70.26 251.06,71.18 251.06,74.34 248.63,76.78 248.63,78.93 247.8,79.76 247.8,81.42 245.85,83.38 243.25,83.38 242.77,83.86 241.16,83.86 240.9,84.11 239.11,84.11 238.47,84.76 236.92,84.76 235.88,85.8 234.06,85.8 233.32,86.54 231.58,86.54 220.13,97.99 220.13,98.73 219.49,99.36 219.49,99.63 216.23,102.9 216.23,103.05 214.58,104.7 214.58,106.58 214.77,106.77 214.77,107.58 213.52,108.83 213.52,110.9 213.18,111.24 213.18,113.22 v1(213.66,113.7)
  IN4 w0.254: v1(211.61,135.4) 211.99,135.78 211.99,156.67 211.7,156.95 209.96,156.95 208.33,158.58 206.93,158.58 205.84,159.68 205.84,162.29 205.21,162.92 201.01,162.92 199.46,161.37 195.32,161.37 193.62,163.07 183.75,163.07 182.92,163.91 179.42,163.91 v1(178.67,163.16)
  BOTTOM w0.254: PU101.14 276.95,57.35 v1(277.15,57.15) ; v1(211.61,135.4) 211.83,135.4 213.16,134.07 213.16,114.21 v1(213.66,113.7) ; PR27.1 179.02,169.13 179.44,168.71 179.44,167.03 178.73,166.32 178.73,163.21 v1(178.67,163.16)
3V_PWROK#: length 5.7
  TOP w0.102: R391.2 149.46,158.28 v2(149.06,158.28) 146.89,158.28 146.09,159.08 U18.17
+0.75V_DDR_VTT: length 42.4
  TOP w0.356: v1(133.28,84.07) 133.54,83.8 JDIMM1.204 ; v1(155.71,83.8) 155.96,83.8 156.26,83.5 JDIMM3.203 ; v1(141.58,85.03) 141.58,84.27 142.34,83.5 JDIMM1.203 ; JDIMM3.204 150.22,83.8 v1(150.66,84.24)
  TOP w0.508: v1(162.1,83.05) 161.64,82.59 CD62.1 ; CD19.1 CD18.1 v1(131.38,85.41) ; CD17.1 CD20.1 130.83,86.22 131.54,86.22 132.05,85.7 v1(132.05,85.4) ; CD59.1 v1(164.69,82.74) ; CD61.1 v1(162.66,82.74) ; CD60.1 v1(163.68,82.77)
  BOTTOM w0.102: 229.88,55.6 v4(227.67,55.6)
  BOTTOM w0.356: JDIMM2.203 133.84,83.5 v1(133.28,84.07) ; v1(150.66,84.24) 149.92,83.5 JDIMM4.203 ; JDIMM2.204 142.21,83.8 141.58,84.43 v1(141.58,85.03) ; JDIMM4.204 v1(155.71,83.8)
  BOTTOM w0.508: CD37.1 CD38.1 128.14,82.09 129.75,82.09 CD40.1 CD39.1 130.78,84.81 v1(131.38,85.41) ; v1(162.66,82.74) 162.66,81.83 161.85,81.01 CD83.1 ; v1(163.68,82.77) 163.68,81.77 CD82.1 ; v1(162.1,83.05) 161.94,82.88 161.94,82.12 160.92,81.1 CD84.1 ; CD81.1 164.69,81.58 v1(164.69,82.74)
  vias: v1(167.99,85.15) v1(167.99,84.47) v1(233.08,56.49) v1(233.72,56.49)
+0.75VSP: length 6.9
  IN3 w0.254: v1(231.04,47.94) 231.04,52.96 231.23,53.15 v1(231.23,53.79)
  BOTTOM w0.203: PU201.2 230.9,47.81 v1(231.04,47.94)
  vias: v1(229.28,47.57) v1(229.31,46.94) v1(229.84,53.79) v1(229.84,53.15) v1(230.59,53.79) v4(229.13,48.17)
+1.0V_LAN: length 47.2
  TOP w0.203: U31.40 v1(125.05,164.79) ; v1(125.55,156.69) 125.45,156.79 U31.22 ; v1(120.17,158.38) 120.17,158.65 120.56,159.05 U31.11 ; v1(126.4,164.71) 126.25,164.56 U31.37 ; U31.43 v1(123.85,164.77) ; v1(120,160.24) 120.01,160.24 121.07,160.24 U31.8
  TOP w0.254: C469.1 123.16,155.86 123.16,156.91 123.16,156.91 123.16,157.16 123.05,157.27 U31.16
  TOP w0.508: C1177.1 R548.1 C462.1 115.37,161.23 115.13,161 C463.1 v1(115.85,160.59) 116.74,159.7 L29.2 ; v1(125.05,164.79) 125.07,164.81 125.07,165.7 124.81,165.95 C467.1 ; C469.1 v1(122.27,155.73) ; C468.1 v1(119.42,156.02)
  IN1 w0.508: v1(125.55,156.69) 124.59,155.73 v1(122.27,155.73) 121.99,156.02 v1(119.42,156.02) 119.42,157.63 v1(120.17,158.38) 120.23,158.45 120.23,160.01 v1(120,160.24) 119.65,160.59 v1(115.85,160.59)
  IN4 w0.508: v1(121.49,165.51) 121.49,164.57 121.74,164.31 123.39,164.31 v1(123.85,164.77) 125.03,164.77 v1(125.05,164.79) 126.32,164.79 v1(126.4,164.71)
  BOTTOM w0.508: v1(120,160.24) 120.17,160.24 121.49,161.56 v2(121.49,163.74) v1(121.49,165.51)
+1.5V_CPU_VDDQ: length 38
  TOP w0.254: v1(93.34,65.96) 93.36,65.98 93.42,65.98 93.88,66.45 JCPU1.AF7 ; v1(96.37,66.94) 96.38,66.94 96.87,66.45 JCPU1.AF4
  TOP w0.305: v5(94.39,53.92) 94.43,53.92 93.9,54.45 JCPU1.P7
  TOP w0.356: v1(101.38,66.74) 101.36,66.74 101.07,66.45 JCPU1.AF1 ; v1(96.38,57.94) 96.87,57.45 JCPU1.U4
  TOP w0.381: v1(94.39,59.92) 94.4,59.92 93.9,60.42 JCPU1.Y7 ; v1(96.4,53.92) 96.4,53.92 96.9,54.42 JCPU1.P4 ; JCPU1.AC7 93.9,63.42 v1(93.4,62.92) ; JCPU1.AC1 99.9,63.42 v1(100.4,62.92) ; JCPU1.U7 93.86,57.45 93.37,56.97 93.34,56.94 93.34,56.95 v1(93.37,56.97) ; JCPU1.Y4 96.9,60.42 v1(96.4,59.92) ; JCPU1.U1 100.22,57.45 101.06,58.29 v5(101.06,58.91) ; JCPU1.AC4 96.9,63.42 v1(97.4,62.92) ; JCPU1.Y1 99.99,60.45 v1(100.47,60.93)
  TOP w0.508: RC75.1 114.94,71.89 114.43,71.37 112.71,71.37 112.42,71.08 112.42,67.54 112.11,67.23 ; RC4.1 92.81,80.58 v1(93.22,80.18)
  BOTTOM w0.254: v1(93.22,80.18) 92.89,79.85 92.89,73.67 92.64,73.43 92.23,73.43 91.9,73.1 91.9,66.64 92.06,66.47 92.82,66.47 93.11,66.19 93.11,65.98 93.33,65.98 v1(93.34,65.96)
  vias: v1(101.12,62.9) v1(115.38,61.42) v1(115.85,59.83) v1(116.23,59.17) v1(116.48,59.83) v1(116.61,61.42) v1(116.91,58.56) v1(117.12,59.83) v1(117.26,61.44) v1(117.54,58.78) v1(117.58,58.1) v1(117.81,59.36) v1(117.92,61.51) v1(118.21,58.74) v1(118.21,58.1) v1(118.26,59.8) v4(104.71,59.08)
+1.5V_CPU_VDDQ_CHG: length 2.3
  TOP w0.102: v2(125.97,70.93) R926.2
  TOP w0.508: R926.2 125.07,70.96 Q71.1
+1.05V_M: length 277
  TOP w0.203: UH4.T21 25.66,113.91 v1(25.66,113.86)
  TOP w0.254: v1(25.63,114.75) 25.63,114.69 26,114.32 UH4.V21 ; v1(23.71,113.4) 23.73,113.38 25.12,113.38 UH4.T19
  TOP w0.508: v1(114.43,163.13) 114.43,163.41 114.2,163.64 R548.2 ; CH64.1 33.44,97.35 34.16,98.07 34.28,98.07 v1(34.49,98.29) 34.49,98.2 35.22,97.47 CH65.1
  IN1 w0.508: v1(12.71,139.48) 12.51,139.48 11.14,138.12 11.14,137.74 9.82,136.41 9.82,134.72 7.47,132.37 7.47,125.83 8.26,125.04 8.27,125.04 8.63,124.68 8.63,121.26 11.34,118.55 11.96,118.55 12.3,118.9 v1(12.67,118.9) ; v1(30.02,98.74) 30.26,98.74 31.73,100.21 33.2,100.21 34.5,98.91 34.5,98.3 v1(34.49,98.29)
  IN2 w0.254: 53.31,135.83 52.5,136.64 v1(52.2,136.64) 52.42,136.87 55.36,136.87 55.45,136.77 55.36,136.68 55.36,136.18 55,135.83 53.31,135.83
  IN2 w0.508: v1(120.38,115.53) 119.15,116.76 116.76,116.76 114.6,118.92 109.08,118.92 107.03,120.97 104.9,120.97 102.26,123.61 102.26,124.61 101.45,125.43 93.79,125.43 92.84,126.38 81,126.38 80.55,126.82 80.55,129.1 79.74,129.91 73.06,129.91 70.6,132.37 70.6,132.79 70,133.39 69.89,133.39 67.3,135.99 66.37,135.99 66.03,136.34 64.88,136.34 63.83,137.39 62.2,137.39 61.66,136.84 55.86,136.84 55.79,136.77 55.45,136.77
  IN4 w0.254: v1(30.02,98.74) 30.02,98.77 30.03,98.78 30.03,99.09 29.95,99.17 29.95,101.05 30.28,101.38 30.28,104.8 29.18,105.89 29.18,109.69 28.32,110.55 28.32,111.39 27.58,112.13 27.58,112.67 27.74,112.83 27.74,113.48 v1(27.28,113.94)
  IN4 w0.508: v1(5.18,104.59) 5.18,104.6 5.83,103.95 5.83,102.87 6.53,102.16 6.53,98.55 9.28,95.8 12.46,95.8 12.8,95.47 19.92,95.47 21.02,94.37 23.35,94.37 24.57,95.59 25.56,95.59 26.19,96.22 26.96,96.22 27.39,96.65 29.73,96.65 30.02,96.94 32.69,96.94 33.67,97.92 34.2,97.92 34.49,98.21 v1(34.49,98.29)
  BOTTOM w0.254: v1(12.67,118.9) 12.67,118.89 12.76,118.97 15.91,118.97 16.09,118.8 17.4,118.8 18.39,117.81 25.17,117.81 25.65,117.32 26.63,117.32 27.24,117.93 v1(27.29,117.93)
  BOTTOM w0.508: v1(120.38,115.53) 122.5,115.53 125.28,118.31 125.28,119.38 127.01,121.11 127.01,129.04 118.54,137.52 118.54,144.34 117.42,145.45 117.42,147.16 118.06,147.79 118.06,150.55 118.43,150.91 118.43,158.28 117.02,159.69 117.02,160.32 v4(115.59,161.75) 114.43,162.91 v1(114.43,163.13) ; RH248.1 6.25,118.92 4.93,117.6 4.93,108.27 5.18,108.01 v1(5.18,104.59) ; v1(27.28,113.94) 27.59,113.94 CH69.1 ; v1(28.1,117.14) 28.05,117.09 CH68.1 ; v1(17.44,143.55) 17.44,141.75 15.45,139.76 12.99,139.76 v1(12.71,139.48) ; v1(25.63,114.75) 25.65,114.73 CH67.1
  vias: v1(17.44,144.18) v1(18.07,144.18) v1(18.07,143.55) v1(18.07,142.91) v1(18.71,144.18) v1(18.71,143.55) v1(18.71,142.91) v1(27.26,117.14) v1(27.29,115.48) v1(27.28,114.72) v1(28.07,117.98) v1(28.91,117.98) v1(28.88,117.14) v1(29.72,117.26) v1(49.11,135.75) v1(49.3,136.36) v1(49.76,135.74) v1(50.01,136.34) v1(50.71,136.42) v1(50.65,135.74) v1(51.29,135.76) v1(52.12,135.74)
+1.05V_M_VCCSUS: length 29.6
  TOP w0.254: UH4.V19 26.06,113.44 v1(25.66,113.04) 25.63,113.04 25.28,112.69 UH4.T17
  IN1 w0.254: v1(8.7,117.74) 8.66,117.78 8.32,117.78 7.35,116.82 7.35,115.9 7.01,115.56 7.01,114.31 7.59,113.73 9.27,113.73 10.04,112.95 10.04,112.34 10.48,111.91 13.19,111.91 14.43,113.14 17.99,113.14 18.76,113.91 19.48,113.91 19.48,113.9 19.88,113.9 19.89,113.91 21.48,113.91 21.49,113.9 21.89,113.9 21.9,113.91 22.14,113.91 22.15,113.9 22.55,113.9 22.56,113.91 22.79,113.91 22.8,113.9 23.43,113.9 23.45,113.88 24.08,113.88 24.09,113.87 24.45,113.87 25.28,113.04 v1(25.66,113.04)
  BOTTOM w0.254: v1(25.66,113.04) 25.66,113.04 25.65,113.04 25.01,113.04 CH83.1 ; RH248.2 8.18,118.42 8.05,118.29 8.05,117.87 v2(8.16,117.75) 8.69,117.75 v1(8.7,117.74)
+1.5V_MEM: length 225.6
  TOP w0.356: JDIMM1.93 144.44,50.5 145.22,51.29 v1(145.22,53.37) ; JDIMM1.76 133.75,45.4 133.23,44.88 v1(133.23,44.56) ; JDIMM3.76 147.98,45.4 146.52,43.95 146.52,43.78 ; v1(145.92,47.51) 145.92,48.3 146.62,49 JDIMM3.88 ; JDIMM1.82 133.2,47.2 132.46,46.46 v1(132.46,44.56) ; v1(144.59,47.47) 144.59,48.21 144.1,48.7 JDIMM1.87 ; v1(146,58.8) 146,58.8 146.34,58.8 147.14,58 JDIMM3.118 ; JDIMM1.118 133.58,58 132.36,59.23 v1(132.36,60.08) ; v1(159.28,55.9) JDIMM3.111 ; JDIMM3.105 157.29,54.09 159.33,54.09 159.33,54.1 159.46,54.22 ; JDIMM1.124 133.31,59.8 133.03,60.07 v1(133.03,60.08) ; 132.74,49.59 133.33,49 JDIMM1.88 ; JDIMM1.75 144.32,45.1 144.55,44.87 v1(144.55,43.83) ; JDIMM1.111 144.52,55.9 v1(144.6,55.82) ; v1(158.79,50.5) JDIMM3.93 ; v1(144.5,58.87) 144.5,59.12 144.12,59.5 JDIMM1.123 ; JDIMM3.99 159.3,52.3 v1(159.42,52.43) ; JDIMM3.117 158.62,57.7 158.96,57.35 ; v1(145.24,47.49) 145.24,47.22 144.92,46.9 JDIMM1.81 ; v1(151.39,59.21) 151.39,59.22 151.39,59.45 151.04,59.8 JDIMM3.124 ; 146.51,47.5 146.51,47.53 146.84,47.2 JDIMM3.82 ; v1(159.08,45.1) JDIMM3.75 ; JDIMM3.100 147.46,52.6 v1(146.7,53.37) 147.73,54.4 JDIMM3.106 ; JDIMM1.94 134.84,50.75 132.96,50.75 v1(132.65,51.05) ; JDIMM3.123 158.22,59.5 158.48,59.25 158.62,59.25 158.65,59.21 159.11,59.21 159.15,59.25 159.23,59.25 159.64,59.66 v1(159.64,59.77) ; v1(158.85,48.7) JDIMM3.87 ; v1(131.88,51.05) 131.88,51.22 133.25,52.6 JDIMM1.100 ; v1(145.97,53.36) 145.97,52.02 147.19,50.8 JDIMM3.94 ; JDIMM1.106 133.6,54.4 132.49,55.51 v1(132.49,56.22) 132.51,56.2 JDIMM1.112 ; v1(158.99,46.9) JDIMM3.81 ; JDIMM1.99 144.04,52.3 144.55,52.81 v1(144.55,53.37) 144.55,53.82 144.27,54.1 JDIMM1.105 ; JDIMM1.117 144.42,57.7 ; JDIMM3.112 147.77,56.2 147.5,55.94 145.98,55.94 145.94,55.9
  TOP w0.508: v1(117.26,69.39) 117.26,67.91 CC82.1 ; RC78.1 114.94,75.81 v1(115.02,75.9) ; v1(132.6,29.96) 132.52,30.04 RD4.1
  IN4 w0.508: v1(115.02,75.9) 115.7,75.22 115.7,72.11 117.26,70.55 v1(117.26,69.39) ; v1(132.6,29.96) 134.17,29.96 135.11,30.9 135.11,42.68 v1(133.23,44.56)
  BOTTOM w0.305: JDIMM4.118 156.17,58 155.94,58.23 155.31,58.23 154.89,57.81 v1(154.89,57.44)
  BOTTOM w0.356: JDIMM4.111 145.36,55.9 v1(145.35,55.91) ; JDIMM2.112 144.16,56.2 144.42,55.94 144.47,55.94 v1(144.6,55.82) ; JDIMM2.100 144.24,52.6 144.55,52.91 v1(144.55,53.37) 144.55,54.06 144.21,54.4 JDIMM2.106 ; JDIMM2.111 133.86,55.9 133.46,56.31 132.58,56.31 v1(132.49,56.22) ; JDIMM2.118 144.43,58 v1(145.22,58.79) ; JDIMM4.123 146.68,59.5 146,58.82 v1(146,58.8) 146,58.79 147.09,57.7 JDIMM4.117 ; JDIMM4.94 158.49,50.8 v1(158.79,50.5) ; JDIMM2.82 144.04,47.2 144.37,46.86 145.01,46.86 145.24,47.09 v1(145.24,47.49) ; v1(144.55,43.83) 144.55,44.98 144.13,45.4 JDIMM2.76 ; JDIMM4.87 147.66,48.7 146.51,47.55 146.51,47.53 147.14,46.9 JDIMM4.81 ; JDIMM2.88 144.32,49 144.59,48.74 v1(144.59,47.47) ; 132.61,48.4 132.91,48.7 JDIMM2.87 ; v1(131.88,51.05) 131.88,51.15 133.03,52.3 JDIMM2.99 ; JDIMM4.100 159.25,52.6 v1(159.42,52.43) ; JDIMM2.105 133.76,54.1 132.57,55.28 132.26,55.28 ; JDIMM2.81 133,46.9 132.46,46.36 v1(132.46,44.56) ; v1(133.23,44.56) 133.33,44.65 133.36,44.65 133.36,44.78 133.68,45.1 JDIMM2.75 ; JDIMM2.93 133.2,50.5 v1(132.65,51.05) ; JDIMM4.93 147.54,50.5 146.7,51.34 v1(146.7,53.37) ; JDIMM4.88 158.55,49 v1(158.85,48.7) ; v1(158.99,46.9) 158.69,47.2 JDIMM4.82 ; JDIMM2.94 144.6,50.8 145.15,51.35 145.15,53.29 v1(145.22,53.37) ; 144.75,59.5 144.45,59.8 JDIMM2.124 ; JDIMM4.124 154.05,59.8 153.93,59.67 153.93,59.34 154.05,59.21 v1(154.18,59.21) ; JDIMM4.75 147.51,45.1 146.52,44.11 146.52,43.78 ; v1(132.36,60.08) 132.36,59.25 133.91,57.7 JDIMM2.117 ; JDIMM4.76 158.78,45.4 v1(159.08,45.1) ; v1(151.16,53.14) 151.16,52.43 151.03,52.3 JDIMM4.99 ; 145.63,54.1 JDIMM4.105
  BOTTOM w0.381: v1(159.42,54.22) 159.24,54.4 JDIMM4.106 ; JDIMM2.123 133.2,59.5 ; v1(159.28,55.9) 158.98,56.2 JDIMM4.112
  BOTTOM w0.508: CD47.1 v1(160.83,47.05)
  vias: v1(121,58.41) v1(121.52,57.94) v1(122.02,57.47) v1(122.5,56.95) v1(122.74,55.87) v1(122.96,56.49) v1(123.4,55.88) v1(123.47,54.61) v1(124.7,53.32) v1(125.37,53.32) v1(126.01,53.32) v1(126.67,53.32) v1(128.07,53.32) v1(128.28,60.91) v1(129.6,64.87) v1(130.1,53.32) v1(132,53.32) v1(136.75,52.42) v1(136.91,58.35) v1(137.76,54.35) v1(137.76,50.78) v1(137.77,48.58) v1(137.76,46.83) v1(137.79,45.14) v1(137.89,43.22) v1(138.18,58.35) v1(138.65,56.64) v1(139.03,54.34) v1(139.03,52.42) v1(139.03,50.78) v1(139.03,46.83) v1(139.05,48.58) v1(139.06,45.14) v1(139.16,43.22) v1(139.41,60.79) v1(139.45,58.35) v1(139.92,56.64) v1(140.3,54.34) v1(140.3,50.78) v1(140.32,48.88) v1(140.3,46.83) v1(140.33,45.17) v1(140.43,43.22) v1(140.68,60.79) v1(140.72,58.35) v1(141.32,52.42) v1(151.54,43.15) v1(151.59,55.12) v1(151.97,50.83) v1(152.04,48.78) v1(152.04,47.12) v1(152.3,44.71) v1(152.66,59.21) v1(153.11,55.12) v1(153.06,43.15) v1(153.24,50.83) v1(153.31,48.78) v1(153.31,47.12) v1(153.37,57.44) v1(153.44,53.14) v1(153.57,44.71) v1(154.51,50.83) v1(154.64,55.12) v1(154.58,48.78) v1(154.58,47.12) v1(154.58,43.15) v1(155.73,53.14) v1(160.17,57.9) v1(160.77,49.34) v1(160.86,45.02) v1(161.17,59.77) v1(161.71,52.43) v1(162.69,59.77) v1(164.31,54.01) v1(164.51,61.35) v1(164.51,60.72) v1(164.51,60.08) v1(164.51,59.45) v1(164.51,58.81) v1(164.51,58.18) v1(164.6,57.3) v1(164.69,49.29) v1(164.65,44.98) v1(165.15,61.35) v1(165.15,60.72) v1(165.15,60.08) v1(165.15,59.45) v1(165.15,58.81) v1(165.15,58.18) v1(165.78,61.35) v1(165.78,60.72) v1(165.78,60.08) v1(165.78,59.45) v1(165.78,58.81) v1(165.78,58.18) v4(203.35,65.32)
+1.05V_MP: length 26.8
  TOP w0.102: 9.17,139.69 9.17,138.57 v2(8.53,137.94)
  TOP w0.254: PR407.1 3.4,157.37 3.08,157.68 1.84,157.68 v1(1.41,157.25)
  IN2 w0.254: v1(1.41,157.25) 7.38,157.25 10.13,154.5 10.13,142.3 v1(10.01,142.18)
+1.05V_RUN: length 113.7
  TOP w0.203: UH4.AN34 33.38,120.72 33.07,120.41 32.99,120.41 v1(32.97,120.38) 32.99,120.36 32.99,120.33 33.32,120.01 UH4.AN33 ; v1(30.55,112.36) 30.49,112.36 30.15,112.69 UH4.AF17
  TOP w0.254: v1(30.64,110.91) 30.64,110.91 30.44,110.91 UH4.AF13 ; v1(30.64,110.91) 31.05,111.32 UH4.AH14 ; v1(30.64,110.91) 30.24,111.32 UH4.AF14 ; v1(28.91,112.34) 28.91,112.25 28.59,111.93 UH4.AC16 ; v1(28.91,112.34) 28.55,112.69 UH4.AC17 ; v1(28.91,112.34) 29.26,112.69 UH4.AD17 ; UH4.AL29 32.57,118.36 32.17,117.96 v1(32.11,117.96) ; v1(30.55,120.4) 30.92,120.77 UH4.AG34 ; v1(30.55,120.4) 30.15,120.01 UH4.AF33 ; v1(30.55,120.4) 30.2,120.74 UH4.AF34 ; v1(34.37,117.34) 34.37,117.49 34.03,117.84 UH4.AP26 ; v1(34.37,117.34) 33.61,117.34 UH4.AN27 ; v1(34.37,117.34) 34.37,117.18 34.04,116.85 UH4.AP24 ; UH4.AT24 34.7,116.06 v1(34.35,116.41) 34.28,116.33 33.8,116.33 UH4.AN26 ; UH4.AN19 33.39,113.51 UH4.AP17 34.01,113.05 v1(34.3,113.34) ; UH4.AN16 33.15,112.16 33.15,112.46 UH4.AN17 33.38,112.81 33.08,113.11 v1(32.97,113.11) 32.97,113.83 32.93,113.87 v1(32.93,113.92) 32.98,113.92 UH4.AN21 33.38,114.34 33.9,114.86 UH4.AP21 34.01,115.03 34.31,115.35 v1(34.38,115.35) 34.35,115.38 34.27,115.38 34.01,115.61 UH4.AP23 ; v1(30.63,110.28) 30.71,110.28 31.07,110.64 UH4.AH13 ; UH4.AG33 30.62,119.69 30.58,119.69 v1(30.53,119.63)
  TOP w0.508: v1(50.15,116.18) 50.07,116.1 50.07,115.76 49.44,115.13 RH247.1 LH3.1 49.39,117.91 48.84,118.45 48.84,118.94 48.4,119.38 47.19,119.38 47.1,119.29 RH111.1 ; RH200.1 32.83,133.15 LH6.1 34.9,133.34 35.24,133.68 35.24,134.06 35.57,134.39 v1(35.69,134.39) ; LH5.2 36.33,99.64 36.51,99.47 39.62,99.47 v1(39.84,99.68) 40.05,99.47 40.85,99.47 42.04,100.65 RH195.1 ; v1(27.43,133.85) 27.43,133.57 28,132.99 28,132.66 RH100.2
  IN1 w0.381: v1(29.73,115.49) 29.73,115.53 28.94,116.32 28.18,116.32 27.93,116.57 27.02,116.57 26.1,117.5 25.75,117.5 24.92,118.34 v1(24.29,118.34)
  IN2 w0.254: v1(30.53,119.63) 32.29,119.63 32.83,119.1 33.59,119.1 33.78,118.91 37.35,118.91 37.45,118.81 40.83,118.81 41.71,117.93 45.1,117.93 46.1,116.93 48.33,116.93 49.72,115.55 50.62,115.55 50.66,115.58 v1(50.71,115.58)
  IN2 w0.457: v1(30.55,120.4) 31.11,120.97 33.21,120.97 33.55,120.63 33.55,120.21 33.55,119.89 33.97,119.47 36.64,119.47 37.12,119.95 40.54,119.95 41.98,118.5 45.48,118.5 46.52,117.46 48.84,117.46 50.13,116.18 v1(50.15,116.18)
  BOTTOM w0.508: CH79.1 34.71,116.73 34.39,116.41 v1(34.35,116.41) ; CH31.1 31.12,120.98 31.35,120.75 v1(31.35,120.35) ; CH47.1 33.12,112.96 v1(32.97,113.11) ; v1(29.73,114.76) 29.86,114.63 CH33.1 ; R925.1 46.54,132.14 v4(47.25,132.85) v1(47.92,133.52) ; CH96.1 30.59,119.57 v1(30.53,119.63) ; v1(31.34,117.21) 31.31,117.18 CH45.1 ; RH40.2 29.92,109.74 RH42.2 29.98,110.28 v1(30.63,110.28) ; CH82.1 28.44,111.76 28.7,112.01 28.7,112.13 v1(28.91,112.34) ; v1(30.55,120.4) 29.98,120.4 CH81.1 ; CH32.1 28.54,119.44 29.69,119.44 30.29,118.84 CH77.1 30.57,118.41 v1(30.57,117.98) ; CH48.1 24.64,118.68 v1(24.29,118.34) ; v1(32.97,120.38) 33.27,120.69 CH30.1 ; CH46.1 31.29,115.48 v1(31.35,115.54) ; RH205.1 35.22,133.92 v1(35.69,134.39) ; CH56.1 23.93,116.46 24.34,116.87 v1(24.34,117.3) ; CH44.1 34.37,119.01 v1(34.37,117.34)
  vias: v1(28.91,114.76) v1(30.56,115.52) v1(30.56,114.7) v1(30.56,113.94) v1(31.32,113.94) v1(31.35,117.98) v1(48.41,134.16) v1(48.55,133.52) v1(49.05,134.16) v1(49.19,133.52) v1(49.68,134.16) v1(49.82,133.52) v1(50.32,134.16) v1(50.46,133.52) v1(50.95,134.16)
+1.5V_RUN: length 388.5
  TOP w0.254: U12.26 33.44,147.64 33.52,147.56 34.6,147.56 C436.1 ; U12.9 28.32,150.51 27.86,150.97 27.86,151.23 27.56,151.54 27.23,151.54 v1(27.16,151.6) ; U12.19 29.82,145.45 29.92,145.35 29.92,144.65 29.83,144.56 v1(29.83,144.54) ; v1(33.98,148.83) 33.79,148.64 U12.28 ; U12.11 26.46,148.64 25.04,150.06 v1(25.04,151.05) ; v1(25.11,147) 25.2,146.91 25.91,146.91 26.63,147.64 U12.13
  TOP w0.356: JIO1.76 35.03,23.35 v1(34.73,23.05) 35.03,22.75 JIO1.78
  TOP w0.508: C609.1 11.06,150.29 v1(11.92,151.16) ; C436.1 34.64,148.13 34.48,148.3 v1(34.47,148.3) ; C620.1 v1(23.98,150.94) 23.98,148.31 24.14,148.15 24.71,148.15 24.98,147.88 24.98,147.13 v1(25.11,147) ; v1(179.44,96.7) 179.44,96.72 179.73,97.02 179.73,98.06 178.83,98.96 178.83,100.85 179.49,101.51 v1(179.49,101.66) ; R785.1 35.66,153.76 v1(35.34,154.08) ; v1(31.22,151.54) 31.34,151.66 C435.1 ; v1(109.52,162.9) 109.52,162.55 109.35,162.37 C594.1
  IN1 w0.508: v1(179.35,93.88) 179.2,94.03 179.2,96.46 v1(179.44,96.7)
  IN2 w0.508: v1(112.16,153.7) 112.15,153.7 111.54,154.31 v1(109.62,154.31) ; v1(18.36,88.44) 14.86,88.44 10.91,92.39 8.24,92.39 5.18,95.45 5.18,103.69 3.9,104.97 3.53,104.97 1.98,106.52 1.98,122.47 2.77,123.25 2.77,124.1 2.04,124.82 2.04,134.61 1.95,134.7 1.95,136.31 4.55,138.91 7.57,138.91 8.2,139.55 9.68,139.55 11.77,141.64 11.78,141.64 12.41,142.27 12.41,143.45 12.88,143.92 12.88,147.5 13.99,148.62 16.06,148.62 19.28,151.83 23.34,151.83 23.98,151.19 v1(23.98,150.94)
  IN2 w0.762: v1(35.34,154.08) 35.44,153.98 38.73,153.98 39.18,154.42 42.3,154.42 44.07,156.19 46.87,156.19 47.2,156.52 52.92,156.52 53.66,157.25 53.66,157.76 54.66,158.76 59.18,158.76 59.5,159.08 60.59,159.08 62.04,160.53 63.98,160.53 64.63,159.88 67.19,159.88 67.55,160.24 74.27,160.24 75.64,158.86 75.64,156.45 82.9,149.19 108.35,149.19 109.18,148.36 110.08,148.36
  IN3 w0.508: 188.89,95.92 187.86,96.95 v1(187.79,96.95) ; 188.89,95.92 190.19,95.92 190.77,96.5 190.77,99.02 193.11,101.36 195.76,101.36 v1(196.49,100.62) 197.09,100.62 ; 188.89,95.92 187.64,94.68 180.15,94.68 v1(179.35,93.88)
  IN4 w0.508: v1(25.11,147) 25.17,146.94 25.17,146.81 26.38,145.61 27.19,145.61 28.64,144.16 29.36,144.16 29.74,144.54 v1(29.83,144.54) ; v1(34.73,23.05) 34.73,27.24 34.11,27.86 34.11,31.41 34.56,31.85 34.56,40.92 33.78,41.7 33.78,44.67 31.42,47.03 31.42,47.95 27.37,52 27.37,56.67 22.23,61.82 13.4,61.82 11.28,63.95 11.28,71.95 14.26,74.93 14.26,76.48 18.26,80.48 18.26,82.54 17.77,83.03 17.77,87.85 v1(18.36,88.44) 19.4,89.48 19.42,89.48 19.66,89.73 21.5,89.73 25.61,93.84 26.41,93.84 26.6,94.03 27.51,94.03 27.82,94.35 32.14,94.35 32.93,95.14 33.96,95.14 34.81,95.99 v1(34.81,96.36)
  BOTTOM w0.254: RH211.2 27.96,104.13 28.43,103.66 28.87,103.66 29.54,104.33 31.93,104.33 32.57,103.68 32.57,102.5 34.43,100.65 34.43,99.07 35.06,98.44 35.06,96.61 v1(34.81,96.36)
  BOTTOM w0.508: v1(196.49,100.62) 196.89,101.02 197.03,101.02 197.99,101.98 C601.1 ; JMINI1.28 109.56,154.25 v1(109.62,154.31) ; v1(187.79,96.95) 187.87,96.95 188.29,97.37 JMINI2.28 ; JMINI4.48 31.64,150.67 31.22,151.09 v1(31.22,151.54) ; JMINI2.6 200.29,97.66 199.8,97.18 v1(199.66,97.18) ; JMINI4.28 23.64,150.43 23.98,150.77 v1(23.98,150.94) ; JMINI4.6 11.64,150.87 v1(11.92,151.16) ; v1(33.98,148.83) 33.98,150.47 35.34,151.83 v1(35.34,154.08) ; C724.1 35.68,23.19 34.87,23.19 v1(34.73,23.05) ; v1(179.49,101.66) 179.51,101.66 179.55,101.7 C602.1 180.29,101.59 JMINI2.48
  vias: v1(109.49,142.32) v1(109.52,141.67) v1(110.17,142.35) v1(110.2,141.68) v1(110.4,165.55) v1(110.4,164.86) v1(110.69,149.7) v1(110.69,149.05) v1(111.14,165.56) v1(111.14,164.83) v1(111.85,149.05) v1(111.95,149.68) v1(172.32,161.21) v1(172.97,161.18) v1(173.67,161.18) v1(174.34,161.14) v1(191.24,152.29) v1(191.15,151.61) v1(191.88,152.3) v1(192.54,152.29) v1(196.14,76.07) v1(196.15,75.34) v1(196.84,76.11) v1(196.87,75.31) v1(198.82,105.58) v1(198.88,104.2) v1(199.45,105.58) v1(199.52,104.23) v4(185.02,151.3)
+1.5V_RUN_CHG: length 2.5
  BOTTOM w0.102: v2(191.01,149.52) 190.53,149.99 Q68.1
  BOTTOM w0.508: R924.2 191.84,150.43 Q68.1
+1.05V_RUN_CHG: length 3.2
  BOTTOM w0.102: Q70.1 43.03,131.82 v2(42.52,132.33)
  BOTTOM w0.508: R925.2 44.44,132.54 43.81,132.54 43.53,132.26 Q70.1
+1.05V_RUN_ENABLE: length 11
  TOP w0.508: Q63.4 51.28,131.39 v2(50.53,130.65) 48.93,130.65 C773.1 47.82,129.54 46.87,129.54 R930.2 46.82,129.58 R1611.1 45.25,129.3 45.39,129.3 45.62,129.07 45.62,128.21 45.38,127.97 45.34,127.97 44.92,127.54 Q304.3
+1.05V_RUN_VCCA_A_DPL: length 10.4
  TOP w0.254: v1(39.54,126.95) 39.51,126.95 39.18,127.27 UH4.BD47
  TOP w0.508: LH6.2 35.55,131.65 36.44,132.55 CH94.1 37.69,131.7 38.06,131.33 v1(38.06,131)
  BOTTOM w0.508: v1(39.54,126.95) 39.05,127.44 CH92.1 38.54,127.54 38.06,128.02 v2(38.06,128.49) v1(38.06,131)
+1.05V_RUN_VCCA_B_DPL: length 10.2
  TOP w0.254: UH4.BF47 40.07,127.34 v1(39.72,127.69)
  TOP w0.508: LH7.2 43.26,131.65 42.36,132.55 CH95.1 40.99,131.74 v1(40.32,131.06)
  BOTTOM w0.508: CH93.1 39.93,127.48 v1(39.72,127.69) 39.72,128.94 v2(40.68,129.9) 40.68,130.71 v1(40.32,131.06)
+1.05V_RUN_VCCCLKDMI: length 20.6
  TOP w0.254: UH4.AB36 28.29,121.38 28.59,121.68 v1(28.66,121.68)
  IN3 w0.508: v1(28.66,121.68) 28.92,121.68 29.26,122.02 29.26,130.31 30.27,131.32 33.27,131.32 33.73,130.86 v1(34.82,130.86)
  BOTTOM w0.508: v1(34.82,130.86) 34.09,130.86 v2(33.89,131.05) 33.56,131.38 CH106.1 RH205.2 ; CH50.1 28.13,121.16 v1(28.66,121.68)
+1.05V_RUN_VTT: length 586.8
  TOP w0.254: v1(35.08,114.31) 34.7,113.94 UH4.AT20 ; v1(35.76,114.31) 35.74,114.29 35.74,114.22 UH4.AU20 ; v1(42.12,107.19) 42.12,107.28 41.48,107.92 UH4.BJ8
  TOP w0.356: JCPU1.Y10 89.98,60.45
  TOP w0.508: PC740.2 18.68,77.95 v1(18.26,77.53) ; v1(69.11,89.08) 69.11,87.69 71.42,85.37 72.13,85.37 v1(72.58,84.93) 72.58,84.3 72.48,84.2 72.48,83.88 v1(72.43,83.83) 71.84,83.83 71.16,84.52 69.96,84.52 69.45,84.01 v1(68.96,84.01) 68.54,84.43 67.04,84.43 66.6,84.87 66.6,85.97 v1(66.43,86.14) RC49.1 ; R862.2 177.38,155 v1(177.51,155.13) ; RC63.1 61.86,83.88 v1(62.01,83.72) ; v1(122.81,105) 122.81,106.12 125.48,108.8 127.25,108.8 133.48,102.57 138.85,102.57 142.9,98.51 v1(142.91,98.51) ; v1(86.22,34.78) 85.19,34.78 84.94,35.04 RC20.2 ; JCPU1.J23 77.9,49.95 78.75,50.8 79.03,50.8 79.37,51.14 79.58,51.14 80.72,52.27 84.16,52.27 v1(84.95,51.49) ; R399.1 v1(150.39,168.94) ; v1(89.84,34.71) 89.86,34.74 90.62,34.74 RC70.1 ; R1179.1 177.73,149.92 177.96,150.15 v1(177.96,150.31) ; v1(76.92,98.4) 76.86,98.46 76.86,98.74 76.81,98.79 76.81,100.06 77.11,100.37 77.11,104.1 79.01,105.99 79.01,109.46 80.07,110.53 v1(80.07,110.5) 80.05,110.53 80.05,112.22 80.48,112.65 80.97,112.65 v1(81.72,113.4) ; v1(158.2,122.77) 158.58,123.15 158.58,125.68 156.79,127.47 156.79,131.93 152.79,135.93 152.32,135.93 150.15,138.1 150.15,143.89 148.74,145.3 148.74,146.53 144.99,150.28 v1(144.99,151.16) ; RC1.2 82.9,34.98 v1(82.45,34.53) ; PC1150.1 v1(89.64,52.13) ; CC66.1 76.71,92.61 v1(76.44,92.34) 76.69,92.09 CC67.1 76.69,90.27 RC38.2 76.71,90.11 77.87,88.95 77.87,85.8 77.65,85.57 v5(77.16,85.57) ; PR732.1 v1(18.93,75.28)
  IN1 w0.508: v1(76.92,98.4) 76.92,98.88 76.59,99.21 75.81,99.21 75.29,98.69 74.57,98.69 73.15,97.27 73.15,97.17 72.29,96.3 70.17,96.3 66.93,93.07 66.93,90.53 65.33,88.93 65.33,87.24 v1(66.43,86.14) ; v1(62.01,83.72) 62.62,83.72 63.53,82.81 v1(63.53,80.88) 63.54,80.87 63.54,79.63 63.19,79.28 63.19,78.03 v1(63.61,77.62) 63.65,77.58 63.65,76.16 61.44,73.95 61.44,69.34 60.04,67.95 60.04,47.38 61.97,45.45 61.97,42.65 64.53,40.09 64.53,38.42 64.72,38.23 v1(64.86,38.23)
  IN2 w0.089: 82.73,44.81 82.88,44.67
  IN2 w0.508: v1(68.96,84.01) 68.44,84.53 65.33,84.53 63.77,82.98 63.77,81.94 63.5,81.67 63.5,80.91 v1(63.53,80.88) ; v1(122.81,105) 122.81,105.07 121.77,106.11 103.37,106.11 99.67,109.81 99.67,110.82 98.78,111.71 93.9,111.71 92.44,113.17 81.94,113.17 81.72,113.39 v1(81.72,113.4) ; v1(66.43,86.14) 66.64,86.34 66.64,88.01 67.7,89.08 v1(69.11,89.08) 69.6,89.57 73.84,89.57 75.3,88.11 76.8,88.11 77.28,88.6 77.28,91.45 76.48,92.25 76.48,92.3 v1(76.44,92.34) ; v1(20.55,75.3) 20.55,75.62 20.12,76.05 19.56,76.05 18.93,75.42 v1(18.93,75.28) 18.39,74.74 18.08,74.74 17.44,75.39 17.44,77.18 17.79,77.53 v1(18.26,77.53) ; v1(80.07,110.5) 80.02,110.45 79.06,110.45 77.99,111.52 74.73,111.52 71.35,108.14 63.87,108.14 61.27,110.74 51.34,110.74 50.63,110.03 47.15,110.03 45.03,107.91 42.84,107.91 v1(42.12,107.19)
  IN3 w0.508: v1(177.96,150.31) 177.58,149.92 176.92,149.92 176.54,150.31 176.54,154.17 v1(177.51,155.13) 177.51,159.97 177.18,160.3 177.18,163.7 176.24,164.64 175.21,164.64 173.44,166.41 173.44,170.82 174.59,171.96 174.59,172.62 173.95,173.25 170.09,173.25 169.28,172.44 164.49,172.44 160.99,168.94 v1(150.39,168.94) 148.89,170.43 145.77,170.43 144.36,171.84 143.11,171.84 139.85,168.58 139.85,163.61 141.16,162.31 142.06,162.31 144.58,159.79 144.58,155.07 144.23,154.72 144.23,152.91 144.99,152.15 v1(144.99,151.16)
  BOTTOM w0.254: v1(35.76,114.31) 35.76,114.45 36.14,114.83 40.82,114.83 41.24,115.25 41.35,115.14 41.35,114.1 41.06,113.81 36.79,113.81 36.33,113.35 CH49.1
  BOTTOM w0.305: v1(76.44,92.34) 76.44,92.23 76.15,91.94 JXDP1.16
  BOTTOM w0.508: v1(69.11,89.08) 69.05,89.14 RC42.2 ; RC15.1 64.58,77.25 64.21,77.62 v1(63.61,77.62) 63.57,77.66 RC65.1 ; 41.24,115.25 41.24,116.88 41.74,117.39 44.88,117.39 CH85.1 44.31,116.36 42.8,116.36 42.14,115.7 42.14,114.62 42.86,113.89 42.86,108.56 ; CH87.1 CH86.1 42.7,108.72 42.86,108.56 ; CH49.1 35.88,113.72 35.76,113.84 v1(35.76,114.31) v1(35.08,114.31) ; RC41.2 72.38,83.78 v1(72.43,83.83) 72.12,83.83 71.18,84.77 RC14.1 ; 78.42,37.31 76.88,38.85 65.87,38.85 65.25,38.23 v1(64.86,38.23) 64.31,37.68 59.54,37.68 57.19,40.03 43.36,40.03 41.86,38.53 40.66,38.53 39.62,39.57 39.62,42.96 31.6,50.99 31.6,57.52 17.38,71.73 17.38,73.74 v1(18.93,75.28) ; v1(142.91,98.51) 143.8,99.4 155.12,99.4 156.39,100.67 156.39,115.65 156.88,116.14 156.88,121.45 v1(158.2,122.77) ; v1(20.55,75.3) 20.55,75.49 21.07,76.01 PR745.2 PR743.2 PR737.2 ; RC16.1 65.97,85.1 65.97,85.68 v1(66.43,86.14) ; PC1150.1 v1(89.64,52.13) ; 42.86,108.56 42.86,107.93 v1(42.12,107.19) 41.27,106.34 41.27,104.23 41.76,103.74 RH262.1 ; v5(77.16,85.57) 77.58,85.57 78.21,86.2 RC43.2
  vias: v1(77.19,25.08) v1(77.19,24.45) v1(80.02,20.06) v1(80.03,19.42) v1(80.66,20.06) v1(80.67,19.42) v1(83.32,42.96) v1(83.36,43.95) v1(84.33,46.95) v1(84.33,45.93) v1(84.43,29.4) v1(84.43,27.37) v1(84.43,25.34) v1(84.68,20.13) v1(84.68,19.5) v1(85.29,46.92) v1(85.33,44.94) v1(85.32,20.13) v1(85.32,19.5) v1(85.37,45.93) v1(86.43,49.92) v1(86.42,47.92) v1(86.43,46.92) v1(86.42,44.94) v1(86.41,43.95) v1(86.41,42.96) v1(86.44,48.92) v1(87.32,49.92) v1(87.31,48.92) v1(87.31,46.92) v1(87.29,45.96) v1(87.27,43.95) v1(87.27,42.96) v1(87.48,59.5) v1(87.48,57.47) v1(87.48,55.31) v1(87.48,53.15) v1(87.48,51.12) v1(87.7,67.4) v1(87.7,40.75) v1(88.3,49.92) v1(88.28,48.92) v1(88.31,47.93) v1(88.31,46.92) v1(88.31,45.93) v1(88.31,44.94) v1(88.31,43.95) v1(88.31,42.96) v1(88.31,41.99) v1(88.37,40.82) v1(89,59.5) v1(89.33,58.74) v1(89.25,57.21) v1(89.33,49.92) v1(89.33,48.92) v1(89.33,47.93) v1(89.33,46.92) v1(89.33,45.93) v1(89.33,44.94) v1(89.33,43.95) v1(89.33,42.96) v1(89.34,41.97) v1(89.51,40.85) v1(89.64,56.45) v1(89.64,54.29) v1(89.76,38.55) v1(89.76,36.51) v1(89.76,20.13) v1(89.76,19.5) v1(90.02,29.4) v1(90.02,27.37) v1(90.02,25.34) v1(90.18,64.02) v1(90.4,20.13) v1(90.4,19.5) v4(78.32,33.34) v5(85.35,43.95) v5(85.35,41.97) v5(89.25,55.44) v5(89.92,50.98)
