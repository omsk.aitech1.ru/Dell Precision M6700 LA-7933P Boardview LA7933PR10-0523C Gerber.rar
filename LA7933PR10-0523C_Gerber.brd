# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PECI_EC_R: length 6.4
  TOP w0.102: U54.A48 172.56,150.88 172.63,150.95 172.63,151.24 172.69,151.31 172.91,151.31 172.97,151.24 172.97,150.98 173.07,150.88 173.23,150.88 173.35,151 173.35,151.35 173.71,151.7 173.82,151.7 173.97,151.55 174.14,151.55 174.31,151.72 174.31,151.9 174.17,152.04 174.17,152.16 v2(174.37,152.36) 174.45,152.44 174.58,152.44 174.69,152.33 174.87,152.33 175.05,152.51 175.05,152.69 174.96,152.78 174.96,152.96 175.14,153.14 175.48,153.14 R863.1
PEG_B_CLKRQ#: length 7.8
  TOP w0.102: UH4.E6 20.07,106.81 19.76,106.5 v1(19.76,106.49)
  BOTTOM w0.102: v1(19.76,106.49) 19.56,106.29 19.3,106.03 19.3,106.03 19.05,105.78 17.88,105.78 v2(15.78,103.68) 14.29,102.19 RH98.2
PEG_COMP: length 8.9
  TOP w0.102: v1(82.02,51.12) 80.95,51.12 79.97,50.14 79.64,50.14 78.95,49.45 JCPU1.J22 JCPU1.H22
  TOP w0.305: v3(81.38,50.55) 81,50.55 JCPU1.J21
  BOTTOM w0.254: v1(82.02,51.12) 82.51,51.12 RC2.2 82.3,50.55 v3(81.38,50.55)
PEG_CRX_GTX_C_N0: length 12.5
  TOP w0.109: CC1.1 186.95,123.64 v1(187.92,123.64) 189.46,123.64 189.48,123.66 190.08,123.66 190.1,123.64 191.88,123.64 194.84,126.6 196.62,126.6 196.79,126.77 JMXM1.177
PEG_CRX_GTX_C_N1: length 12.6
  TOP w0.109: CC2.1 187.05,125.56 v1(187.96,125.56) 189.58,125.56 189.61,125.59 190.17,125.59 190.19,125.56 191.89,125.56 194.75,128.42 196.23,128.42 196.49,128.16 196.64,128.16 196.75,128.27 JMXM1.171
PEG_CRX_GTX_C_N2: length 12
  TOP w0.109: JMXM1.165 196.84,129.77 196.68,129.61 193.28,129.61 191.5,127.83 191.3,127.83 191.28,127.85 190.71,127.85 190.69,127.83 v1(187.78,127.83) 187.01,127.83 CC3.1
PEG_CRX_GTX_C_N3: length 12.6
  TOP w0.109: JMXM1.157 196.79,133.27 196.65,133.13 195.35,133.13 192.21,129.99 189.88,129.99 189.85,130.01 189.28,130.01 189.25,129.99 v1(187.93,129.99) 187.01,129.99 CC4.1
PEG_CRX_GTX_C_N4: length 10.9
  TOP w0.109: CC5.1 188.54,132.02 v1(189.24,132.02) 191.98,132.02 192.01,132.04 192.59,132.04 192.61,132.02 192.89,132.02 195.49,134.63 196.65,134.63 196.79,134.77 JMXM1.151
PEG_CRX_GTX_C_N5: length 10.6
  TOP w0.109: JMXM1.145 196.79,136.27 196.65,136.13 195.47,136.13 193.29,133.95 192.75,133.95 192.72,133.97 192.14,133.97 192.12,133.95 v1(189.34,133.95) 188.7,133.95 CC6.1
PEG_CRX_GTX_C_N6: length 10.4
  TOP w0.109: CC7.1 188.64,135.91 189.03,135.91 189.05,135.93 189.61,135.93 189.63,135.91 v1(191.46,135.91) 192.1,135.91 193.82,137.63 193.99,137.63 196.65,137.63 196.79,137.77 JMXM1.139
PEG_CRX_GTX_C_N7: length 10.3
  TOP w0.109: JMXM1.133 196.79,139.27 196.65,139.13 196.39,139.13 196.14,138.87 194.03,138.87 193.71,138.55 193.55,138.55 193.07,139.03 192.72,139.03 v1(192.53,138.85) 192.39,138.7 192.39,138.35 192.87,137.87 192.87,137.71 192.47,137.32 191.31,137.32 191.29,137.34 190.73,137.34 190.7,137.32 190.47,137.32 CC8.1
PEG_CRX_GTX_C_N8: length 9.9
  TOP w0.109: CC9.1 190.39,139.31 190.74,139.31 190.76,139.33 191.32,139.33 191.35,139.31 191.76,139.31 191.88,139.44 191.88,140.4 192.13,140.65 v1(192.43,140.65) 192.75,140.65 193,140.4 193,140.1 193.11,139.99 193.44,139.99 193.54,140.1 193.54,140.39 193.78,140.63 194.83,140.63 196.65,140.63 196.79,140.77 JMXM1.127
PEG_CRX_GTX_C_N9: length 10
  TOP w0.109: CC10.1 188.57,141.25 v1(189.41,141.25) 190.4,141.25 190.42,141.27 191,141.27 191.02,141.25 191.18,141.25 191.4,141.47 194.31,141.47 194.82,141.98 196.5,141.98 196.79,142.27 JMXM1.121
PEG_CRX_GTX_C_N10: length 6.8
  TOP w0.109: CC11.1 193.5,142.61 193.75,142.61 193.95,142.81 194,142.81 194.13,142.94 194.13,143.43 194.38,143.68 v1(194.7,143.68) 194.96,143.68 195.21,143.43 195.21,142.93 195.32,142.82 195.72,142.82 195.82,142.93 195.82,143.38 196.08,143.63 196.65,143.63 196.79,143.77 JMXM1.115
PEG_CRX_GTX_C_N11: length 7
  TOP w0.109: JMXM1.109 196.79,145.27 196.65,145.13 196.09,145.13 195.51,144.55 193.7,144.55 193.68,144.57 193.11,144.57 193.09,144.55 v1(192.09,144.55) 191.56,144.55 CC12.1
PEG_CRX_GTX_C_N12: length 5.2
  TOP w0.109: JMXM1.103 196.79,146.77 196.65,146.63 196.33,146.63 196.26,146.7 196.26,146.85 196.01,147.1 196.01,147.26 195.85,147.42 195.25,147.42 195.06,147.23 195.06,146.93 195.33,146.66 195.33,146.04 195.28,145.99 195.17,145.99 194.86,146.3 CC13.1
PEG_CRX_GTX_C_N13: length 6
  TOP w0.109: JMXM1.97 196.79,148.27 196.65,148.13 195.87,148.13 195.85,148.15 195.29,148.15 195.26,148.13 194.24,148.13 193.77,147.66 v1(193.18,147.66) 192.64,147.66 CC14.1
PEG_CRX_GTX_C_N14: length 3.2
  TOP w0.109: JMXM1.91 196.94,149.77 196.8,149.63 196.27,149.63 196.02,149.37 v1(195.77,149.37) 195.25,149.37 CC15.1
PEG_CRX_GTX_C_N15: length 3.1
  TOP w0.109: CC16.1 195.25,151.4 v1(195.79,151.4) 195.95,151.4 196.19,151.17 196.69,151.17 196.79,151.27 JMXM1.85
PEG_CRX_GTX_C_P0: length 12.6
  TOP w0.109: CC17.1 187.07,123.42 187.62,123.42 187.64,123.4 188.2,123.4 188.22,123.42 v1(189.8,123.42) 191.79,123.42 191.96,123.42 192.62,124.08 194.93,126.39 196.67,126.39 196.79,126.27 JMXM1.179
PEG_CRX_GTX_C_P1: length 12.6
  TOP w0.109: CC18.1 186.96,125.35 187.66,125.35 187.68,125.33 188.24,125.33 188.26,125.35 v1(189.89,125.35) 191.98,125.35 194.84,128.21 196.14,128.21 196.4,127.95 196.61,127.95 196.79,127.77 JMXM1.173
PEG_CRX_GTX_C_P2: length 12
  TOP w0.109: CC19.1 187.05,127.62 187.48,127.62 187.5,127.59 188.06,127.59 188.08,127.62 v1(190.99,127.62) 191.58,127.62 193.37,129.4 196.66,129.4 196.79,129.27 JMXM1.167
PEG_CRX_GTX_C_P3: length 12.6
  TOP w0.109: CC20.1 187.05,129.77 187.63,129.77 187.65,129.75 188.21,129.75 188.23,129.77 v1(189.57,129.77) 192.29,129.77 195.43,132.91 196.65,132.91 196.79,132.77 JMXM1.159
PEG_CRX_GTX_C_P4: length 10.9
  TOP w0.109: JMXM1.153 196.79,134.27 196.65,134.41 195.58,134.41 192.97,131.81 v1(192.3,131.81) 189.54,131.81 189.52,131.78 188.96,131.78 188.94,131.81 188.58,131.81 CC21.1
PEG_CRX_GTX_C_P5: length 10.6
  TOP w0.109: CC22.1 188.61,133.73 189.04,133.73 189.06,133.71 189.63,133.71 189.65,133.73 v1(192.44,133.73) 193.38,133.73 195.56,135.91 196.65,135.91 196.79,135.77 JMXM1.147
PEG_CRX_GTX_C_P6: length 10.4
  TOP w0.109: JMXM1.141 196.79,137.27 196.65,137.41 193.9,137.41 192.19,135.7 191.77,135.7 191.75,135.68 191.18,135.68 191.16,135.7 v1(189.33,135.7) 188.67,135.7 CC23.1
PEG_CRX_GTX_C_P7: length 10.2
  TOP w0.109: JMXM1.135 196.79,138.77 196.65,138.91 196.48,138.91 196.23,138.66 194.11,138.66 193.79,138.34 193.46,138.34 192.98,138.82 192.84,138.82 192.6,138.58 192.6,138.43 193.08,137.95 193.08,137.63 192.56,137.11 v1(191.01,137.11) 190.45,137.11 CC24.1
PEG_CRX_GTX_C_P8: length 9.8
  TOP w0.109: CC25.1 190.41,139.1 v1(191.04,139.1) 191.84,139.1 192.1,139.35 192.1,140.31 192.2,140.42 192.68,140.42 192.79,140.31 192.79,140.01 193.02,139.78 193.52,139.78 193.76,140.01 193.76,140.31 193.86,140.42 194.74,140.42 194.74,140.41 196.65,140.41 196.79,140.27 JMXM1.129
PEG_CRX_GTX_C_P9: length 9.9
  TOP w0.109: JMXM1.123 194.91,141.77 194.4,141.25 191.49,141.25 191.27,141.04 v1(190.7,141.04) 189.71,141.04 189.69,141.02 189.13,141.02 189.1,141.04 188.79,141.04 CC26.1
PEG_CRX_GTX_C_P10: length 6.8
  TOP w0.109: CC27.1 193.47,142.4 193.84,142.4 194.04,142.6 194.09,142.6 194.34,142.85 194.34,143.35 194.45,143.45 194.89,143.45 195,143.35 195,142.84 195.25,142.59 v1(195.54,142.59) 195.79,142.59 196.04,142.84 196.04,143.29 196.16,143.41 196.65,143.41 196.79,143.27 JMXM1.117
PEG_CRX_GTX_C_P11: length 7
  TOP w0.109: JMXM1.111 196.79,144.77 196.65,144.91 196.18,144.91 195.6,144.34 v1(193.39,144.34) 192.39,144.34 192.37,144.31 191.81,144.31 191.78,144.34 191.6,144.34 CC28.1
PEG_CRX_GTX_C_P12: length 5.3
  TOP w0.109: JMXM1.105 196.79,146.27 196.65,146.41 196.24,146.41 196.04,146.61 196.04,146.77 195.8,147.01 195.8,147.17 195.76,147.21 195.34,147.21 195.27,147.14 195.27,147.01 195.54,146.74 195.54,145.95 195.34,145.75 195.29,145.75 CC29.1
PEG_CRX_GTX_C_P13: length 5.9
  TOP w0.109: CC30.1 192.55,147.45 192.88,147.45 192.9,147.43 193.46,147.43 193.48,147.45 193.86,147.45 194.32,147.91 v1(195.57,147.91) 196.65,147.91 196.79,147.77 JMXM1.99
PEG_CRX_GTX_C_P14: length 3.2
  TOP w0.109: CC31.1 195.28,149.16 195.47,149.16 195.49,149.14 196.08,149.14 196.36,149.42 196.73,149.42 196.88,149.27 JMXM1.93
PEG_CRX_GTX_C_P15: length 3.2
  TOP w0.109: CC32.1 195.28,151.19 195.49,151.19 195.51,151.17 195.89,151.17 196.1,150.96 196.6,150.96 196.79,150.77 JMXM1.87
PEG_CRX_GTX_N0: length 174.4
  TOP w0.089: v1(67.38,49.96) 67.87,50.45 JCPU1.K33
  TOP w0.109: CC1.2 185.23,123.55 184.97,123.55 v3(184.76,123.76)
  IN1 w0.089: 70.75,78.55 70.75,75.56 70.75,75.55 70.75,74.53 70.78,74.49 70.78,55.8 70.59,55.6 70.2,55.6 69.8,55.2 69.8,52.7 69.7,52.6 69.11,52.6 68.78,52.27 68.78,50.77 68.54,50.53 68.09,50.53 67.51,49.96 v1(67.38,49.96)
  IN1 w0.135: 70.75,78.55 70.75,80.66 72.96,82.87 72.96,83.99 73.51,84.54 73.51,87.99 76.36,90.84 76.9,90.84 78.23,92.18 78.23,92.92 80,94.69 84.07,94.69 85.99,96.61 87.99,96.61 96.32,104.94 102.52,104.94 103.71,106.13 118.44,106.13 121.09,108.79 133.7,108.79 134.89,107.61 141.88,107.61 142.01,107.74 142.01,108.47 142.3,108.75 142.91,108.75 143.19,108.47 143.19,107.74 143.33,107.61 150.25,107.61 150.9,108.26 152.6,108.26 156.97,112.62 157.17,112.62 159.71,115.16 159.71,115.68 165.71,121.68 173.49,121.68 174.37,122.56 176.98,122.56 177.81,123.38 179.75,123.38 180.26,123.9 180.26,124.17 180.54,124.45 182.37,124.45 182.65,124.17 182.65,123.51 182.78,123.38 184.38,123.38 v3(184.76,123.76)
PEG_CRX_GTX_N1: length 174.4
  TOP w0.089: v1(66.45,51.98) 65.98,52.45 JCPU1.M35
  TOP w0.109: CC2.2 185.25,125.6 184.95,125.6 v3(184.76,125.79)
  IN1 w0.089: v1(66.45,51.98) 66.15,51.98 66.02,51.85 66.02,51.54 66.02,51.45 66.02,50.64 66.1,50.56 67.57,50.56 67.74,50.73 67.74,51.19 68.13,51.59 68.13,52.18 68.79,52.84 68.79,53.55 68.81,53.57 68.81,55.27 69.13,55.58 69.55,55.58 69.79,55.82 69.79,76.74 69.84,76.78 69.84,78.17 69.78,78.22 69.78,78.55
  IN1 w0.135: 69.78,78.55 69.78,80.94 71.69,82.85 71.69,87.49 72.62,88.42 72.62,89.15 75.24,91.77 76.58,91.77 76.92,92.12 76.92,92.85 79.53,95.46 83.2,95.46 85.12,97.38 87.67,97.38 96.03,105.74 102.12,105.74 103.28,106.9 114.41,106.9 115.25,107.74 118.96,107.74 121,109.78 148.52,109.78 149.15,109.14 151.26,109.14 164.69,122.58 173.26,122.58 174.07,123.39 176.73,123.39 178.89,125.55 184.52,125.55 v3(184.76,125.79)
PEG_CRX_GTX_N2: length 177.3
  TOP w0.089: v1(66.44,50.97) 66.9,51.42 JCPU1.L34
  TOP w0.109: v3(184.86,127.99) 185.04,127.81 185.28,127.81 CC3.2
  IN1 w0.089: 68.71,78.52 68.71,77.78 68.76,77.73 68.76,67.38 68.81,67.34 68.81,55.86 68.52,55.57 68.12,55.57 67.8,55.25 67.8,53.52 67.74,53.46 67.74,51.85 67.47,51.58 66.94,51.58 66.65,51.29 66.65,51.17 v1(66.44,50.97)
  IN1 w0.135: 68.71,78.52 68.71,80.97 70.92,83.18 70.92,88.53 74.08,91.69 74.08,92.47 74.61,93 74.81,93 75.64,93.83 76.74,93.83 79.15,96.23 82.88,96.23 84.8,98.15 87.35,98.15 95.83,106.63 99.07,106.63 99.46,107.02 101.56,107.02 102.21,107.67 114.1,107.67 114.93,108.51 118.31,108.51 120.5,110.69 151.7,110.69 164.37,123.37 172.23,123.37 173.86,124.99 177.25,124.99 180.14,127.89 180.96,127.89 181.13,128.06 181.13,128.86 181.4,129.13 182.07,129.13 182.36,128.85 182.36,127.75 182.59,127.51 182.9,127.51 183.03,127.64 183.03,128.93 183.31,129.21 183.99,129.21 184.26,128.93 184.26,128.05 184.41,127.9 184.77,127.9 v3(184.86,127.99)
PEG_CRX_GTX_N3: length 177.9
  TOP w0.089: JCPU1.J35 65.89,49.45 65.47,49.02 v1(65.28,49.02)
  TOP w0.109: CC4.2 185.28,129.97 185.06,129.97 v3(184.87,130.15)
  IN1 w0.089: v1(65.28,49.02) 65.74,49.48 65.74,49.74 64.76,50.72 64.76,52.24 65.1,52.58 65.65,52.58 65.83,52.75 65.83,54.13 66.19,54.5 66.6,54.5 66.78,54.68 66.78,55.23 67.11,55.56 67.41,55.56 67.78,55.93 67.78,67.41 67.74,67.46 67.74,76.87 67.7,76.91 67.7,78.55
  IN1 w0.135: v3(184.87,130.15) 184.71,129.99 181.15,129.99 177.08,125.92 173.66,125.92 171.96,124.22 164.1,124.22 151.35,111.47 120.15,111.47 117.96,109.28 114.61,109.28 113.78,108.44 101.89,108.44 101.27,107.82 99.15,107.82 98.72,107.4 95.51,107.4 87.03,98.92 84.48,98.92 82.56,97 78.83,97 76.43,94.6 75.29,94.6 74.49,93.8 74.3,93.8 73.28,92.78 73.28,91.98 73.07,91.78 72.61,91.78 69.66,88.82 69.66,83.08 67.7,81.11 67.7,78.55
PEG_CRX_GTX_N4: length 185.5
  TOP w0.089: v1(68.42,48.95) 68.6,48.95 68.9,49.26 JCPU1.J32
  TOP w0.109: CC5.2 186.82,132.02 186.55,132.02 v3(186.3,132.27)
  IN1 w0.089: 71.59,78.55 71.59,76.38 71.79,76.18 71.79,55.76 71.6,55.58 71.19,55.58 70.82,55.2 70.82,53.26 70.88,53.2 70.88,51.82 70.65,51.59 70.22,51.59 69.88,51.26 69.88,49.77 69.67,49.56 68.99,49.56 68.7,49.27 68.7,49.09 68.55,48.95 68.42,48.95 v1(68.42,48.95)
  IN1 w0.135: 71.59,78.55 71.59,78.96 73.8,81.17 73.8,81.84 74.29,82.34 74.29,86.89 75.72,88.32 76.8,88.32 77.47,88.98 77.47,90.33 79.13,91.99 79.13,92.61 80.44,93.92 84.39,93.92 86.28,95.81 88.32,95.81 96.65,104.14 102.81,104.14 104.04,105.36 118.76,105.36 120.83,107.43 128.81,107.43 129.45,106.79 150.54,106.79 151.15,107.4 152.87,107.4 156.92,111.46 157.17,111.46 162.22,116.5 163.02,116.5 163.42,116.1 163.61,116.1 163.9,116.38 163.9,116.57 163.29,117.18 163.29,117.57 163.74,118.01 164.13,118.01 164.73,117.41 164.92,117.41 165.21,117.69 165.21,117.88 164.67,118.42 164.67,118.81 165.11,119.26 165.5,119.26 166.05,118.72 166.24,118.72 168.35,120.83 173.77,120.83 174.71,121.77 177.29,121.77 178.13,122.61 185.12,122.61 185.27,122.77 185.27,127.05 185.51,127.28 185.51,130.68 185.33,130.86 185.33,131.53 185.86,132.07 186.09,132.07 v3(186.3,132.27)
PEG_CRX_GTX_N5: length 185.8
  TOP w0.089: v1(66.37,47.9) 66.9,48.44 JCPU1.H34
  TOP w0.109: v3(186.37,134.48) 186.7,134.15 187.06,134.15 CC6.2
  IN1 w0.089: v1(66.37,47.9) 66.48,47.9 66.71,48.13 66.71,48.28 66.65,48.34 64.69,48.34 64,49.03 64,52.64 64.7,53.34 64.7,54.1 65.19,54.59 65.61,54.59 65.76,54.74 65.76,55.22 66.1,55.56 66.52,55.56 66.72,55.75 66.72,72.3 66.81,72.4 66.81,73.48 66.72,73.57 66.72,77.71 66.64,77.79 66.64,78.55
  IN1 w0.135: 66.64,78.55 66.64,81.18 67.66,82.21 67.66,84.43 67.98,84.75 68.4,85.17 68.4,89.45 69.15,90.2 69.74,90.2 72.48,92.93 72.48,94.16 74.93,96.61 77.35,96.61 78.51,97.77 82.24,97.77 84.16,99.69 86.71,99.69 95.18,108.17 98.37,108.17 98.8,108.59 100.95,108.59 101.57,109.21 113.46,109.21 114.29,110.05 117.6,110.05 119.8,112.24 151.02,112.24 163.77,124.99 166.01,124.99 166.01,124.99 171.6,124.99 173.43,126.81 176.88,126.81 184.35,134.28 186.17,134.28 v3(186.37,134.48)
PEG_CRX_GTX_N6: length 190.1
  TOP w0.089: v1(69.47,47.94) 69.47,48.03 69.89,48.45 JCPU1.H31
  TOP w0.109: v3(186.35,136.07) 186.52,135.9 186.96,135.9 187.31,136.24 CC7.2
  IN1 w0.089: 73.03,78.45 73,78.42 73,77.78 72.9,77.68 72.9,77.21 73,77.11 73,54.68 72.62,54.29 72.27,54.29 72.04,54.07 72.04,53.57 72.1,53.51 72.1,51.73 71.75,51.37 71.34,51.37 71.12,51.15 71.12,49.66 70.8,49.35 70.33,49.35 70.1,49.12 70.1,48.57 69.86,48.32 69.27,48.32 69.02,48.08 69.02,47.82 69.16,47.68 69.32,47.68 69.47,47.83 v1(69.47,47.94)
  IN1 w0.135: v3(186.35,136.07) 186.59,135.83 186.87,135.83 187.23,135.46 187.23,130.86 186.95,130.57 186.71,130.57 186.59,130.45 186.59,130.03 186.71,129.9 187.01,129.9 187.29,129.62 187.29,128.99 187.01,128.72 186.66,128.72 186.53,128.59 186.53,128.17 186.66,128.05 186.95,128.05 187.23,127.76 187.23,127.13 186.95,126.85 186.66,126.85 186.53,126.72 186.53,126.31 186.66,126.18 187.01,126.18 187.29,125.9 187.29,125.27 187.01,125 186.66,125 186.53,124.87 186.53,124.45 186.66,124.32 186.95,124.32 187.23,124.04 187.23,123.55 186.73,123.05 186.48,123.05 186.3,122.87 186.3,122.34 185.43,121.48 181.29,121.48 181.15,121.34 181.15,121.18 180.87,120.89 180.25,120.89 179.97,121.18 179.97,121.34 179.84,121.48 179.43,121.48 179.3,121.34 179.3,121.18 179.01,120.89 178.05,120.89 177.82,120.66 175.91,120.66 174.97,119.72 168.69,119.72 163.98,115.01 162.28,115.01 157.63,110.36 157.28,110.36 153.28,106.36 151.59,106.36 150.99,105.77 129.02,105.77 128.38,106.41 121.25,106.41 119.18,104.34 104.46,104.34 103.24,103.11 97.07,103.11 88.64,94.69 87.61,94.69 84.75,91.82 81.96,91.82 75.93,85.8 75.93,83.74 75.46,83.27 75.46,81.26 73.1,78.9 73.1,78.52 73.03,78.45
PEG_CRX_GTX_N7: length 190
  TOP w0.089: JCPU1.G33 67.9,47.28 67.66,47.04 v1(67.38,47.04)
  TOP w0.109: v3(188.41,137.66) 188.41,137.59 188.63,137.37 188.82,137.37 189.11,137.66 CC8.2
  IN1 w0.089: v1(67.38,47.04) 68.02,46.4 70.95,46.4 71.61,47.07 71.61,48.16 72.12,48.67 72.12,49.1 72.36,49.34 72.75,49.34 73.14,49.72 73.14,51.13 73.76,51.75 73.76,52.03 75.03,53.3 75.03,68.74 75,68.77 75,77.3 74.98,77.32 74.98,78.53 75.01,78.55
  IN1 w0.135: v3(188.41,137.66) 188.95,137.11 188.95,123.29 188.95,122.62 185.61,119.28 182.58,119.28 182.44,119.14 182.44,118.86 182.16,118.58 181.55,118.58 181.26,118.86 181.26,119.14 181.13,119.28 180.73,119.28 180.59,119.14 180.59,118.86 180.31,118.58 179.69,118.58 179.41,118.86 179.41,119.14 179.27,119.28 178.83,119.28 178.56,119.01 176.54,119.01 175.6,118.07 169.22,118.07 164.44,113.3 162.8,113.3 158.09,108.59 157.7,108.59 153.85,104.74 152.16,104.74 151.65,104.23 121.25,104.23 119.82,102.8 105.95,102.8 105.2,102.8 103.97,101.57 97.71,101.57 89.28,93.15 88.34,93.15 82.19,87 81.82,87 77.91,83.09 77.91,82.47 77.11,81.67 77.11,80.72 75.01,78.62 75.01,78.55
PEG_CRX_GTX_N8: length 195.2
  TOP w0.089: v1(70.5,47.94) 70.5,47.72 70.77,47.45 JCPU1.G30
  TOP w0.109: v3(188.1,139.41) 188.26,139.24 188.72,139.24 CC9.2
  IN1 w0.089: v1(70.5,47.94) 70.5,47.72 70.56,47.66 70.78,47.66 70.9,47.78 70.9,49.19 71.25,49.54 71.71,49.54 71.92,49.75 71.92,51.23 72.26,51.58 72.73,51.58 72.93,51.78 72.93,52.41 73.8,53.28 73.8,78.55
  IN1 w0.135: v3(188.1,139.41) 187.95,139.26 187.09,139.26 186.96,139.39 186.96,139.77 186.68,140.04 186.09,140.04 185.81,139.77 185.81,139.38 185.69,139.26 185.49,139.26 185.22,138.98 185.22,136.79 185.49,136.51 186.11,136.51 186.38,136.79 186.38,137.95 186.51,138.07 186.96,138.07 187.08,137.95 187.08,136.61 187.36,136.34 187.65,136.34 187.81,136.18 187.81,123.51 187.81,123.04 185.07,120.31 178.33,120.31 178.17,120.14 176.17,120.14 175.22,119.19 168.88,119.19 164.1,114.4 162.4,114.4 157.7,109.7 157.34,109.7 153.46,105.82 151.77,105.82 151.21,105.25 128.81,105.25 128.17,105.89 121.47,105.89 119.39,103.82 104.72,103.82 103.49,102.6 97.28,102.6 88.86,94.17 87.92,94.17 81.86,88.11 81.48,88.11 80.97,87.61 79.58,87.61 78.42,86.45 78.42,85.46 76.06,83.1 76.06,81.12 73.82,78.88 73.81,78.88 73.8,78.88 73.8,78.55
PEG_CRX_GTX_N9: length 195.7
  TOP w0.089: v1(65.25,46.04) 65.66,46.45 JCPU1.F35
  TOP w0.109: v3(186.56,141.33) 186.77,141.12 186.91,141.12 CC10.2
  IN1 w0.089: 63.73,47.52 63.75,47.52 64.6,46.67 65.27,46.67 65.67,46.28 65.67,45.77 65.61,45.71 65.45,45.71 65.25,45.91 v1(65.25,46.04) ; 65.7,78.55 65.7,78.37 65.75,78.33 65.75,75.43 65.52,75.2 65.52,70.89 65.7,70.71 65.7,55.84 65.48,55.61 64.93,55.61 63.75,54.43 63.75,54.17 63.73,54.16
  IN1 w0.135: 65.7,78.55 65.7,81.98 66.41,82.68 66.41,84.45 66.97,85.01 66.97,89.13 70.27,92.43 70.27,93.77 71.93,95.43 72.63,95.43 74.65,97.45 76.83,97.45 78,98.62 82,98.62 83.98,100.6 86.53,100.6 94.87,108.93 97.83,108.93 98.31,109.41 100.68,109.41 101.39,110.12 113.28,110.12 113.98,110.82 116.74,110.82 118.94,113.01 150.7,113.01 163.45,125.76 170.05,125.76 170.28,125.99 170.28,127.02 170.56,127.29 171.2,127.29 171.48,127.02 171.48,126.82 171.61,126.7 172.03,126.7 172.15,126.82 172.15,127.3 172.44,127.58 176.54,127.58 183.6,134.65 183.6,135.64 184.44,136.48 184.44,139.92 185.69,141.16 186.4,141.16 v3(186.56,141.33) ; 63.73,54.16 63.69,54.12 63.69,53.48 63.05,52.85 63.05,47.93 63.46,47.52 63.73,47.52
PEG_CRX_GTX_N10: length 200.3
  TOP w0.089: v1(67.39,44.91) 67.4,44.91 66.9,45.41 JCPU1.E34
  TOP w0.109: CC11.2 191.76,142.65 191.41,142.65 v3(191.16,142.9)
  IN1 w0.089: 78.77,78.43 78.74,78.41 78.74,77.93 78.67,77.86 78.67,76.92 78,76.25 78,51.71 76.25,49.96 76.25,48.67 75.65,48.07 75.65,47.53 75.02,46.9 75.02,46.69 74.66,46.33 73.16,46.33 72.03,45.2 72.03,44.82 71.17,43.96 71.17,43.69 70.8,43.32 69.09,43.32 68.5,43.91 68.5,44.68 68,45.17 67.66,45.17 67.4,44.91 v1(67.39,44.91)
  IN1 w0.135: v3(191.16,142.9) 191.62,142.44 191.62,126.78 191.38,126.54 191.38,121.39 185.73,115.74 170.83,115.74 168.68,113.59 168.14,113.59 165.34,110.79 164.76,110.79 158.88,104.9 158.36,104.9 155.35,101.89 153.38,101.89 152.91,101.42 130.94,101.42 130.47,101.89 127.86,101.89 127.29,101.32 125.62,101.32 125.05,101.89 122.18,101.89 120.77,100.48 106.46,100.48 105.24,99.26 98.66,99.26 90.24,90.84 89.35,90.84 82.97,84.46 82.66,84.46 81.57,83.37 81.57,82.56 80.28,81.27 80.28,80.52 79.3,79.54 79.3,78.97 78.99,78.65 78.77,78.43
PEG_CRX_GTX_N11: length 200.5
  TOP w0.089: v1(68.41,45.9) 68.6,45.9 68.9,45.6 JCPU1.E32
  TOP w0.109: CC12.2 189.81,144.51 189.53,144.51 v3(189.33,144.72)
  IN1 w0.089: v1(68.41,45.9) 68.41,45.87 68.92,45.36 70.77,45.36 72.04,46.63 72.04,48 72.36,48.32 72.44,48.32 72.96,48.32 73.22,48.32 73.27,48.36 73.73,48.36 74.09,48.72 74.09,49.27 74.6,49.78 74.6,50.04 74.6,50.04 74.6,50.24 75.09,50.73 75.09,52 75.77,52.68 75.77,68.31 75.99,68.53 75.99,73.27 75.99,73.27 75.99,73.78 75.99,73.78 75.99,74.12 75.99,74.12 75.99,77.26 76.14,77.41 76.18,77.44 76.31,77.58 76.31,77.76 76.95,78.4 76.95,78.55
  IN1 w0.135: v3(189.33,144.72) 189.36,144.69 189.89,144.69 190.17,144.42 190.17,143.8 189.84,143.47 189.84,142.93 189.55,142.64 188.91,142.64 188.78,142.52 188.78,142.23 188.91,142.1 189.55,142.1 189.84,141.82 189.84,141.34 189.55,141.06 188.86,141.06 188.73,140.93 188.73,140.65 188.86,140.52 189.55,140.52 189.84,140.24 189.84,122.2 185.45,117.81 177,117.81 176.5,117.3 170.12,117.3 168.44,115.62 167.91,115.62 164.73,112.45 163.2,112.45 154.2,103.45 152.33,103.45 151.92,103.04 132.19,103.04 131.78,103.45 121.56,103.45 120.14,102.03 106.5,102.03 105.63,102.03 104.41,100.8 98.03,100.8 89.6,92.38 88.66,92.38 82.51,86.22 82.13,86.22 79.55,83.64 79.55,82.74 78.01,81.2 78.01,80.53 76.95,79.46 76.95,78.55
PEG_CRX_GTX_N12: length 211.3
  TOP w0.089: v5(67.38,43.88) 67.37,43.89 67.37,43.89 67.9,44.42 JCPU1.D33
  TOP w0.109: CC13.2 193.49,145.91 193.31,145.91 v3(193.14,146.08)
  IN1 w0.089: 81.23,78.55 79.77,77.1 79.77,68.05 80.4,67.43 80.4,59.31 79.37,58.28 79.37,51.19 77.72,49.54 77.72,47.81 77.46,47.56 77.1,47.56 76.69,47.15 76.69,46.45 75.76,45.53 75.76,44.78 75.53,44.54 74.69,44.54 73.7,43.55 72.96,43.55 70.57,41.17 68.57,41.17 68.01,41.72 68.01,43.17 67.74,43.44 67.09,43.44 67,43.53 67,43.83 67.04,43.88 v5(67.38,43.88)
  IN1 w0.135: v3(193.14,146.08) 192.63,145.57 192.63,144.72 193.01,144.34 193.01,126.03 192.66,125.69 192.66,120.72 188.57,116.62 188.57,115.76 187.25,114.45 184.11,114.45 183.28,113.61 181.46,113.61 180.63,114.45 173.16,114.45 170.95,112.24 169.54,112.24 168.16,110.86 167.77,110.86 166.41,109.5 165.3,109.5 161.85,106.05 161.85,104.94 156.59,99.68 144.29,99.68 143.88,100.09 129.64,100.09 128.52,98.97 123.75,98.97 123.62,99.1 123.62,99.72 123.34,100 122.71,100 122.44,99.72 122.44,99.1 122.3,98.97 110.14,98.97 109.15,97.98 99.2,97.98 90.77,89.55 89.88,89.55 83.41,83.08 83.41,82.55 82.08,81.22 82.08,80.46 81.28,79.66 81.28,78.6 81.23,78.55
PEG_CRX_GTX_N13: length 210.8
  TOP w0.089: v1(69.47,44.89) 69.78,44.89 69.9,44.77 JCPU1.D31
  TOP w0.109: CC14.2 190.9,147.77 190.43,147.77 v3(190.22,147.98)
  IN1 w0.089: v1(69.47,44.89) 70.01,44.35 70.95,44.35 71.47,44.86 71.47,45.48 73.32,47.34 74.65,47.34 75.12,47.82 75.12,50.17 75.38,50.43 75.66,50.43 77,51.76 77,77.15 77.7,77.85 77.7,78.51 77.72,78.53 77.72,78.55
  IN1 w0.135: v3(190.22,147.98) 190.88,147.98 191.12,147.74 191.12,146.64 190.84,146.35 186.75,146.35 186.62,146.23 186.62,145.81 186.75,145.68 190.84,145.68 191.12,145.4 191.12,143.66 190.61,143.14 190.61,121.8 185.84,117.03 177.32,117.03 176.8,116.51 170.5,116.51 168.71,114.72 168.11,114.72 164.95,111.56 163.5,111.56 159.78,107.83 159.78,106.93 158.61,105.77 158.08,105.77 154.99,102.68 152.92,102.68 152.45,102.21 131.66,102.21 131.19,102.68 127.56,102.68 126.97,102.1 126.05,102.1 125.46,102.68 121.88,102.68 120.46,101.26 106.96,101.26 106.01,101.26 104.78,100.03 98.35,100.03 89.92,91.61 89,91.61 82.7,85.31 82.31,85.31 80.34,83.33 80.34,82.42 79.41,81.5 79.41,80.81 77.72,79.12 77.72,78.55
PEG_CRX_GTX_N14: length 218.5
  TOP w0.089: v1(67.39,41.93) 67.39,42.11 67.73,42.45 JCPU1.B33
  TOP w0.109: v3(192.96,149.59) 193.18,149.37 193.52,149.37 CC15.2
  IN1 w0.089: 81.56,77.97 81.55,77.97 81.55,77.94 80.82,77.22 80.82,68.32 81.28,67.87 81.28,58.7 80.52,57.94 80.52,55.24 80.39,55.11 80.39,51.23 78.71,49.55 78.71,48.15 78.73,48.13 78.73,47.8 78.71,47.79 78.71,45.81 78.43,45.53 77.07,45.53 76.78,45.23 76.78,43.76 76.6,43.58 76.55,43.58 76.54,43.57 76.21,43.57 76.19,43.59 75.04,43.59 74.65,43.2 74.65,42.47 73.13,40.96 73.13,40.6 72.81,40.28 68.18,40.28 66.88,41.58 66.88,42.24 67.08,42.44 67.55,42.44 67.6,42.39 67.6,42.14 v1(67.39,41.93)
  IN1 w0.135: 81.56,77.97 82.07,78.48 82.07,79.33 84.63,81.89 84.63,82.4 86.61,84.38 87.73,84.38 91.48,88.13 91.48,89.17 99.52,97.21 109.64,97.21 110.56,98.13 128.77,98.13 129.91,99.28 143.6,99.28 144,98.87 156.87,98.87 163.19,105.2 163.19,106.29 165.55,108.65 166.64,108.65 167.91,109.92 168.41,109.92 169.9,111.4 171.32,111.4 173.54,113.63 180.34,113.63 182.39,111.58 183.32,111.58 185.01,113.27 187.29,113.27 189.46,115.44 189.46,116.4 193.43,120.38 193.43,125.37 193.78,125.71 193.78,146.95 192.23,148.5 192.23,149.15 192.49,149.42 192.78,149.42 v3(192.96,149.59)
PEG_CRX_GTX_N15: length 218.3
  TOP w0.089: JCPU1.C32 68.93,43.45 v1(69.47,42.91)
  TOP w0.109: CC16.2 193.52,151.4 193.37,151.4 v3(193.17,151.6)
  IN1 w0.089: v1(69.47,42.91) 69.45,42.93 69.18,42.93 69.07,42.82 69.07,42.57 69.07,42.57 69.07,42.38 69.08,42.37 69.08,42.36 69.16,42.27 70.33,42.27 71.49,43.44 71.49,43.97 72.07,44.54 72.65,44.54 72.87,44.76 72.87,45.19 73.2,45.52 74.2,45.52 75.37,46.69 75.37,46.89 75.68,47.2 75.68,47.2 76.04,47.56 76.04,47.56 76.21,47.56 76.22,47.56 76.44,47.56 76.69,47.82 76.69,49.66 78.83,51.79 78.83,67.21 78.79,67.25 78.79,67.34 78.8,67.34 78.8,76.29 79.2,76.68 79.2,78.11 79.55,78.46 79.62,78.53 79.62,78.53 79.64,78.55
  IN1 w0.135: v3(193.17,151.6) 192.66,151.09 188.87,151.09 188.59,150.82 188.59,148.33 188.87,148.05 189.56,148.05 189.84,148.33 189.84,149.45 189.97,149.58 191.31,149.58 191.44,149.45 191.44,148.18 191.86,147.76 191.86,144.22 192.14,143.94 192.14,126.25 191.89,126.01 191.89,121.12 185.99,115.21 172.73,115.21 170.65,113.13 169.3,113.13 167.89,111.72 167.54,111.72 166.09,110.27 164.98,110.27 160.99,106.28 160.99,105.17 157.19,101.37 153.63,101.37 153.13,100.88 130.05,100.88 129.62,101.31 128.31,101.31 127.77,100.78 125.39,100.78 124.86,101.31 122.32,101.31 120.94,99.92 106.67,99.92 105.5,98.75 98.88,98.75 90.45,90.32 89.56,90.32 82.95,83.71 82.64,83.71 82.09,83.15 82.09,82.31 81.21,81.44 81.21,80.69 79.88,79.35 79.88,78.79 79.64,78.55
PEG_CRX_GTX_P0: length 174.4
  TOP w0.089: v3(68.41,49.89) 67.98,49.45 JCPU1.J33
  TOP w0.109: CC17.2 185.27,123.34 184.97,123.34 v1(184.76,123.13)
  IN1 w0.089: 71.01,78.55 71.01,78.34 70.96,78.3 70.96,74.59 70.98,74.57 70.98,72.71 70.98,72.02 70.98,72.02 70.98,55.7 70.67,55.39 70.29,55.39 69.99,55.1 69.99,52.6 69.79,52.4 69.19,52.4 68.98,52.19 68.98,50.69 68.62,50.33 68.17,50.33 67.92,50.07 67.92,49.77 68.03,49.66 68.18,49.66 v3(68.41,49.89)
  IN1 w0.135: 71.01,78.55 71.01,80.55 73.21,82.76 73.21,83.88 73.76,84.43 73.76,87.88 76.47,90.59 77,90.59 78.48,92.07 78.48,92.81 80.11,94.44 84.17,94.44 86.09,96.36 88.09,96.36 96.43,104.69 102.63,104.69 103.82,105.88 118.54,105.88 121.2,108.53 133.6,108.53 134.78,107.35 141.98,107.35 142.27,107.64 142.27,108.36 142.4,108.5 142.81,108.5 142.94,108.36 142.94,107.64 143.22,107.35 150.35,107.35 151,108 152.7,108 157.07,112.37 157.28,112.37 159.97,115.06 159.97,115.58 165.81,121.43 173.59,121.43 174.47,122.3 177.09,122.3 177.92,123.13 179.86,123.13 180.52,123.79 180.52,124.07 180.65,124.19 182.27,124.19 182.4,124.07 182.4,123.4 182.67,123.13 v1(184.76,123.13)
PEG_CRX_GTX_P1: length 174.4
  TOP w0.089: v3(65.38,51.97) 65.9,51.45 JCPU1.L35
  TOP w0.109: CC18.2 185.26,125.39 184.99,125.39 v1(184.76,125.16)
  IN1 w0.089: 70.04,78.55 70.04,78.24 70.05,78.23 70.05,76.7 69.98,76.63 69.98,55.72 69.64,55.37 69.21,55.37 69.01,55.16 69.01,53.49 68.98,53.47 68.98,52.74 68.34,52.09 68.34,51.5 67.94,51.11 67.94,50.64 67.67,50.37 66,50.37 65.81,50.55 65.81,51.45 65.81,51.54 v3(65.38,51.97)
  IN1 w0.135: 70.04,78.55 70.04,80.84 71.94,82.74 71.94,87.39 72.87,88.32 72.87,89.04 75.35,91.52 76.68,91.52 77.18,92.01 77.18,92.75 79.63,95.21 83.3,95.21 85.22,97.13 87.78,97.13 96.14,105.49 102.22,105.49 103.38,106.65 114.52,106.65 115.36,107.48 119.06,107.48 121.1,109.53 148.41,109.53 149.05,108.89 151.36,108.89 164.8,122.33 173.37,122.33 174.18,123.14 176.84,123.14 179,125.3 184.62,125.3 v1(184.76,125.16)
PEG_CRX_GTX_P2: length 177.5
  TOP w0.089: JCPU1.K34 66.9,50.57 v3(67.3,50.97)
  TOP w0.109: v1(184.86,127.36) 185.1,127.6 185.27,127.6 CC19.2
  IN1 w0.089: v3(67.3,50.97) 67.22,50.89 66.98,50.89 66.9,50.97 66.9,51.23 67.05,51.37 67.64,51.37 67.95,51.68 67.95,53.37 68.01,53.43 68.01,55.17 68.2,55.36 68.61,55.36 69,55.75 69,67.46 68.95,67.5 68.95,78.55
  IN1 w0.135: 68.95,78.55 68.97,78.56 68.97,80.87 71.17,83.07 71.17,88.43 74.33,91.59 74.33,92.36 74.72,92.75 74.92,92.75 75.74,93.57 76.85,93.57 79.25,95.97 82.98,95.97 84.9,97.89 87.46,97.89 95.93,106.37 99.17,106.37 99.57,106.77 101.66,106.77 102.31,107.42 114.2,107.42 115.04,108.25 118.42,108.25 120.6,110.44 151.81,110.44 164.48,123.11 172.34,123.11 173.96,124.74 177.35,124.74 180.25,127.64 181.06,127.64 181.38,127.95 181.38,128.75 181.51,128.88 181.96,128.88 182.1,128.74 182.1,127.58 182.43,127.25 183.01,127.25 183.28,127.53 183.28,128.83 183.41,128.96 183.88,128.96 184.01,128.83 184.01,127.94 184.31,127.64 184.57,127.64 v1(184.86,127.36)
PEG_CRX_GTX_P3: length 177.9
  TOP w0.089: v3(66.38,48.95) 66.18,48.95 65.9,48.67 JCPU1.H35
  TOP w0.109: CC20.2 185.27,129.76 185.11,129.76 v1(184.87,129.52)
  IN1 w0.089: 67.95,78.55 67.95,78.02 67.93,77.99 67.93,67.56 67.99,67.5 67.99,55.84 67.5,55.35 67.2,55.35 66.99,55.14 66.99,54.59 66.68,54.29 66.28,54.29 66.03,54.04 66.03,52.66 65.74,52.37 65.18,52.37 64.97,52.16 64.97,50.8 65.95,49.83 65.95,49.37 65.85,49.27 65.85,49.05 65.95,48.95 v3(66.38,48.95)
  IN1 w0.135: 67.95,78.55 67.95,81.01 69.91,82.97 69.91,88.72 72.72,91.53 73.18,91.53 73.53,91.88 73.53,92.67 74.41,93.55 74.6,93.55 75.39,94.34 76.53,94.34 78.93,96.74 82.67,96.74 84.59,98.66 87.14,98.66 95.61,107.14 98.82,107.14 99.25,107.57 101.38,107.57 101.99,108.19 113.88,108.19 114.72,109.02 118.06,109.02 120.25,111.21 151.46,111.21 164.21,123.97 172.06,123.97 173.76,125.67 177.19,125.67 181.25,129.73 184.66,129.73 v1(184.87,129.52)
PEG_CRX_GTX_P4: length 185.5
  TOP w0.089: JCPU1.H32 68.98,48.45 v3(69.48,48.95)
  TOP w0.109: CC21.2 186.78,131.81 186.47,131.81 v1(186.3,131.64)
  IN1 w0.089: v3(69.48,48.95) 69.39,48.86 69.07,48.86 68.91,49.02 68.91,49.19 69.08,49.35 69.76,49.35 70.09,49.68 70.09,51.17 70.3,51.39 70.74,51.39 71.07,51.72 71.07,53.34 71.01,53.4 71.01,55.1 71.27,55.36 71.68,55.36 71.98,55.65 71.98,76.29 71.8,76.47 71.8,78.43 71.82,78.45 71.82,78.52 71.84,78.54 71.84,78.55
  IN1 w0.135: 71.84,78.55 71.84,78.85 74.05,81.06 74.05,81.74 74.55,82.23 74.55,86.78 75.83,88.06 76.91,88.06 77.72,88.88 77.72,90.22 79.39,91.89 79.39,92.51 80.54,93.67 84.5,93.67 86.39,95.56 88.42,95.56 96.75,103.89 102.92,103.89 104.14,105.11 118.86,105.11 120.93,107.18 128.7,107.18 129.34,106.54 150.64,106.54 151.26,107.15 152.97,107.15 157.03,111.2 157.28,111.2 162.32,116.24 162.92,116.24 163.32,115.84 163.72,115.84 164.15,116.28 164.15,116.68 163.55,117.28 163.55,117.46 163.84,117.76 164.02,117.76 164.63,117.15 165.03,117.15 165.46,117.59 165.46,117.99 164.92,118.53 164.92,118.71 165.22,119.01 165.4,119.01 165.94,118.46 166.34,118.46 168.45,120.57 173.87,120.57 174.81,121.51 177.39,121.51 178.23,122.36 185.22,122.36 185.53,122.66 185.53,126.94 185.76,127.18 185.76,130.79 185.58,130.97 185.58,131.43 185.97,131.81 186.12,131.81 186.29,131.64 v1(186.3,131.64)
PEG_CRX_GTX_P5: length 185.8
  TOP w0.089: v1(67.38,47.9) 67.21,47.9 66.9,47.6 JCPU1.G34
  TOP w0.109: v3(186.37,133.85) 186.46,133.94 186.74,133.94 CC22.2
  IN1 w0.089: 66.91,78.55 66.91,73.68 67.02,73.57 67.02,72.31 66.91,72.2 66.91,55.65 66.61,55.35 66.18,55.35 65.97,55.14 65.97,54.66 65.69,54.38 65.28,54.38 64.91,54.02 64.91,53.25 64.21,52.55 64.21,49.11 64.78,48.54 66.74,48.54 66.91,48.36 66.91,47.85 67.03,47.74 67.22,47.74 v1(67.38,47.9)
  IN1 w0.135: v3(186.37,133.85) 186.19,134.02 184.46,134.02 176.99,126.56 173.53,126.56 171.71,124.73 165.91,124.73 165.9,124.74 163.87,124.74 151.13,111.99 119.9,111.99 117.71,109.79 114.4,109.79 113.56,108.96 101.67,108.96 101.06,108.34 98.9,108.34 98.48,107.91 95.29,107.91 86.81,99.43 84.27,99.43 82.35,97.51 78.61,97.51 77.45,96.36 75.03,96.36 72.73,94.05 72.73,92.82 69.85,89.94 69.25,89.94 68.65,89.35 68.65,85.06 67.92,84.32 67.92,82.11 66.91,81.1 66.91,78.55
PEG_CRX_GTX_P6: length 190.1
  TOP w0.089: JCPU1.G31 69.74,47.45 69.44,47.15 v1(69.44,47.03)
  TOP w0.109: v3(186.35,135.43) 186.6,135.69 186.9,135.69 CC23.2
  IN1 w0.089: 72.79,78.55 72.79,78.4 72.8,78.4 72.8,77.86 72.69,77.76 72.69,77.13 72.8,77.03 72.8,54.77 72.53,54.5 72.18,54.5 71.85,54.17 71.85,53.44 71.9,53.4 71.9,51.82 71.66,51.58 71.25,51.58 70.91,51.24 70.91,49.75 70.72,49.56 70.25,49.56 69.89,49.21 69.89,48.73 69.71,48.54 69.19,48.54 68.81,48.16 68.81,47.73 69.07,47.47 69.33,47.47 69.44,47.36 v1(69.44,47.03)
  IN1 w0.135: 72.79,78.55 72.79,78.57 72.85,78.63 72.85,79.01 75.2,81.37 75.2,83.38 75.68,83.85 75.68,85.9 81.85,92.08 84.64,92.08 87.51,94.94 88.54,94.94 96.96,103.37 103.13,103.37 104.36,104.59 119.08,104.59 121.15,106.66 128.49,106.66 129.13,106.02 150.89,106.02 151.48,106.62 153.17,106.62 157.17,110.62 157.53,110.62 162.17,115.27 163.87,115.27 168.58,119.98 174.86,119.98 175.8,120.92 177.72,120.92 177.95,121.15 178.91,121.15 179.04,121.28 179.04,121.45 179.33,121.73 179.94,121.73 180.22,121.45 180.22,121.28 180.36,121.15 180.76,121.15 180.9,121.28 180.9,121.45 181.18,121.73 185.33,121.73 186.04,122.44 186.04,122.98 186.37,123.3 186.63,123.3 186.98,123.66 186.98,123.94 186.85,124.07 186.55,124.07 186.28,124.35 186.28,124.98 186.55,125.25 186.91,125.25 187.04,125.38 187.04,125.8 186.91,125.92 186.55,125.92 186.28,126.2 186.28,126.83 186.55,127.11 186.85,127.11 186.98,127.24 186.98,127.66 186.85,127.79 186.55,127.79 186.28,128.07 186.28,128.7 186.55,128.97 186.91,128.97 187.04,129.1 187.04,129.52 186.91,129.65 186.61,129.65 186.33,129.92 186.33,130.55 186.61,130.83 186.85,130.83 186.98,130.96 186.98,135.35 186.76,135.57 186.49,135.57 v3(186.35,135.43)
PEG_CRX_GTX_P7: length 190
  TOP w0.089: JCPU1.F33 68.42,46.97 v3(68.42,47.03)
  TOP w0.109: CC24.2 189.11,136.81 188.76,137.16 188.55,137.16 v1(188.35,136.96)
  IN1 w0.089: 74.75,78.55 74.75,78.54 74.78,78.52 74.78,77.23 74.79,77.22 74.79,68.68 74.82,68.65 74.82,53.39 73.55,52.12 73.55,51.84 72.93,51.22 72.93,49.81 72.67,49.55 72.28,49.55 71.91,49.18 71.91,48.76 71.41,48.25 71.41,47.15 70.86,46.61 68.1,46.61 67.79,46.92 67.79,47.36 67.93,47.5 68.29,47.5 68.42,47.37 v3(68.42,47.03)
  IN1 w0.135: 74.75,78.55 74.75,78.72 76.86,80.83 76.86,81.78 77.66,82.58 77.66,83.2 81.71,87.25 82.09,87.25 88.24,93.4 89.18,93.4 97.6,101.83 103.87,101.83 105.09,103.05 105.84,103.05 119.71,103.05 121.14,104.48 151.54,104.48 152.05,104.99 153.74,104.99 157.59,108.84 157.98,108.84 162.69,113.55 164.33,113.55 169.11,118.33 175.5,118.33 176.44,119.27 178.46,119.27 178.73,119.53 179.38,119.53 179.66,119.25 179.66,118.96 179.8,118.83 180.2,118.83 180.34,118.96 180.34,119.25 180.62,119.53 181.23,119.53 181.52,119.25 181.52,118.96 181.65,118.83 182.06,118.83 182.19,118.96 182.19,119.25 182.47,119.53 185.5,119.53 188.7,122.72 188.7,123.18 188.7,123.18 188.7,136.83 188.57,136.96 v1(188.35,136.96)
PEG_CRX_GTX_P8: length 195.2
  TOP w0.089: v1(70.5,47.02) 70.5,46.99 70.9,46.59 JCPU1.F30
  TOP w0.109: CC25.2 188.82,139.03 188.36,139.03 v3(188.1,138.77)
  IN1 w0.089: 74.06,78.55 74.06,78.51 73.99,78.44 73.99,53.18 73.14,52.33 73.14,51.69 72.82,51.37 72.35,51.37 72.12,51.14 72.12,49.66 71.79,49.33 71.33,49.33 71.11,49.1 71.11,47.67 70.89,47.45 70.75,47.45 70.5,47.19 v1(70.5,47.02)
  IN1 w0.135: v3(188.1,138.77) 187.87,139 186.98,139 186.7,139.28 186.7,139.66 186.57,139.79 186.19,139.79 186.07,139.66 186.07,139.28 185.79,139 185.6,139 185.47,138.88 185.47,136.89 185.6,136.77 186,136.77 186.13,136.89 186.13,138.05 186.41,138.33 187.06,138.33 187.34,138.05 187.34,136.72 187.46,136.59 187.76,136.59 188.06,136.28 188.06,123.61 188.06,122.94 185.18,120.05 178.44,120.05 178.27,119.89 176.27,119.89 175.32,118.94 168.99,118.94 164.2,114.15 162.51,114.15 157.8,109.44 157.44,109.44 153.56,105.56 151.88,105.56 151.31,105 128.71,105 128.07,105.64 121.57,105.64 119.5,103.57 104.82,103.57 103.6,102.34 97.39,102.34 88.96,93.92 88.02,93.92 81.96,87.86 81.58,87.86 81.08,87.35 79.68,87.35 78.67,86.35 78.67,85.36 76.31,83 76.31,81.01 74.06,78.77 74.06,78.55
PEG_CRX_GTX_P9: length 195.7
  TOP w0.089: JCPU1.E35 65.73,45.45 v3(65.25,44.97)
  TOP w0.109: v1(186.56,140.69) 186.78,140.91 186.95,140.91 CC26.2
  IN1 w0.089: 63.73,47.78 63.79,47.78 64.69,46.88 65.36,46.88 65.89,46.36 65.89,45.6 v3(65.25,44.97) ; 63.94,54.04 63.96,54.06 63.96,54.25 63.96,54.34 65.01,55.4 65.59,55.4 65.89,55.71 65.89,70.8 65.73,70.97 65.73,75.11 65.96,75.34 65.96,78.55
  IN1 w0.135: 63.73,47.78 63.56,47.78 63.31,48.03 63.31,52.74 63.94,53.37 63.94,54.04 ; v1(186.56,140.69) 186.35,140.91 185.79,140.91 184.69,139.81 184.69,136.37 183.86,135.53 183.86,134.54 176.64,127.33 172.54,127.33 172.41,127.2 172.41,126.72 172.13,126.44 171.5,126.44 171.23,126.72 171.23,126.91 171.1,127.04 170.66,127.04 170.53,126.91 170.53,125.88 170.16,125.5 163.55,125.5 150.81,112.76 119.04,112.76 116.85,110.56 114.08,110.56 113.39,109.87 101.5,109.87 100.79,109.16 98.41,109.16 97.93,108.68 94.97,108.68 86.63,100.34 84.09,100.34 82.11,98.36 78.11,98.36 76.94,97.19 74.75,97.19 72.73,95.17 72.03,95.17 70.52,93.66 70.52,92.33 67.22,89.03 67.22,84.9 66.66,84.34 66.66,82.58 65.96,81.87 65.96,78.55
PEG_CRX_GTX_P10: length 200.3
  TOP w0.089: v1(67.4,45.89) 67.41,45.88 67.41,45.77 67.73,45.45 JCPU1.E33
  TOP w0.109: v3(191.16,142.27) 191.34,142.44 191.7,142.44 CC27.2
  IN1 w0.089: 78.53,78.55 78.53,78.02 78.46,77.94 78.46,77 77.79,76.34 77.79,51.8 76.04,50.05 76.04,48.75 75.44,48.15 75.44,47.62 74.81,46.99 74.81,46.78 74.57,46.53 73.08,46.53 71.82,45.28 71.82,44.91 70.97,44.05 70.97,43.78 70.72,43.53 69.17,43.53 68.7,44 68.7,44.76 68.09,45.38 67.08,45.38 66.95,45.5 66.95,45.76 67.08,45.89 v1(67.4,45.89)
  IN1 w0.135: 78.53,78.55 78.53,78.56 78.81,78.83 79.05,79.07 79.05,79.65 80.02,80.62 80.02,81.37 81.32,82.67 81.32,83.47 82.55,84.71 82.86,84.71 89.24,91.09 90.13,91.09 98.56,99.52 105.14,99.52 106.36,100.74 120.66,100.74 122.07,102.15 125.16,102.15 125.73,101.58 127.19,101.58 127.76,102.15 130.57,102.15 131.04,101.68 152.8,101.68 153.27,102.15 155.24,102.15 158.25,105.16 158.77,105.16 164.66,111.04 165.23,111.04 168.04,113.85 168.58,113.85 170.72,115.99 185.63,115.99 191.12,121.49 191.12,126.65 191.36,126.89 191.36,142.06 v3(191.16,142.27)
PEG_CRX_GTX_P11: length 200.5
  TOP w0.089: v3(69.48,45.98) 69.01,46.45 JCPU1.F32
  TOP w0.109: v1(189.33,144.08) 189.55,144.3 189.84,144.3 CC28.2
  IN1 w0.089: 76.13,77.94 76.12,77.93 76.12,77.9 76.08,77.85 76.08,77.64 76.03,77.59 75.97,77.53 75.78,77.34 75.78,73.7 75.78,73.7 75.78,73.36 75.78,73.35 75.78,68.62 75.56,68.4 75.56,52.77 74.88,52.09 74.88,50.81 74.39,50.32 74.39,49.95 74.39,49.87 73.88,49.36 73.88,48.81 73.65,48.57 73.18,48.57 73.13,48.53 73.05,48.53 72.53,48.53 72.27,48.53 71.83,48.09 71.83,46.71 70.68,45.57 69.01,45.57 68.82,45.75 68.82,46.13 68.91,46.22 69.33,46.22 69.48,46.06 v3(69.48,45.98)
  IN1 w0.135: 76.13,77.94 76.69,78.5 76.69,79.57 77.76,80.64 77.76,81.31 79.3,82.85 79.3,83.74 82.03,86.47 82.4,86.47 88.56,92.63 89.49,92.63 97.92,101.06 104.3,101.06 105.53,102.28 106.39,102.28 120.03,102.28 121.45,103.7 131.89,103.7 132.3,103.29 151.81,103.29 152.22,103.7 154.09,103.7 163.09,112.7 164.63,112.7 167.8,115.88 168.33,115.88 170.01,117.56 176.39,117.56 176.9,118.06 185.34,118.06 189.58,122.3 189.58,140.13 189.45,140.27 188.75,140.27 188.48,140.54 188.48,141.04 188.75,141.31 189.45,141.31 189.58,141.45 189.58,141.72 189.45,141.85 188.81,141.85 188.53,142.13 188.53,142.62 188.81,142.9 189.45,142.9 189.58,143.03 189.58,143.58 189.91,143.91 189.91,144.31 189.79,144.44 189.69,144.44 v1(189.33,144.08)
PEG_CRX_GTX_P12: length 211.3
  TOP w0.089: JCPU1.D34 66.9,44.31 66.54,43.95 v3(66.38,43.95)
  TOP w0.109: v1(193.14,145.44) 193.39,145.69 193.53,145.69 CC29.2
  IN1 w0.089: v3(66.38,43.95) 66.66,43.95 66.79,43.82 66.79,43.45 67,43.23 67.65,43.23 67.8,43.08 67.8,41.64 68.48,40.96 70.66,40.96 73.04,43.34 73.78,43.34 74.78,44.34 75.61,44.34 75.97,44.69 75.97,45.44 76.9,46.37 76.9,47.06 77.18,47.35 77.55,47.35 77.93,47.73 77.93,49.45 79.58,51.1 79.58,58.19 80.61,59.22 80.61,67.51 79.98,68.14 79.98,76.97 81.52,78.51 81.52,78.55
  IN1 w0.135: 81.52,78.55 81.53,78.56 81.53,79.55 82.33,80.35 82.33,81.11 83.67,82.45 83.67,82.98 89.99,89.3 90.88,89.3 99.3,97.72 109.26,97.72 110.25,98.71 122.41,98.71 122.69,99 122.69,99.62 122.82,99.75 123.24,99.75 123.36,99.62 123.36,99 123.65,98.71 128.62,98.71 129.74,99.84 143.78,99.84 144.18,99.43 156.69,99.43 162.1,104.84 162.1,105.94 165.41,109.25 166.51,109.25 167.87,110.6 168.26,110.6 169.64,111.99 171.06,111.99 173.26,114.19 180.52,114.19 181.35,113.36 183.39,113.36 184.22,114.19 187.36,114.19 188.82,115.66 188.82,116.52 192.92,120.61 192.92,125.58 193.26,125.93 193.26,144.45 192.89,144.82 192.89,145.19 v1(193.14,145.44)
PEG_CRX_GTX_P13: length 210.9
  TOP w0.089: JCPU1.E31 69.98,45.45 v1(70.5,44.93)
  TOP w0.109: v3(190.22,147.35) 190.38,147.51 190.83,147.51 CC30.2
  IN1 w0.089: v1(70.5,44.93) 70.5,45.1 70.41,45.18 69.97,45.18 69.87,45.08 69.87,44.78 70.11,44.54 70.85,44.54 71.26,44.95 71.26,45.57 73.24,47.55 74.56,47.55 74.92,47.9 74.92,50.25 75.3,50.64 75.58,50.64 76.79,51.85 76.79,77.24 77.49,77.94 77.49,78.51 77.47,78.53 77.47,78.55
  IN1 w0.135: 77.47,78.55 77.47,79.22 79.16,80.92 79.16,81.6 80.08,82.53 80.08,83.44 82.21,85.56 82.6,85.56 88.9,91.86 89.81,91.86 98.24,100.29 104.68,100.29 105.9,101.51 106.86,101.51 120.35,101.51 121.77,102.93 125.57,102.93 126.15,102.35 126.87,102.35 127.45,102.93 131.3,102.93 131.76,102.46 152.34,102.46 152.81,102.93 154.89,102.93 157.97,106.02 158.5,106.02 159.52,107.04 159.52,107.94 163.4,111.81 164.84,111.81 168,114.97 168.6,114.97 170.39,116.76 176.69,116.76 177.21,117.29 185.73,117.29 190.35,121.91 190.35,143.25 190.87,143.76 190.87,145.29 190.73,145.43 186.65,145.43 186.37,145.7 186.37,146.33 186.65,146.61 190.73,146.61 190.87,146.74 190.87,147.63 190.77,147.73 190.6,147.73 v3(190.22,147.35)
PEG_CRX_GTX_P14: length 218.5
  TOP w0.089: JCPU1.C33 67.9,43.34 v5(67.39,42.83)
  TOP w0.109: CC31.2 193.49,149.16 193.19,149.16 v3(192.96,148.93)
  IN1 w0.089: v5(67.39,42.83) 67.21,42.65 66.99,42.65 66.67,42.33 66.67,41.49 68.09,40.07 72.9,40.07 73.34,40.51 73.34,40.87 74.86,42.39 74.86,43.11 75.12,43.38 76.1,43.38 76.12,43.36 76.62,43.36 76.64,43.37 76.68,43.37 76.98,43.67 76.98,45.15 77.16,45.32 78.52,45.32 78.65,45.45 78.92,45.73 78.92,47.7 78.94,47.72 78.94,48.22 78.92,48.23 78.92,49.47 80.6,51.14 80.6,55.02 80.72,55.15 80.72,57.85 81.49,58.62 81.49,67.95 81.03,68.41 81.03,77.13 81.64,77.74 81.65,77.74 81.7,77.79 81.73,77.79 81.74,77.79
  IN1 w0.135: 81.74,77.79 82.32,78.38 82.32,79.22 84.89,81.79 84.89,82.3 86.71,84.13 87.84,84.13 91.73,88.02 91.73,89.06 99.62,96.95 109.74,96.95 110.67,97.88 128.88,97.88 130.02,99.02 143.49,99.02 143.9,98.62 156.97,98.62 163.45,105.09 163.45,106.18 165.66,108.4 166.75,108.4 168.02,109.67 168.51,109.67 170,111.15 171.43,111.15 173.65,113.37 180.24,113.37 182.28,111.33 183.42,111.33 185.11,113.02 187.39,113.02 189.71,115.34 189.71,116.29 193.69,120.27 193.69,125.26 194.03,125.61 194.03,147.05 192.48,148.6 192.48,149.04 192.6,149.16 192.73,149.16 v3(192.96,148.93)
PEG_CRX_GTX_P15: length 218.4
  TOP w0.089: JCPU1.B32 68.9,42.64 68.62,42.93 v5(68.41,42.93)
  TOP w0.109: CC32.2 193.91,150.79 193.52,151.19 193.39,151.19 v1(193.17,150.97)
  IN1 w0.089: 79.82,78.37 79.81,78.36 79.78,78.36 79.74,78.32 79.7,78.32 79.7,78.32 79.4,78.02 79.4,76.59 78.99,76.18 78.99,67.34 79.04,67.3 79.04,51.7 76.9,49.57 76.9,47.73 76.52,47.35 76.12,47.35 75.89,47.12 75.89,47.11 75.58,46.8 75.58,46.6 74.29,45.31 73.29,45.31 73.08,45.1 73.08,44.67 72.74,44.33 72.15,44.33 71.7,43.88 71.7,43.35 70.41,42.06 69.08,42.06 68.87,42.27 68.87,42.28 68.86,42.29 68.86,42.4 68.86,42.48 v5(68.41,42.93)
  IN1 w0.135: 79.82,78.37 80.14,78.69 80.14,79.25 81.47,80.58 81.47,81.34 82.34,82.21 82.34,83.05 82.74,83.45 83.05,83.45 89.67,90.07 90.56,90.07 98.98,98.49 105.6,98.49 106.78,99.67 121.05,99.67 122.43,101.05 124.75,101.05 125.28,100.52 127.88,100.52 128.41,101.05 129.51,101.05 129.94,100.62 153.24,100.62 153.73,101.12 157.3,101.12 161.24,105.06 161.24,106.17 165.08,110.02 166.2,110.02 167.65,111.47 167.99,111.47 169.4,112.88 170.76,112.88 172.84,114.96 186.1,114.96 192.15,121.01 192.15,125.9 192.39,126.15 192.39,144.05 192.12,144.32 192.12,147.87 191.69,148.29 191.69,149.56 191.41,149.84 189.86,149.84 189.58,149.56 189.58,148.43 189.46,148.31 188.97,148.31 188.85,148.43 188.85,150.71 188.97,150.84 193.04,150.84 v1(193.17,150.97)
PEG_CTX_GRX_C_N0: length 184.4
  TOP w0.089: JCPU1.M29 71.9,52.56 71.5,52.96 71.5,52.97 71.47,53 v3(71.5,53)
  IN3 w0.089: 73.85,78.55 73.49,78.19 73.22,78.19 72.73,77.71 72.73,76.82 72.8,76.76 72.8,54.69 72.64,54.53 72.22,54.53 71.85,54.16 71.85,53.36 71.49,53 v3(71.5,53)
  IN3 w0.14: v1(201.14,126.96) 200.99,126.81 200.63,126.81 199.49,125.67 199.49,124.19 196.65,121.35 193.76,121.35 190.46,118.05 190.46,114.89 189.07,113.5 188.07,113.5 186.85,112.28 184.82,112.28 182.71,110.17 181.1,110.17 181.09,110.16 181.08,110.16 180.35,109.43 180.35,109.42 179.9,108.97 179.23,108.97 179.11,109.09 177.1,109.09 176.9,109.29 176.9,109.91 176.63,110.19 176.08,110.19 175.8,109.91 175.8,109.33 175.66,109.2 172.15,109.2 171.96,109.39 171.01,109.39 170.6,109.79 167.76,109.79 165.61,107.65 164.37,107.65 163.88,107.15 159.78,107.15 159.61,107.32 152.14,107.32 150.86,106.04 148.4,106.04 148,106.44 144.08,106.44 143.68,106.04 131.08,106.04 130.44,106.69 122.3,106.69 119.74,104.13 99.2,104.13 89.51,94.44 87.89,94.44 80.36,86.91 79.05,86.91 78.48,86.34 78.48,85.09 76.96,83.57 76.52,83.57 76.08,83.13 76.08,82.56 75.11,81.59 75.11,80.08 74.67,79.65 74.67,79.38 73.85,78.55
  BOTTOM w0.109: CC33.2 201.68,126.68 201.41,126.68 v1(201.14,126.96)
PEG_CTX_GRX_C_N1: length 183.7
  TOP w0.089: JCPU1.M32 68.85,52.45 68.39,52.91 v1(68.39,53.02)
  IN3 w0.089: v1(68.39,53.02) 67.95,53.45 67.95,54.02 68,54.07 68,55.16 68.2,55.36 68.61,55.36 69,55.75 69,67.46 68.95,67.51 68.95,78.53 68.93,78.55
  IN3 w0.14: 68.93,78.55 68.85,78.64 68.85,79.36 71.97,82.49 71.97,85.2 72.36,85.6 72.36,86.46 72.78,86.88 73.25,86.88 73.79,87.41 73.79,88.21 76.34,90.77 77.19,90.77 78.6,92.18 78.6,93.1 79.93,94.44 82.46,94.44 85.46,97.43 88.49,97.43 98.58,107.53 119.12,107.53 121.83,110.24 161.01,110.24 165.26,114.49 178.37,114.49 179.39,115.51 183.88,115.51 184.14,115.77 184.14,116.22 184.27,116.35 184.71,116.35 184.84,116.22 184.84,115.77 185.1,115.51 185.75,115.51 186.14,115.9 186.14,117.96 194.49,126.3 196.32,126.3 196.65,126.63 196.65,127.24 196.38,127.51 196.12,127.51 v3(195.93,127.7)
  BOTTOM w0.109: v3(195.93,127.7) 196.1,127.53 196.4,127.53 196.82,127.95 CC34.2
PEG_CTX_GRX_C_N2: length 196
  TOP w0.089: JCPU1.M31 69.9,52.5 69.39,53.01 v3(69.38,53.01)
  IN3 w0.089: 70.94,78.55 70.94,78.54 70.95,78.52 70.95,78.2 70.78,78.03 70.78,55.79 70.59,55.6 70.2,55.6 69.79,55.19 69.79,53.41 69.39,53.01 v3(69.38,53.01)
  IN3 w0.14: 70.94,78.55 70.94,78.56 71.8,79.43 72.38,79.43 73.06,80.1 73.06,80.26 73.52,80.71 73.52,82.72 74.28,83.48 74.28,85.45 75.04,86.21 76.05,86.21 78.28,88.44 78.28,89.97 81.27,92.96 83.98,92.96 87.06,96.04 88.92,96.04 98.61,105.73 119.15,105.73 122.26,108.83 130.48,108.83 131.71,107.61 141.81,107.61 143.04,108.84 147.83,108.84 149.06,107.61 150.24,107.61 151.54,108.92 160.58,108.92 160.73,108.76 163.08,108.76 163.87,109.55 164.28,109.55 164.42,109.41 164.6,109.41 164.91,109.72 164.91,109.9 164.77,110.05 164.77,110.45 165.22,110.9 165.62,110.9 165.83,110.69 166.01,110.69 166.32,111.01 166.32,111.41 166.6,111.68 168.12,111.68 168.27,111.84 168.27,112.42 168.55,112.7 175.11,112.7 175.4,112.41 175.4,111.89 175.54,111.75 175.96,111.75 176.1,111.89 176.1,112.48 176.38,112.75 177.41,112.75 177.68,112.48 177.68,111.91 177.81,111.79 178.42,111.79 178.55,111.91 178.55,112.8 178.88,113.13 179.9,113.13 180.03,113.26 180.03,113.8 180.31,114.07 180.89,114.07 181.16,113.8 181.16,112.07 181.29,111.94 181.67,111.94 181.8,112.07 181.8,113.21 182.07,113.48 182.94,113.48 183.54,114.07 186.22,114.07 187.2,115.05 187.63,115.05 188.54,115.96 188.54,118.48 193.75,123.69 196.72,123.69 197.94,124.91 197.94,128.91 198.62,129.6 199.19,129.6 v1(199.6,130)
  BOTTOM w0.109: v1(199.6,130) 199.87,129.73 200.16,129.73 CC35.2
PEG_CTX_GRX_C_N3: length 196.5
  TOP w0.089: JCPU1.L32 69.02,51.45 v3(69.48,50.98)
  IN3 w0.089: v3(69.48,50.98) 69.26,51.21 68.99,51.21 67.82,52.38 66.18,52.38 65.83,52.73 65.83,54.11 66.2,54.48 66.58,54.48 66.78,54.68 66.78,55.23 67.11,55.56 67.41,55.56 67.79,55.93 67.79,67.41 67.73,67.47 67.73,78.45 67.7,78.48 67.7,78.55
  IN3 w0.14: v1(199.97,133.59) 199.76,133.38 198.39,133.38 198.27,133.49 198.27,133.72 198,134 197.19,134 196.91,133.72 196.91,132.06 197.2,131.78 197.72,131.78 197.85,131.65 197.85,131.2 197.72,131.08 197.2,131.08 196.91,130.79 196.91,130.31 183.99,117.39 183.92,117.39 183.28,117.39 183.28,117.39 179.81,117.39 177.95,115.52 164.83,115.52 160.59,111.28 121.41,111.28 118.69,108.56 98.15,108.56 88.08,98.49 85.06,98.49 82.08,95.52 79.37,95.52 76.9,93.04 76.9,92.16 76.56,91.82 75.15,91.82 72.35,89.02 72.35,88.17 71.04,86.86 71.04,86.53 70.94,86.43 70.94,82.91 67.7,79.67 67.7,78.55
  BOTTOM w0.109: CC36.2 200.63,133.43 200.14,133.43 v1(199.97,133.59)
PEG_CTX_GRX_C_N4: length 200.9
  TOP w0.089: JCPU1.L29 71.9,51.57 71.5,51.97 v1(71.5,51.99)
  IN3 w0.089: v1(71.5,51.99) 71.61,52.11 71.61,52.31 71.54,52.39 71.16,52.39 70.88,52.67 70.88,53.11 70.82,53.17 70.82,55.21 71.17,55.56 71.62,55.56 71.79,55.72 71.79,76.28 71.61,76.45 71.61,77.64 71.76,77.78 71.76,77.82 71.89,77.95 71.95,77.95 71.97,77.98 71.98,77.98
  IN3 w0.14: 71.98,77.98 72.13,77.98 72.88,78.73 73.86,79.71 73.86,79.94 74.29,80.37 74.29,81.97 75.27,82.95 75.27,83.44 76.17,84.34 76.6,84.34 77.71,85.45 77.71,86.75 78.79,87.83 79.36,87.83 79.94,88.42 79.94,90.53 81.45,92.04 84.39,92.04 87.62,95.26 89.24,95.26 98.91,104.93 119.45,104.93 121.98,107.46 130.76,107.46 131.4,106.81 143.14,106.81 143.72,107.39 148.14,107.39 148.72,106.81 150.54,106.81 151.87,108.14 160.09,108.14 160.3,107.94 163.49,107.94 164.04,108.49 165.36,108.49 167.64,110.77 168.55,110.77 168.63,110.69 169.27,110.69 169.4,110.82 169.4,111.64 169.69,111.93 170.32,111.93 170.61,111.64 170.61,110.83 170.73,110.71 171.18,110.71 171.3,110.83 171.3,111.64 171.59,111.93 172.22,111.93 172.51,111.64 172.51,111.11 172.65,110.97 173.07,110.97 173.21,111.11 173.21,111.64 173.48,111.91 174.14,111.91 174.42,111.64 174.42,111.11 174.56,110.97 182.41,110.97 183.41,111.97 183.41,112.74 183.97,113.3 186.54,113.3 187.52,114.28 187.95,114.28 189.32,115.64 189.32,118.15 194.06,122.9 197.1,122.9 198.72,124.51 198.72,126.01 200.25,127.55 200.25,129.19 200.54,129.48 200.79,129.48 200.93,129.62 200.93,130.04 200.79,130.18 200.54,130.18 200.25,130.47 200.25,131.23 200.55,131.53 200.91,131.53 201.48,132.11 201.48,134.04 201.8,134.35 202.8,134.35 203.01,134.56 203.3,134.56 v1(203.55,134.81)
  BOTTOM w0.109: CC37.2 203.92,134.63 203.73,134.63 v1(203.55,134.81)
