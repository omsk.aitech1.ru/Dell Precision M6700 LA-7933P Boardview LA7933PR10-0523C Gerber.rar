# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AC_PRESENT: length 244.7
  TOP w0.102: UH4.H20 21.34,113.78 21.69,113.42 v1(21.69,113.38) ; v1(169.39,156.02) 169.39,155.67 v2(168.99,155.27) R835.1 168.26,154.01 168.26,153.26 167.97,152.98 U54.A54
  IN4 w0.102: 18.48,113.44 18.82,113.78 19.16,113.78 19.17,113.77 21.3,113.77 v1(21.69,113.38)
  IN4 w0.109: v1(169.39,156.02) 169.39,155.8 167.05,153.47 167.05,152.88 166.8,152.63 158.14,152.63 157.85,152.92 152.45,152.92 151.03,154.34 149.62,154.34 147.09,156.87 141.4,156.87 138.42,153.89 116.36,153.89 115.96,153.49 113.08,153.49 111.09,155.49 108.8,155.49 106.82,153.51 104.98,153.51 104.31,152.83 97.55,152.83 97.34,152.83 95.48,150.97 81.73,150.97 80.75,151.96 80.21,151.96 76.03,156.13 76.03,158.85 73.95,160.93 65.56,160.93 65.09,161.4 64.2,161.4 62.83,162.78 50.53,162.78 50.43,162.67 45.29,162.67 43.98,161.37 35.89,161.37 33.92,163.34 19.61,163.34 14.6,158.33 14.6,150.81 16.28,149.13 16.28,138.42 15.59,137.73 15.59,136.21 14.76,135.37 14.76,133.88 14.14,133.26 14.14,132.75 11.49,130.11 10.44,130.11 6.87,126.53 6.87,122.83 7.82,121.89 7.82,121.13 6.58,119.89 6.58,114.29 6.88,113.99 6.88,113.97 7,113.86 7,113.04 7.28,112.75 9.64,112.75 10.56,113.68 12.63,113.68 13.05,113.27 18.31,113.27 18.48,113.44
ACAV_DOCK_SRC#: length 142.1
  TOP w0.254: v1(175.8,63.79) v2(176.5,63.79) 177.15,63.79 PR1013.2 177.51,64.58 176.88,65.2 PR1017.1
  IN2 w0.254: v1(162.72,109.77) 162.35,110.14 129.85,110.14 128.42,111.57 108.41,111.57 105.24,114.73 105.24,117.56 102.88,119.93 98.66,119.93 97.1,121.49 97.1,123.01 96.07,124.04 93.61,124.04 92.39,125.26 v1(92.06,125.26)
  IN3 w0.254: v1(171.79,92.22) 171.79,91.05 172.29,90.55 172.29,80.26 171.6,79.58 171.6,67.55 172.87,66.28 172.87,64.36 173.44,63.79 v1(175.8,63.79)
  BOTTOM w0.254: v1(92.06,125.26) 91.74,125.58 JDOCK1.42 ; v1(162.72,109.77) 162.72,108.9 161.81,107.99 161.81,103.49 162.72,102.58 162.72,100.61 165.97,97.36 165.97,94.09 167.16,92.91 171.08,92.91 171.78,92.22 v1(171.79,92.22)
ACAV_IN: length 344.8
  TOP w0.254: U18.27 143.07,164.02 143.17,164.11 143.17,164.45 142.71,164.91 v1(142.61,164.91) ; v1(173.65,22.81) 173.73,22.9 178.05,22.9 178.44,23.29 PR916.1 PR911.2 178.41,26.01 PR915.1 PR912.2 ; U54.B1 161.96,151.13 161.3,151.79 v1(160.67,151.79) ; v1(179.08,65.22) 178.92,65.38 PR1021.1 ; v1(185.42,66.12) 185.32,66.22 v2(185.32,70.73) 185.32,75.38 178.79,81.9 176.87,81.9 170.04,88.74 162.8,88.74 159.83,91.71 159.83,102.7 160.54,103.41 160.54,110.72 161.66,111.84 161.66,133.11 161.42,133.35 161.42,135.71 160.12,137.01 160.12,138.7 v1(160.22,138.8)
  IN1 w0.254: v1(179.08,65.22) 179.08,65.13 177.52,63.56 177.52,62.19 176.76,61.43 v1(176.76,51.88) ; v1(160.67,151.79) 160.3,152.16 158.9,152.16 158.3,151.56 158.3,142.25 160.12,140.44 160.12,138.9 v1(160.22,138.8)
  IN2 w0.254: v1(160.67,151.79) 160.67,151.84 160.89,152.07 161.67,152.07 162.19,152.59 171.19,152.59 171.66,152.12 172.08,152.12 172.55,152.59 175.49,152.59 176.25,153.35 176.99,153.35 177.14,153.2 180.01,153.2 182.92,150.29 192.48,150.29 v1(192.58,150.19)
  IN3 w0.254: v1(192.58,150.19) 193.19,150.19 193.89,150.89 193.89,154.92 194.5,155.52 203.85,155.52 v1(204.48,154.89) ; v1(160.67,151.79) 160.46,151.79 155.92,156.34 155.92,159.46 153.72,161.66 151.14,161.66 150.84,161.35 148.49,161.35 147.62,162.22 145.32,162.22 142.63,164.91 v1(142.61,164.91) ; v1(173.65,22.81) 173.65,21.63 175.94,19.33 208.47,19.33 211.77,22.63 223.87,22.63 226.15,20.36 226.15,16.83 228.14,14.83 244.74,14.83 v1(245.91,16) ; v1(179.08,65.22) 179.08,65.38 179.51,65.81 185.11,65.81 v1(185.42,66.12)
  BOTTOM w0.254: v1(173.65,22.81) 167.38,22.81 165.52,24.68 165.52,39.92 176.38,50.78 176.38,51.5 v1(176.76,51.88) ; v1(245.91,16) 246.01,15.9 PQ910.2 ; v1(204.48,154.89) 205.27,154.89 205.56,154.6 205.56,153.96 205.35,153.75 U17.1
ACAV_IN_NB: length 272.5
  TOP w0.102: v1(230.72,16.45) 229.25,14.97 227.86,14.97 226.74,16.09 226.74,20.03 223.48,23.29 210.64,23.29 209.02,24.92 209.02,53.28 209.93,54.19 226.77,54.19 v2(226.9,54.06) 227.86,54.06 228.04,54.24 232.79,54.24 232.97,54.06 237.46,54.06 243.98,60.58 243.98,61.15 243.52,61.61 243.52,67.56 243.95,67.99 v1(243.96,67.99) ; v1(176.38,78.93) 176.38,81.43 169.62,88.19 162.29,88.19 159.31,91.17 159.31,102.92 160.01,103.62 160.01,110.94 161.11,112.03 161.11,131.15 160.35,131.92 160.35,136.04 159.51,136.88 159.51,139.38 160.56,140.44 160.56,143.46 160.98,143.88 U54.A15
  TOP w0.254: v1(176.38,78.93) PR1019.2
  IN2 w0.127: v1(243.96,67.99) 243.65,67.99 242.37,66.71 231.14,66.71 229.06,64.62 229.06,63.78 227.7,62.42 226.04,62.42 225.9,62.56 204.4,62.56 202.61,60.77 199.53,60.77 199.12,60.36 194.23,60.36 192.27,62.32 189.22,62.32 187.46,60.57 184.59,60.57 184.47,60.68 183.88,60.68 182.18,62.38 182.18,73.44 177.87,77.74 177.87,79.08 177.58,79.38 176.82,79.38 v1(176.38,78.93)
  BOTTOM w0.102: v1(243.96,67.99) U47.1 ; PR938.2 230.29,16.02 v1(230.72,16.45)
ACAVDK_SRC: length 2.7
  TOP w0.254: PR1017.2 176.88,68.22 176.37,68.74 PU1001.4
ACAVIN: length 2.7
  TOP w0.254: PR1021.2 178.37,67.38 178.37,67.88 178.37,67.89 178.37,68.31 178.37,68.32 PU1001.8
ALERT#: length 5.4
  TOP w0.102: PR725.2 22.58,78.04 v1(22.83,77.79) 23.64,78.59 PU702.6
  BOTTOM w0.102: PR743.1 22.17,77.12 v1(22.83,77.79) 23.32,78.27 23.89,78.27 v2(24.05,78.11)
ALW_ON_3.3V#: length 22.5
  TOP w0.102: QH6.2 11.26,125.02 11.36,125.12 12.27,125.12 v1(12.66,125.51)
  IN1 w0.109: v1(12.04,133.78) 12.04,133.33 10.58,131.86 10.58,129.98 10.76,129.8 10.76,126.75 11.05,126.45 11.67,126.45 12.06,126.85 12.7,126.85 13.17,126.38 13.17,126.02 v1(12.66,125.51)
  BOTTOM w0.102: v1(12.04,133.78) 12.19,133.63 14.01,133.63 14.72,134.34 Q305.6 14.79,134.69 14.79,135.57 14.67,135.7 R907.2 14.07,135.48 Q305.5 ; v2(10.91,135.69) 11.21,135.39 Q66.2
  BOTTOM w0.127: v1(12.04,133.78) 12.04,134.23 11.69,134.57 Q66.2
ALW_PWRGD_3V_5V: length 224.6
  TOP w0.102: v1(242.06,56.07) v2(242.06,55.52)
  TOP w0.254: v1(182.94,51.94) 181.34,53.54 181.34,63.02 182.48,64.16 185.06,64.16 186.51,65.61 186.51,75.3 178.7,83.11 177.02,83.11 173.33,86.81 173.33,87.61 171.09,89.85 163.66,89.85 160.96,92.56 160.96,101.92 161.75,102.71 161.75,107.49 163.52,109.27 163.52,132.6 164.27,133.35 v1(164.27,136.45) ; v1(165.52,143.93) 165.32,144.13 U54.B15
  IN1 w0.254: v1(165.52,143.93) 165.73,143.93 166.09,143.57 166.09,142.82 165.49,142.23 165.49,140.56 164.27,139.34 v1(164.27,136.45)
  IN2 w0.254: v1(182.94,51.94) 182.94,52.9 183.17,53.12 185.53,53.12 186.09,53.68 192.66,53.68 194.28,52.06 202.06,52.06 202.35,52.35 203.57,52.35 204.28,51.64 204.28,51.38 204.89,50.78 205.6,50.78 206.69,51.87 206.69,55 209.08,57.39 220.88,57.39 222.37,55.91 224.26,55.91 225.84,57.49 227.57,57.49 228.27,58.19 v1(228.71,58.19) ; v1(242.06,56.07) 243.99,56.07 247.24,59.32 268.95,59.32 v1(271.92,62.29)
  IN4 w0.254: v1(242.06,56.07) 241.53,55.54 230.76,55.54 228.71,57.58 v1(228.71,58.19)
  BOTTOM w0.254: PR114.1 v1(271.92,62.29) 272,62.29 273.28,61.01 PU101.23
ALWON: length 213.3
  TOP w0.102: U54.A60 164.97,153.24 164.93,153.28 v1(164.93,153.45) ; v1(215.47,91.28) 216.15,90.59 216.15,85.42 213.71,82.98 209.59,82.98 208.01,81.39 198.42,81.39 195.93,83.88 183.17,83.88 v1(183.09,83.81)
  IN1 w0.109: v1(183.09,83.81) 183.06,83.85 183.06,83.9 184.34,85.18 184.34,92.55 186.97,95.18 186.97,98.66 186.87,98.77 186.87,102.45 189.76,105.35 189.76,106.74 189.37,107.14 189.37,108.83 190.43,109.89 190.43,110.01 190.42,110.02 v1(190.42,110.07) ; v1(225.79,83.37) 226.38,83.96 231.04,83.96 232.2,82.8 232.62,82.8 233.03,82.39 233.03,81.97 233.46,81.53 238.04,81.53 238.32,81.26 240.39,81.26 240.75,80.9 243.46,80.9 243.67,81.1 244.04,81.1 244.83,80.31 244.83,75.78 248.07,72.54 248.07,68.71 250.9,65.88 v1(250.9,65.04) ; v1(164.93,153.45) 166.91,151.47 168.91,151.47 169.14,151.24 169.14,149.89 169.54,149.48 171.57,149.48 172.37,148.68 173.01,148.68 175.48,146.21 175.48,145.71 176.16,145.03 176.16,142.98 176.63,142.51 176.63,140.08 v1(176.66,140.06)
  IN2 w0.127: v1(190.42,110.07) 189.62,110.87 189.62,133.35 188.25,134.72 188.25,136.07 187.77,136.56 187.77,137.49 187.79,137.52 v1(187.79,137.49)
  IN4 w0.109: v1(187.79,137.49) 187.79,137.52 187.77,137.54 187.77,137.69 185.75,139.71 185.75,140.89 185.33,141.31 183.68,141.31 182.38,140.02 182.38,139.81 181.56,138.99 178.1,138.99 177.04,140.06 v1(176.66,140.06)
  BOTTOM w0.102: v1(215.47,91.28) 215.73,91.28 216.52,92.06 v2(220.95,92.06) 223.59,92.06 226.43,89.23 226.43,84.01 v1(225.79,83.37) ; v1(250.9,65.04) 250.95,65.04 255.42,60.57 266.53,60.57 266.77,60.8 PR115.1
AUD_HP_NB_SENSE: length 292.5
  TOP w0.102: JIO1.39 v1(29.72,34.15)
  IN1 w0.109: v3(223.14,56.69) 223.2,56.76 223.2,57.74 226.63,61.17 229.06,63.6 229.06,66.08 229.74,66.76 229.74,68.35 232.15,70.76 232.15,75.98 233.74,77.56 236.13,77.56 v1(236.98,78.41)
  IN4 w0.109: v1(29.72,34.15) 30.36,33.5 30.36,29.99 30.19,29.81 30.19,27.33 30.5,27.01 30.5,24.91 29.28,23.69 29.08,23.69 28.17,22.78 28.17,18.93 27.48,18.24 27.48,13.01 31.93,8.56 34.54,8.56 36.28,6.82 106.26,6.82 108.41,8.97 110.74,8.97 112.56,10.79 112.56,12.9 114.72,15.06 117.23,15.06 119.94,12.36 119.94,11.49 120.78,10.66 121.43,10.66 122.15,11.38 123.11,11.38 123.48,11.75 123.67,11.75 123.67,11.75 131.71,11.75 132.85,12.89 154.69,12.89 155.35,13.55 157.41,13.55 158.11,12.85 160.6,12.85 161.97,14.23 161.97,19.16 164.62,21.81 164.62,35.3 166.25,36.93 166.25,39.84 175.86,49.45 178.49,49.45 179.45,50.41 180.43,50.41 181.09,51.07 190.29,51.07 194.57,55.35 196.52,55.35 198.8,57.63 222.92,57.63 223.18,57.37 223.18,56.73 v3(223.14,56.69)
  BOTTOM w0.102: U46.A41 237.08,78.31 v1(236.98,78.41)
AUD_NB_MUTE#: length 286.5
  TOP w0.102: JIO1.43 29.23,32.95 28.95,32.68 v1(28.95,32.31)
  IN1 w0.109: v1(222.73,57.19) 222.76,57.21 222.76,57.62 226.4,61.26 228.69,63.55 228.83,63.7 228.83,66.17 229.51,66.85 229.51,68.45 231.93,70.86 231.93,76.05 233.65,77.77 235.43,77.77 v1(236.08,78.42)
  IN4 w0.109: v1(28.95,32.31) 28.95,32.33 29.42,32.79 29.79,32.79 30.1,32.48 30.1,30.15 29.96,30.01 29.96,27.24 30.28,26.92 30.28,25.01 29.18,23.91 28.98,23.91 27.94,22.87 27.94,19.02 27.25,18.34 27.25,12.93 29.08,11.1 29.08,10.08 30.86,8.31 34.35,8.31 36.07,6.59 106.44,6.59 108.58,8.74 116.57,8.74 118.12,10.29 121.39,10.29 121.8,10.7 122.75,10.7 123.57,11.52 131.8,11.52 132.9,12.62 160.69,12.62 162.2,14.14 162.2,19.07 164.9,21.77 164.9,35.07 166.48,36.65 166.48,39.75 175.96,49.22 178.63,49.22 179.56,50.15 180.53,50.15 181.23,50.84 190.38,50.84 194.67,55.13 196.63,55.13 198.5,57 222.54,57 v1(222.73,57.19)
  BOTTOM w0.102: v1(222.73,57.19) 223.21,57.19 v2(223.3,57.28) ; v1(236.08,78.42) U46.A39
AUX_EN_WOWL: length 132.9
  TOP w0.102: v1(174.45,88.67) 174.64,88.67 175.84,87.47 175.84,86.27 177.65,84.47 179.17,84.47 181.75,81.89 185.12,81.89 185.43,82.21 187.21,82.21 188.1,81.32 195.12,81.32 198.32,78.11 198.32,70.34 199.55,69.11 202.57,69.11 206.96,64.72 228.07,64.72 229.07,63.72 231.05,63.72 231.56,63.21 235.56,63.21 235.93,63.58 238.93,63.58 240.5,65.15 240.5,68.15 v1(240.78,68.43)
  IN1 w0.109: v1(173.73,109.87) 173.73,110.1 173.35,110.48 172.5,110.48 172.1,110.07 172.1,108.26 165.61,101.77 165.61,99.89 162.37,96.65 162.37,87.29 162.6,87.06 172.83,87.06 v1(174.45,88.67)
  BOTTOM w0.102: v1(240.78,68.43) 241.05,68.7 U46.B67 ; v1(173.73,109.87) 173.73,109.23 R717.1 174.18,108.78 175.07,108.78 v2(175.3,109) 175.58,109.28 Q310.2
AUX_EN_WOWL#: length 4.7
  BOTTOM w0.102: Q310.5 179.04,109.28 179.2,109.13 179.2,108.8 179.03,108.63 Q310.6 178.25,108.63 178.05,108.43 178.05,108.12 178.66,107.51 R715.2 v2(179.63,107.22)
AUX_MODE_EN: length 3.3
  BOTTOM w0.102: R13.2 240.13,79.95 v2(239.36,79.17) 238.94,78.75 238.94,78.13 239.08,77.99 U46.A45
B_PRE0: length 3.4
  BOTTOM w0.102: U26.8 214.16,84.9 214.92,84.14 R46.2 R87.1
B_PRE1: length 6
  BOTTOM w0.102: R39.2 R82.1 206.42,82.22 206.83,82.62 208.05,82.62 208.37,82.94 208.37,84.16 v2(208.44,84.23) 208.61,84.4 U26.17
BAT1_LED#: length 267.3
  TOP w0.102: JIO1.104 37.16,14.95 37.95,14.16 42.25,14.16 43.53,12.88 43.53,12.32 43.98,11.88 v1(44.04,11.88)
  IN1 w0.109: v1(44.04,11.88) 45.03,10.88 101.92,10.88 104.65,13.61 105.42,13.61 107.81,16 111.79,16 113.5,17.71 118.22,17.71 120.26,15.67 128.31,15.67 128.81,15.18 149.54,15.18 151.84,17.48 156.62,17.48 159.82,14.28 165.55,14.28 167.13,15.86 167.13,24.02 165.85,25.3 165.85,39.56 165.87,39.58 165.87,39.75 177.46,51.34 v1(177.46,51.68) ; v1(240.73,70.26) 243.53,70.26 243.83,70.56 244.5,70.56 245.15,69.91 245.15,67.89 246.32,66.72 246.34,66.72 v1(246.35,66.71)
  IN3 w0.127: v1(177.46,51.68) 178.41,51.68 180.22,53.48 185.27,53.48 186.47,54.68 186.67,54.68 188.82,56.83 193.47,56.83 194.54,57.9 201.34,57.9 207.49,64.05 221.91,64.05 223.57,62.38 231.2,62.38 231.46,62.64 241.08,62.64 245.16,66.71 v1(246.35,66.71)
  BOTTOM w0.102: v1(240.73,70.26) 240.78,70.2 U46.B64 ; v1(44.04,11.88) v2(44.04,11.23)
BAT2_LED#: length 252.9
  TOP w0.102: v1(34.91,15.18) 34.94,15.22 34.96,15.22 35.3,15.55 JIO1.102
  IN1 w0.109: v1(177.44,52.36) 177.9,51.91 177.9,51.49 166.08,39.66 166.08,25.55 167.36,24.27 167.36,15.76 165.64,14.05 159.73,14.05 156.53,17.25 151.97,17.25 149.67,14.95 128.71,14.95 128.22,15.44 120.16,15.44 118.12,17.48 113.59,17.48 110.92,14.81 109.59,14.81 108.79,14.01 108.17,14.01 107.55,13.39 104.75,13.39 102.02,10.66 39.47,10.66 34.94,15.18 v1(34.91,15.18)
  IN3 w0.127: v1(236.58,65.94) 236.42,65.94 233.35,62.87 231.35,62.87 231.1,62.61 223.67,62.61 222.01,64.28 207.38,64.28 201.23,58.13 194.44,58.13 193.37,57.06 187.72,57.06 187.44,56.78 187.44,56.01 185.82,54.39 184.83,54.39 184.15,53.71 179.55,53.71 178.2,52.36 v1(177.44,52.36)
  BOTTOM w0.102: v1(236.58,65.94) U46.A9 ; v1(34.91,15.18) v2(34.91,15.8)
BAY_SMBCLK: length 3.2
  TOP w0.102: U54.A7 v2(159.47,147.88) 158.99,147.88 158.99,147.88 158.47,147.88 158.35,147.75 R856.1
BAY_SMBDAT: length 5.5
  TOP w0.102: U54.B7 162.63,148.13 162.77,147.98 v1(162.84,147.98)
  BOTTOM w0.102: v1(162.84,147.98) 162.69,147.98 162.57,147.87 v2(160.87,147.87) 159.31,147.87 158.82,147.38 R854.1
BBS_BIT0_R: length 64.9
  TOP w0.102: UH4.P1 24.32,104.44 24.32,103.47 24.26,103.4 24.26,102.16 RH52.1 22.69,100.6 22.69,99.76 22.83,99.62 22.83,99.12 22.41,98.7 22.41,98.68 22.96,98.68 v2(23.86,97.78) 24.13,97.51 24.13,97.42 24.48,97.07 QH1.1 ; v1(63.1,96.6) 63.8,97.3 67.46,97.3 67.66,97.5 70.55,97.5 71.09,98.04 RH26.1
  TOP w0.127: 22.41,98.68 v1(22.39,98.68)
  IN2 w0.127: v1(63.1,96.6) 63.05,96.6 63.02,96.57 62.77,96.57 61.06,98.29 59.03,98.29 58.09,99.23 52.67,99.23 50.3,96.86 48.66,96.86 48.12,97.41 41.24,97.41 40.63,96.8 38.45,96.8 38.13,96.48 35.71,96.48 34.86,95.63 33.91,95.63 33.29,96.25 28.21,96.25 27.66,96.8 27.32,97.14 24.35,97.14 23.08,98.41 22.68,98.41 22.41,98.68 v1(22.39,98.68)
BBS_BIT1: length 6.4
  TOP w0.102: v1(19.79,127) 19.54,127 UH4.D47 ; v1(18.67,129.95) 17.63,130.99 RH342.1
  BOTTOM w0.102: v1(19.79,127) 19.73,127.05 19.33,127.05 18.82,127.56 v2(18.82,129.35) 18.83,129.36 18.83,129.71 18.67,129.87 v1(18.67,129.95)
BC_CLK_ECE1117: length 140.8
  TOP w0.102: v1(97.78,110.62) 97.78,112.23 96.23,113.78 96.21,113.78 95.73,114.26 v1(95.11,114.26) ; v1(82.57,116.95) 82.56,116.95 81.75,116.14 JKB1.4 81.75,114.02 82.15,113.61 82.15,113.03 81.75,112.62 JKB1.3 ; U54.A20 164.47,139.91 164.73,139.65 164.73,133.17 163.92,132.36 163.92,109.14 162.29,107.52 162.29,102.52 v1(162.14,102.38)
  IN2 w0.127: v1(162.14,102.38) 162.04,102.48 151.57,102.48 149.59,104.46 145.57,104.46 145.06,103.95 130.5,103.95 128.54,105.91 125.13,105.91 124.45,105.23 124.45,104.33 123.81,103.7 100.23,103.7 97.78,106.15 v1(97.78,110.62) ; v1(95.11,114.26) 94.87,114.26 92.74,116.39 92.1,116.39 90.59,117.89 85.85,117.89 84.45,116.5 83.03,116.5 v1(82.57,116.95)
  BOTTOM w0.102: v1(97.78,110.62) v2(96.95,110.62)
BC_CLK_ECE5048: length 152.1
  TOP w0.102: v1(186.13,95.31) 185.61,95.83 185.61,97.87 185.09,98.39 185.09,99.91 184.96,100.04 184.59,100.04 184.47,100.17 184.47,100.42 184.59,100.55 184.85,100.55 184.98,100.67 184.98,101.05 184.85,101.18 183.72,101.18 183.59,101.05 183.59,100.67 183.46,100.54 183.21,100.54 183.08,100.67 183.08,101.05 182.96,101.18 182.54,101.18 181.7,102.03 181.7,102.95 182.97,104.22 182.97,111.12 179,115.08 179,129.12 179.45,129.56 179.45,134.09 179.32,134.21 178.93,134.21 178.81,134.34 178.81,134.6 178.93,134.72 179.33,134.72 179.46,134.85 179.46,135.05 179.33,135.18 v1(178.9,135.18) ; v1(174.95,149.48) 174.95,148.82 174.83,148.69 174.61,148.69 174.48,148.57 174.48,147.24 174.36,147.11 174.1,147.11 173.98,147.24 173.98,148.36 173.85,148.49 172.66,148.49 172.55,148.38 U54.A43 ; v1(220.31,67.31) 220.27,67.31 219.99,67.59 v2(219.99,69.7) 219.99,69.96 220.6,70.57 221.54,70.57 222.47,71.5 223.2,71.5 224.86,73.17 225.45,73.17 226.07,73.79 229.31,73.79 v1(229.98,74.46)
  IN1 w0.109: v1(174.95,149.48) 174.95,149.14 174.73,148.91 174.72,148.91 174.63,148.82 174.63,148.64 174.82,148.45 175,148.45 175.14,148.58 175.31,148.58 175.5,148.39 175.5,148.22 175.37,148.08 175.37,147.9 175.55,147.72 175.73,147.72 175.82,147.82 176,147.82 176.18,147.64 176.18,147.46 176.09,147.36 176.09,147.18 176.27,147 176.45,147 176.54,147.1 176.72,147.1 177.1,146.72 177.1,146.4 178.41,145.09 178.41,144.83 178.32,144.74 177.96,144.74 177.84,144.62 177.84,144.36 177.96,144.24 178.41,144.24 178.54,144.11 178.54,143.85 178.41,143.73 178.12,143.73 177.99,143.6 177.99,141.39 178.09,141.29 178.32,141.29 178.45,141.16 178.45,136.95 178.57,136.82 178.68,136.82 178.81,136.69 178.81,136.44 178.68,136.31 178.54,136.31 178.42,136.2 178.42,135.2 178.54,135.09 178.81,135.09 v1(178.9,135.18) ; v1(183.68,81.34) 182.64,82.38 182.64,84.44 183.78,85.59 183.78,92.96 v1(186.13,95.31)
  IN4 w0.109: v1(183.68,81.34) 183.04,80.7 183.04,80.1 192.15,70.99 197.36,70.99 199.55,68.8 203.05,68.8 205.55,66.29 216.74,66.29 217.71,67.27 220.27,67.27 v1(220.31,67.31)
  BOTTOM w0.127: v1(229.98,74.46) 230.47,74.95 U46.A30
BC_CLK_EMC4002: length 36.8
  TOP w0.102: U54.A12 160.97,145.38 160.74,145.15 160.23,145.15 159.9,145.48 v1(159.9,145.63) ; v1(143.57,155.42) U18.11
  IN3 w0.127: v1(159.9,145.63) 159.87,145.63 159.4,145.16 158.55,145.16 157.03,146.67 149.2,146.67 149.07,146.55 149.07,145.12 148.94,145 148.69,145 148.56,145.12 148.56,146.55 148.44,146.67 148.18,146.67 148.06,146.55 148.06,145.12 147.93,145 147.67,145 147.55,145.12 147.55,146.55 147.42,146.67 147.15,146.67 146.98,146.5 146.98,145.97 146.77,145.77 v1(146.25,145.77)
  BOTTOM w0.102: v1(143.57,155.42) 143.61,155.42 143.9,155.13 143.9,153.29 145.82,151.37 145.82,147.78 145.95,147.65 v2(146.2,147.65) 146.49,147.65 146.62,147.52 146.62,147.27 146.49,147.14 145.95,147.14 145.82,147.02 145.82,146.76 145.95,146.63 146.49,146.63 146.62,146.51 146.62,146.27 146.49,146.14 146.34,146.14 146.21,146.01 146.21,145.81 v1(146.25,145.77)
BC_DAT_ECE1117: length 138.9
  TOP w0.102: JKB1.8 JKB1.7 83.75,110.44 84.85,109.37 84.85,107.63 85.06,107.42 85.93,107.42 86.32,107.02 94.87,107.02 v1(98.44,110.59) ; v1(158.85,104.37) 159.33,104.85 159.33,110.97 160.64,112.28 160.64,130.8 159.73,131.72 159.73,135.73 158.6,136.86 v1(158.6,137.22) ; v1(164.13,143.52) 164.22,143.43 U54.B21
  IN2 w0.127: v1(98.44,110.59) 98.44,105.82 100.3,103.95 123.74,103.95 124.22,104.43 124.22,105.33 125.03,106.14 128.66,106.14 130.43,104.37 144.49,104.37 144.8,104.69 149.68,104.69 151.65,102.72 156.3,102.72 156.31,102.71 157.19,102.71 v1(158.85,104.37)
  BOTTOM w0.102: v1(158.6,137.22) 158.6,137.95 R817.2 160.71,138.24 v2(161.13,138.66) 162.34,139.87 162.34,142.05 163.04,142.75 163.46,142.75 164.13,143.42 v1(164.13,143.52)
BC_DAT_ECE5048: length 157.8
  TOP w0.102: v1(233.56,75.12) 233.56,75.07 233.15,74.65 231.24,74.65 230.99,74.91 228.33,74.91 227.52,74.09 226.01,74.09 225.28,73.37 224.78,73.37 223.12,71.7 222.38,71.7 221.46,70.78 219.76,70.78 219.56,70.57 219.56,70.1 219.43,69.97 218.76,69.97 218.63,69.85 218.63,69.59 218.76,69.47 219.43,69.47 219.56,69.34 219.56,66.68 v1(219.8,66.43) ; U54.B45 171.31,148.12 v1(170.55,148.12) ; v1(179.5,91.64) 181,93.14 181,96.41 180.69,96.71 180.69,105.43 181.41,106.14 181.41,110.87 175.82,116.45 175.82,127.93 176.21,128.32 176.21,131.22 175.46,131.97 175.46,133.38 176,133.92 176,134.86 v1(176.25,135.12)
  IN1 w0.109: v1(176.25,135.12) 175.69,135.68 175.69,142.23 175.45,142.47 175.45,144.08 175.11,144.41 174.87,144.41 174.55,144.72 174.55,144.81 171.26,148.1 170.57,148.1 v1(170.55,148.12)
  IN2 w0.127: v1(179.5,91.64) 180.08,91.64 181.11,90.62 181.78,90.62 183.45,88.94 183.45,85.45 186.03,82.87 186.03,69.77 189.96,65.84 198.51,65.84 200.7,63.65 202.3,63.65 202.42,63.77 202.79,63.77 202.85,63.7 217.54,63.7 219.89,66.05 219.89,66.35 v1(219.8,66.43)
  BOTTOM w0.102: U46.B31 232.59,74.7 232.64,74.65 233.15,74.65 233.56,75.07 v1(233.56,75.12) ; v1(170.55,148.12) 170.57,148.1 170.83,148.1 v2(171.6,148.87) 172.59,149.86 173.12,149.86 173.43,149.56 173.43,149.34 174.88,147.89 R814.2
BC_DAT_EMC4002: length 40.4
  TOP w0.102: v1(162.81,144.92) 162.81,144.95 162.63,145.13 U54.B13 ; v1(143.07,154.99) U18.10
  IN3 w0.127: v1(162.81,144.92) 161.44,146.29 158.01,146.29 157.4,146.9 146.71,146.9 v1(145.59,145.78)
  BOTTOM w0.102: v1(162.81,144.92) 160.79,144.92 160.16,144.29 159.32,144.29 159.11,144.07 159.11,143.1 R821.1 ; v1(143.07,154.99) 143.46,154.99 143.67,154.78 143.67,154.49 143.55,154.36 143.31,154.36 143.18,154.23 143.18,153.98 143.31,153.85 143.55,153.85 143.67,153.73 143.67,153.39 143.55,153.26 142.85,153.26 142.72,153.13 v2(142.72,153.01) 142.72,152.88 142.85,152.75 143.55,152.75 143.67,152.63 143.67,151.79 143.86,151.6 145.27,151.6 145.59,151.28 v1(145.59,145.78)
BC_INT#_ECE1117: length 135.5
  TOP w0.102: JKB1.9 JKB1.10 84.75,116.54 85.19,116.98 85.19,118.09 87.78,120.68 v1(87.82,120.68) ; v3(162.13,109.27) 162.23,109.37 162.23,110.78 163.04,111.59 163.04,132.78 163.83,133.57 163.83,141.07 163.97,141.22 U54.A19
  IN2 w0.127: v3(162.13,109.27) 161.87,109.02 143.9,109.02 142.37,107.48 133.32,107.48 131.61,109.2 129.43,109.2 128.62,110.01 123.31,110.01 122.81,110.52 107.57,110.52 104.91,113.18 103.43,113.18 102.09,114.52 102.09,116.32 101.81,116.6 101.41,116.6 100.63,117.37 99.53,117.37 99.4,117.25 99.4,116.97 99.27,116.84 99.02,116.84 98.89,116.97 98.89,117.75 98.77,117.88 98.51,117.88 98.39,117.75 98.39,116.97 98.26,116.84 98,116.84 97.88,116.97 97.88,117.95 97.75,118.07 97.5,118.07 97.37,117.95 97.37,116 97.24,115.88 96.99,115.88 96.86,116 96.86,117.25 96.73,117.37 96.48,117.37 96.35,117.25 96.35,116.05 96.23,115.93 95.97,115.93 95.85,116.05 95.85,117.25 95.72,117.37 95.46,117.37 95.34,117.25 95.34,116.97 95.21,116.84 94.96,116.84 94.83,116.97 94.83,117.25 94.7,117.37 94.22,117.37 92.09,119.51 88.99,119.51 v1(87.82,120.68)
BC_INT#_ECE5048: length 154.7
  TOP w0.102: v1(176.36,135.76) 176.27,135.76 175.77,135.26 175.77,133.98 175.23,133.44 175.23,131.91 175.98,131.16 175.98,128.38 175.59,127.99 175.59,116.36 181.18,110.77 181.18,106.24 180.47,105.52 180.47,96.62 180.74,96.34 180.74,93.23 179.81,92.29 v1(179.45,92.29) ; U54.A42 172.88,147.88 v1(173.02,148.02) ; v1(220.71,66.57) 220.71,66.59 220.8,66.68 v2(220.8,67.86) 220.8,68.71 220.34,69.16 220.34,69.99 220.72,70.37 221.63,70.37 222.53,71.27 223.33,71.27 224.99,72.94 225.55,72.94 226.2,73.58 229.43,73.58 229.71,73.86 230.03,73.86 230.62,74.45 v1(230.62,74.45)
  IN1 w0.109: v1(173.02,148.02) 173.02,147.24 174.85,145.42 175.13,145.42 175.7,144.84 175.7,142.62 175.92,142.41 175.92,136.21 v1(176.36,135.76)
  IN2 w0.127: v1(220.71,66.57) 220.61,66.57 220.34,66.84 220.1,66.84 219.75,67.2 217.69,67.2 217.23,66.74 217.23,65.67 217.36,65.55 218.3,65.55 218.43,65.42 218.43,65.11 218.3,64.99 217.45,64.99 217.32,64.86 217.32,64.2 217.15,64.03 216.86,64.03 216.73,64.16 216.73,65.57 216.6,65.7 216.35,65.7 216.22,65.57 216.22,64.16 216.09,64.03 215.84,64.03 215.71,64.16 215.71,64.66 215.59,64.78 215.33,64.78 215.21,64.66 215.21,64.16 214.98,63.93 202.94,63.93 202.84,64.04 200.94,64.04 200.81,64.16 200.81,64.45 200.94,64.58 201.17,64.58 201.29,64.71 201.29,65.01 201.17,65.14 200.94,65.14 200.81,65.27 200.81,65.94 200.68,66.07 200.47,66.07 200.34,65.94 200.34,65.23 200.21,65.1 200,65.1 199.87,65.23 199.87,65.94 199.74,66.07 190.05,66.07 186.35,69.77 186.35,82.87 183.68,85.54 183.68,89.04 181.87,90.84 181.2,90.84 179.75,92.29 v1(179.45,92.29)
  BOTTOM w0.127: U46.A29 v1(230.62,74.45)
BC_INT#_EMC4002: length 35.1
  TOP w0.102: U18.12 144.07,154.25 R385.1 144.84,154.21 145.53,153.52 145.53,150.72 v2(149.64,146.61) v1(149.64,145.63) ; U54.A13 160.08,144.88 v1(159.94,144.74)
  IN3 w0.127: v1(149.64,145.63) 149.64,146.24 149.82,146.42 150.13,146.42 150.26,146.29 150.26,145.16 150.39,145.03 150.64,145.03 150.77,145.16 150.77,146.29 150.89,146.42 151.15,146.42 151.28,146.29 151.28,145.16 151.4,145.03 151.66,145.03 151.78,145.16 151.78,146.29 151.91,146.42 152.94,146.42 153.07,146.29 153.07,145.69 153.19,145.57 153.45,145.57 153.57,145.69 153.57,146.29 153.7,146.42 154.62,146.42 154.75,146.29 154.75,145.52 154.87,145.39 155.13,145.39 155.26,145.52 155.26,146.29 155.38,146.42 156.87,146.42 157,146.29 157,145.41 157.12,145.28 158.09,145.28 158.46,144.92 159.76,144.92 v1(159.94,144.74)
BCM5882_ALERT#: length 207.7
  TOP w0.102: v1(110.6,10.6) 110.59,10.61 110.59,10.73 109.9,11.42 109.9,16.66 109.62,16.94 109.62,17.32 110.37,18.07 110.37,22.27 112.22,24.12 112.22,31.09 114.84,33.72 116.8,33.72 116.88,33.8 JUSH1.7
  IN3 w0.127: v1(239.96,71.34) 239.49,71.34 239.15,71.68 237.45,71.68 236.5,70.73 235.52,70.73 235.28,70.49 235.28,68.2 235.01,67.93 234.44,67.93 233.6,67.09 229.91,67.09 228.24,65.42 206.02,65.42 203.11,62.51 202.58,62.51 199.34,59.27 193.9,59.27 192.83,58.2 186.14,58.2 184.08,56.15 184.08,55.26 183.67,54.85 175.65,54.85 162.72,41.93 162.72,20.62 158.14,16.03 158.14,13.23 157.23,12.32 127.94,12.32 126.71,13.55 125.88,13.55 124.48,12.15 123.02,12.15 122.81,12.37 122.81,13.64 122.44,14.01 119.15,14.01 117.41,15.75 114.32,15.75 110.87,12.29 110.87,10.82 110.65,10.61 110.6,10.61 v1(110.6,10.6)
  BOTTOM w0.102: v1(239.96,71.34) 240.37,70.93 240.9,70.93 241.17,71.2 U46.B62 ; v2(110.02,10) 110.6,10.58 v1(110.6,10.6)
BEEP: length 323.9
  TOP w0.102: U54.A16 160.99,143.38 160.79,143.18 160.79,140.31 159.74,139.26 159.74,136.98 160.63,136.08 160.63,132.27 v2(161.05,131.85) 161.36,131.53 161.36,111.96 160.24,110.84 160.24,103.53 159.54,102.82 159.54,91.36 162.45,88.44 169.9,88.44 176.92,81.42 178.88,81.42 184.91,75.39 184.91,67.91 180.47,63.46 180.47,52.41 179.7,51.65 179.7,49.75 v1(179.79,49.66) ; v1(29.6,32.35) JIO1.45
  IN4 w0.109: v1(29.6,32.35) 29.6,32.16 28.97,31.53 28.97,29.67 29.73,28.91 29.73,27.14 30.05,26.82 30.05,25.1 29.09,24.14 28.89,24.14 27.68,22.94 27.68,19.09 27.02,18.43 27.02,12.87 27.04,12.85 27.04,12.84 28.87,11.02 28.87,9.94 31.74,7.07 33.39,7.07 33.74,6.72 35.43,6.72 35.79,6.36 106.59,6.36 108.73,8.51 116.7,8.51 118.25,10.06 121.48,10.06 121.89,10.47 122.85,10.47 123.67,11.29 131.89,11.29 133,12.4 161.16,12.4 163.24,14.48 163.24,18.97 165.13,20.86 165.13,34.92 166.71,36.5 166.71,39.65 176.05,48.99 179.13,48.99 v1(179.79,49.66)
BIA_PWM_EC: length 118.2
  TOP w0.102: U54.B25 166.22,143.53 v1(166.71,144.02) ; v1(168.92,136.83) 168.98,136.77 168.98,135.84 168.45,135.31 168.45,127.18 168.11,126.84 v1(168.11,126.3) ; R431.2 82.15,132.19 81.72,132.61 v1(81.72,133.15)
  IN2 w0.127: v1(81.72,133.15) 82.09,133.15 82.48,132.75 83.91,132.75 84.63,132.03 103.4,132.03 104.3,131.13 106.81,131.13 107.04,130.9 114.63,130.9 116.18,129.35 124.04,129.35 124.42,129.73 129.66,129.73 130.81,130.89 152.41,130.89 156.63,126.67 164.77,126.67 165.05,126.95 167.61,126.95 168.11,126.45 v1(168.11,126.3)
  BOTTOM w0.102: D71.2 82.34,136.68 81.95,136.3 81.95,134.68 81.72,134.46 v1(81.72,133.15) ; v1(168.92,136.83) 169.03,136.94 v2(169.03,137.8) 169.03,141.19 168.74,141.48 167.68,141.48 167.19,141.96 167.19,143.54 v1(166.71,144.02)
BIA_PWM_LVDS: length 42.5
  TOP w0.102: v1(82,139.71) 82,139.28 81.47,138.75 R207.1 81.15,138.03 80.91,137.78 D66.1 80.91,135.55 81.44,135.01 v2(81.65,135.01) 81.65,133.86 82.37,133.14 R431.1 R1137.1 83.69,133.14 84.4,132.42 84.4,130.93 D68.1 ; R208.2 66.43,152.38 66.79,152.02 66.79,149.97 67.91,148.86 67.91,147.46 66.17,145.72 v1(66.17,145.05)
  IN4 w0.109: v1(82,139.71) 81.72,139.99 80.07,139.99 77.77,142.29 74.09,142.29 73.23,143.15 68.78,143.15 67.8,144.13 67.08,144.13 v1(66.17,145.05)
  BOTTOM w0.102: v1(82,139.71) 82.71,139.71 83.16,139.27 D71.1
BIA_PWM_PCH: length 101.6
  TOP w0.102: D66.2 78.81,135.68 v1(78.89,135.6) ; v1(23.73,125.63) 23.9,125.63 UH4.P45 ; v1(80.73,113.42) 80.12,114.03 80.12,117.51 82.43,119.83 82.43,121.03 81.25,122.21 81.25,123.56 81.43,123.74 81.43,126.43 81.35,126.51 v2(81.35,126.5) 81.28,126.57 81.28,128.21 v1(81.74,128.66)
  IN1 w0.109: v1(81.74,128.66) 81.21,128.66 80.36,129.52 80.36,133 78.89,134.47 v1(78.89,135.6)
  IN2 w0.102: v1(23.73,125.63) 23.73,127.23 24.37,127.86 25.61,127.86 26.52,128.77 26.52,129.15 26.72,129.35 ; 36.78,129.35 35.37,127.94 33.7,127.94 33.32,128.32 31.71,128.32 31.49,128.54 31.49,129.35
  IN2 w0.127: 26.72,129.35 26.96,129.59 29.58,129.59 30.54,130.56 31.11,130.56 31.49,130.18 31.49,129.35 ; 36.78,129.35 36.98,129.55 44.28,129.55 45.03,128.8 46.63,128.8 47.94,127.5 47.94,125.88 48.54,125.29 48.54,120.01 52.66,115.89 60.86,115.89 61.77,116.8 70.25,116.8 72.33,114.72 73.4,114.72 74.05,114.07 80.08,114.07 v1(80.73,113.42)
BLK_MOSFET_GC: length 92.2
  TOP w0.254: PU1001.30 v1(172.85,73.18)
  TOP w0.381: v1(161.5,14.88) 161.5,15.15 161.87,15.52 163.85,15.52 164.36,15.01 166.52,15.01 167.91,16.4 167.91,18.64 171.36,22.09 177.84,22.09 178.12,22.37 v2(178.17,22.37) 180.2,22.37 PR1006.2
  IN1 w0.381: v1(161.5,14.88) 161.5,15.08 161.85,15.42 161.85,22.88 160.93,23.8 160.93,26.43 161.97,27.47 161.97,41.09 165.39,44.51 165.39,46.08 168.08,48.77 169.73,48.77 173.02,52.06 173.02,62.61 173,62.64 173,62.67 171.92,63.75 171.92,71.98 172.85,72.91 v1(172.85,73.18)
BLKNG_MOSFET_GC: length 109.5
  TOP w0.254: PU1001.20 v1(178.37,76.18)
  IN1 w0.381: v1(165.39,15.74) 164.93,16.19 164.93,24.38 164.41,24.91 164.41,39.67 175.53,50.79 175.53,61.79 176.46,62.73 176.46,65.08 180.3,68.91 180.3,69.53 179.68,70.16 179.68,74.87 v1(178.37,76.18)
  IN3 w0.381: v1(195.65,18.13) 191.13,18.13 187.3,14.3 187.3,11.62 186.41,10.73 180.86,10.73 179.68,11.91 179.68,13.53 178.99,14.21 166.36,14.21 165.39,15.18 v1(165.39,15.74)
  BOTTOM w0.102: PR1009.2 v2(196.89,18.96)
  BOTTOM w0.508: v1(195.65,18.13) 195.9,18.39 PR1009.2
BLUE_CRT: length 7.5
  BOTTOM w0.102: L3.1 55.13,159.53 55.22,159.43 C22.1 R55.1 56.23,159.03 56.73,158.53 v2(57.54,158.53) 58.65,158.53 59.41,157.77 59.41,157.39 59.77,157.03 U19.31
BLUE_CRT_L: length 18.5
  TOP w0.102: JCRT1.3 61.08,172.57 60.65,172.15 58.7,172.15 56.07,169.52 55.12,169.52 54.91,169.31 D10.2 54.91,167.07 55.69,166.29 C13.1 v2(55.69,162.26) 55.69,161.76 v1(56.07,161.38)
  BOTTOM w0.102: v1(56.07,161.38) 56.33,161.12 L3.2
BLUE_DOCK: length 59
  IN3 w0.127: v3(57.92,149.94) 57.92,148.31 59.96,146.28 59.96,145.62 62.41,143.16 69.04,143.16 69.67,142.53 70.6,142.53 72.6,140.53 73.67,140.53 74.19,140.01 75,140.01 77.09,137.92 77.09,134.79 79.9,131.98 84.1,131.98 86.36,129.72 86.8,129.72 91.39,125.13 v1(91.39,124.59)
  BOTTOM w0.102: v1(91.39,124.59) 91.26,124.46 91.26,122.44 93.01,120.69 93.01,119.75 92.74,119.48 JDOCK1.45 ; v3(57.92,149.94) 57.92,150.42 57.02,151.32 57.02,152.09 57.51,152.59 U19.22
BOARD_ID: length 9
  TOP w0.102: v1(163.46,147.1) 163.46,146.99 163.1,146.63 U54.B10
  BOTTOM w0.102: R875.2 C744.1 158.81,144.34 159.66,145.19 160.87,145.19 v2(161.29,145.61) 162.32,146.63 163.12,146.63 163.46,146.98 v1(163.46,147.1)
BOOT:
  vias: v2(177.53,36.22)
BOOT1:
  vias: v2(31.04,75.38)
BOOT1G:
  vias: v2(30.29,83.19)
BOOT2:
  vias: v2(30.67,81.95)
BOOT2G: length 1.5
  TOP w0.102: v2(25.88,89.5) 26.55,88.82 PR764.2
BOOT3: length 1.3
  BOTTOM w0.102: PR711.2 49.57,44.69 v2(49.66,44.78)
BOOT_1.5V:
  vias: v2(228.66,45.56)
BOOT_D: length 6
  TOP w0.102: v2(181.13,40.67) PC910.1
  TOP w0.508: PC910.1 179.09,39.31 PR917.2 178.66,40.4 PD903.1
BREATH_LED#: length 225.1
  TOP w0.102: v1(115.42,128.82) v2(115.42,129.39)
  IN2 w0.127: v1(115.42,128.82) 115.47,128.82 115.53,128.88 124.22,128.88 124.61,129.27 130.43,129.27 131.5,130.34 152.27,130.34 157.38,125.22 166.58,125.22 174.32,117.48 174.99,117.48 181.85,110.61 181.85,107.62 186.89,102.58 186.89,100.5 189.75,97.64 189.75,96.5 190.49,95.77 190.49,95.75 193.89,92.34 193.89,91.11 195.2,89.8 195.2,88.11 197.82,85.49 199.46,85.49 200.41,84.54 208.71,84.54 210.13,83.12 214.53,83.12 216.49,81.17 221.96,81.17 224.62,78.5 224.62,76.91 225.39,76.15 230.01,76.15 230.48,75.68 231.14,75.68 232.17,74.65 233.41,74.65 233.44,74.68 234.19,74.68 234.64,75.13 v1(234.76,75.13)
  IN3 w0.127: v1(276.73,89.73) 276.56,89.56 276.56,89.34 274.67,87.45 274.67,85.51 271.65,82.49 265.23,82.49 259.1,76.37 v1(258.76,76.37)
  IN4 w0.109: v1(234.76,75.13) 234.8,75.1 234.8,74.93 235.3,74.42 237.15,74.42 239.19,72.38 239.19,70.46 239.55,70.1 240,70.1 240.18,70.28 240.18,70.36 240.55,70.73 242.15,70.73 243.01,71.59 243.2,71.59 245.34,73.72 246.4,73.72 246.86,74.19 249.43,74.19 251.49,76.24 258.64,76.24 v1(258.76,76.37)
  BOTTOM w0.102: v1(115.42,128.82) 114.29,129.95 108.46,129.95 107.74,129.23 JDOCK1.98 ; U46.B39 234.83,76.5 235.01,76.31 235.01,75.98 234.99,75.96 234.99,75.37 v1(234.76,75.13) ; v1(276.73,89.73) 276.73,91.5 277.14,91.91 278.78,91.91 279.15,91.53 R955.1 279.15,89.69 279.5,89.35 280.05,89.35 Q84.1
BREATH_LED#_Q: length 330.4
  TOP w0.102: v1(37.49,16.83) 37.44,16.83 37.36,16.75 JIO1.98 ; v1(281.79,88.14) 281.79,87.6 282.14,87.25 282.14,85.32 281.68,84.86 280.21,84.86 278.05,82.7 278.05,81.33 276.92,80.2 276.92,70.8 274.52,68.4 v1(274.52,67.67)
  IN1 w0.109: v1(168.9,15.16) 167.32,13.59 159.51,13.59 156.31,16.79 152.18,16.79 149.88,14.49 128.46,14.49 127.96,14.99 119.97,14.99 117.93,17.02 113.78,17.02 111.11,14.35 109.78,14.35 108.93,13.5 108.33,13.5 107.76,12.93 104.94,12.93 102.21,10.2 37.95,10.2 33.53,14.62 33.53,16.2 33.79,16.46 34.66,16.46 35.03,16.83 v1(37.49,16.83)
  IN3 w0.127: v1(168.9,15.16) 168.9,21.19 165.66,24.43 165.66,34.99 166.29,35.61 166.29,40.94 174.27,48.92 180.03,48.92 181.94,50.83 187.2,50.83 187.79,51.42 190.56,51.42 193.32,54.18 193.32,54.19 193.7,54.57 200.95,54.57 208.82,62.45 221.17,62.45 222.85,60.77 224.1,60.77 224.12,60.78 230.99,60.78 232.16,59.62 233.74,59.62 234.67,58.69 242.17,58.69 244.03,60.54 244.03,63.11 244.03,63.3 248.46,67.73 274.46,67.73 v1(274.52,67.67)
  BOTTOM w0.102: v1(281.79,88.14) 280.99,88.95 v2(280.99,89.83) 280.99,89.84 280.34,90.49 R955.2
BREATH_WHITE_LED: length 11.3
  TOP w0.102: v3(281.2,87.05) 279.49,88.76 JPB1.4
  BOTTOM w0.102: v3(281.2,87.05) 280.66,87.59 277.95,87.59 277.25,88.3 R956.2
BST1_3V: length 1.1
  BOTTOM w0.102: PC100.2 v2(284.15,58.23)
BST1_5V: length 1.3
  BOTTOM w0.102: PR109.2 269.05,60.77 v2(268.74,60.47)
BST_3V:
  vias: v2(280.36,60.24)
BST_5V:
  vias: v2(272.57,60.94)
BST_+V1.05S_VCCPP:
  vias: v2(61.71,22.17)
BST_+V1.05SP: length 1.2
  TOP w0.102: v2(7,151.49) 6.7,151.19 PR402.1
BT_ACTIVE: length 6.9
  TOP w0.102: JBT1.6 v1(297.56,104.83)
  BOTTOM w0.102: Q318.5 293.44,106.24 294.61,105.07 v2(295.73,105.07) 297.36,105.07 297.56,104.86 v1(297.56,104.83)
BT_COEX_STATUS2: length 284.1
  TOP w0.102: JBT1.4 299.56,108.14 v1(299.57,108.14) ; v1(121.17,12.6) 121.17,12.69 121.03,12.83 121.03,15.53 122.3,16.8 122.3,18.05 121.97,18.38 121.42,18.38 121,18.8 121,22.14 118.93,24.21 118.93,31.6 118.73,31.8 JUSH1.11
  IN3 w0.127: v1(224.65,57.91) 225.22,57.34 231.53,57.34 232.9,55.97 235.79,55.97 236.55,56.73 242.93,56.73 246.04,59.84 246.04,60.85 252.02,66.83 273.73,66.83 274.65,65.91 276.74,65.91 279.01,68.19 292.76,68.19 293.3,68.73 293.3,79.84 289.16,83.98 289.16,92.1 290.71,93.65 292.3,93.65 293.25,94.6 297.25,94.6 298.3,95.64 298.3,106.42 298.78,106.9 298.78,107.35 v1(299.57,108.14)
  IN4 w0.109: v1(224.65,57.91) 223.91,58.66 195.6,58.66 192.87,55.93 192.87,54.95 191.9,53.98 186.06,53.98 185.29,53.2 180.78,53.2 177.94,50.36 175.48,50.36 163.68,38.56 163.68,23.22 156.97,16.51 155,16.51 154.71,16.22 152.73,16.22 150.95,14.44 123.73,14.44 122.58,13.28 122.58,12.7 122.29,12.41 121.36,12.41 v1(121.17,12.6)
  BOTTOM w0.102: R1133.2 300.87,108.61 v2(300.28,108.01) 299.69,108.01 v1(299.57,108.14)
BT_LED: length 355
  TOP w0.102: v1(275.3,67.69) 275.3,68.81 277.28,70.79 v2(277.28,72.01) 277.14,72.15 277.14,80.05 278.26,81.17 278.26,82.59 280.25,84.58 284.59,84.58 v1(285.08,85.07) ; JIO1.92 v1(34.83,18.55)
  IN1 w0.109: v1(171,15.15) 168.76,12.9 159.23,12.9 156.03,16.1 152.5,16.1 150.2,13.81 128.17,13.81 127.68,14.3 119.61,14.3 117.57,16.34 114.06,16.34 111.39,13.67 110.11,13.67 109.12,12.68 108.54,12.68 107.42,11.56 106.3,11.56 104.25,9.51 37.67,9.51 32.84,14.34 32.84,18.71 33.21,19.08 34.33,19.08 34.61,18.8 34.61,18.8 34.83,18.57 v1(34.83,18.55)
  IN3 w0.127: v1(285.08,85.07) 285.35,85.34 285.35,93.37 288.16,96.18 288.16,101.02 288.75,101.6 v1(288.85,101.6) ; v1(171,15.15) 171,20.06 166.34,24.72 166.34,34.7 166.97,35.33 166.97,40.65 174.54,48.22 180.3,48.22 182.22,50.14 187.48,50.14 188.07,50.73 190.86,50.73 194.01,53.89 201.27,53.89 208.97,61.59 219.47,61.59 221.54,59.53 223.78,59.53 223.92,59.67 226.08,59.67 226.31,59.44 231,59.44 232.73,57.71 240.36,57.71 240.91,58.26 243.1,58.26 244.26,59.42 244.26,63.21 248.55,67.5 274.03,67.5 274.32,67.21 274.88,67.21 275.3,67.63 v1(275.3,67.69)
  BOTTOM w0.102: R941.2 292.2,103.06 290.74,101.6 v1(288.85,101.6)
BT_LED#: length 4.5
  BOTTOM w0.102: v2(182.35,101.92) 182.12,101.7 R708.1 180.95,101.44 180.95,99.89 181.09,99.74 JMINI2.46
BT_LED#_R: length 177.9
  TOP w0.102: v1(279.25,95.31) 277.98,95.31 274.29,91.63 274.29,81.22 274.04,80.96 263.06,80.96 261.16,82.87 241.74,82.87 241.24,83.36 236.51,83.36 233.06,86.82 231.67,86.82 227.02,91.47 219.08,91.47 v1(219.05,91.5)
  IN3 w0.127: v1(219.05,91.5) 219.05,91.63 218.41,92.27 209.65,92.27 207.87,90.49 206.09,90.49 205.71,90.87 205.71,91.68 207.75,93.71 207.75,100.19 209.65,102.09 209.65,104.97 209.9,105.22 210.79,105.22 211.3,104.71 212.83,104.71 213.46,105.35 213.46,107 212.44,108.01 208.89,108.01 208.63,107.76 208.63,106.36 207.75,105.47 206.86,105.47 205.08,107.25 203.97,107.25 203.34,106.62 203.34,105.48 202.66,104.8 201.43,104.8 v1(200.89,104.25)
  BOTTOM w0.102: v2(291.46,108.04) 291,107.57 Q318.3 290.7,106.89 290.5,106.68 290.5,105.79 290.7,105.59 Q318.1 291,105 291.18,104.82 R938.2 291.18,104.33 290.17,103.32 286.49,103.32 286.23,103.06 286.23,101.66 284.58,100.01 284.58,96.71 283.18,95.31 v1(279.25,95.31) ; R708.2 184.03,105.47 193.14,105.47 194.41,106.74 200.76,106.74 201.4,106.11 201.4,104.76 v1(200.89,104.25)
BT_PRI_STATUS: length 287.4
  TOP w0.102: v1(298.55,108.14) 298.55,106.42 JBT1.5 ; JUSH1.12 121.68,31.3 122.03,30.95 122.03,30.35 122.59,29.79 122.96,29.79 123.39,29.36 123.39,26.63 123.06,26.3 123.06,23.57 124.99,21.64 124.99,20.08 125.86,19.21 125.86,16.91 125.66,16.71 124.93,16.71 124.74,16.9 124.74,17.29 124.36,17.67 123.05,17.67 122.76,17.37 122.76,16.61 121.6,15.46 121.6,13.42 122.11,12.92 v1(122.11,12.88)
  IN3 w0.127: v1(298.55,108.14) 298.55,107 298.04,106.49 298.04,95.81 297.06,94.83 293.08,94.83 292.14,93.89 290.6,93.89 288.94,92.23 288.94,83.89 293.08,79.74 293.08,69.01 292.48,68.42 278.92,68.42 276.64,66.14 274.74,66.14 273.83,67.06 251.9,67.06 245.8,60.95 245.8,59.93 242.9,57.02 232.17,57.02 231.63,57.57 225.88,57.57 v1(225.03,58.42)
  IN4 w0.109: v1(122.11,12.88) 122.15,12.92 122.15,13.25 123.57,14.67 150.8,14.67 152.58,16.45 154.61,16.45 154.92,16.75 156.87,16.75 163.38,23.27 163.38,38.59 175.39,50.59 177.85,50.59 180.68,53.43 185.19,53.43 185.97,54.2 191.81,54.2 192.64,55.04 192.64,56 195.53,58.88 224.57,58.88 v1(225.03,58.42)
  BOTTOM w0.102: v2(298.55,107.57) v1(298.55,108.14) 298.98,108.57 299.99,108.57 300.37,108.95 300.37,109.71 R1134.2
BT_RADIO_DIS#: length 195.2
  TOP w0.102: v1(176.59,87.17) 176.59,86.1 177.81,84.87 179.34,84.87 181.92,82.3 184.95,82.3 185.37,82.72 191.39,82.72 192.16,81.94 195.36,81.94 198.61,78.69 201.03,78.69 201.8,77.92 210.08,77.92 210.4,78.23 210.4,78.68 210.67,78.94 213.29,78.94 213.5,78.74 213.5,78.25 214.64,77.1 214.64,74.52 217.75,71.41 217.75,66.01 218.23,65.53 227.56,65.53 227.84,65.82 230.26,65.82 232.05,64.02 234.59,64.02 235.05,64.48 v1(235.05,65.32)
  IN3 w0.127: v1(298.68,109.72) 297.88,109.72 296.56,108.4 296.56,107.25 290.92,101.61 290.92,95.72 288.71,93.51 288.71,83.79 292.85,79.65 292.85,69.16 292.33,68.64 278.82,68.64 278.42,68.24 274.46,68.24 274.18,67.96 246.06,67.96 244.23,66.13 242.52,66.13 240.17,63.78 236.07,63.78 235.93,63.92 235.93,64.94 236.48,65.49 236.76,65.49 237.02,65.75 237.02,66.12 236.76,66.38 236.28,66.38 235.22,65.32 v1(235.05,65.32)
  BOTTOM w0.102: R694.1 299.73,110.35 D28.1 v1(298.68,109.72) ; R693.2 175.87,85.93 R691.1 176.38,86.68 176.63,86.42 D30.1 177.01,86.75 v1(176.59,87.17) ; v1(235.05,65.32) 234.97,65.32 v2(234.62,65.67) 234.57,65.73 234.57,66.74 U46.A13
BT_RADIO_DIS#_CON: length 6.7
  TOP w0.102: v1(297.53,108.14) 296.56,107.17 JBT1.7
  BOTTOM w0.102: R694.2 298.98,109.25 D28.2 298.16,108.95 298.05,109.06 C754.1 v1(297.53,108.14) 297.53,107.79 v2(296.95,107.2)
BT_RADIO_DIS#_R: length 5.1
  BOTTOM w0.102: R691.2 176.06,87.82 D30.2 177.01,88.2 177.9,89.09 178.79,89.09 179.09,89.39 JMINI2.51
CAM_MIC_CBL_DET#: length 30.1
  TOP w0.102: v3(2.87,132.79) 2.87,132.72 2.35,132.2 JCAM1.16 ; v1(19,125.25) 18.98,125.25 18.75,125.01 UH4.C42 ; RH331.2 14.92,126.56 v1(15.04,126.44)
  IN1 w0.109: v1(12.08,135.33) 12.08,134.4 12.97,133.52 12.97,131.64 11.97,130.65 11.97,129.65 12.48,129.15 12.98,129.15 14.27,127.85 14.27,127.2 v1(15.04,126.44) 15.45,126.86 16.52,126.86 18.13,125.25 v1(19,125.25)
  BOTTOM w0.102: v1(12.08,135.33) 11.17,136.23 8.77,136.23 8.27,135.73 6.87,135.73 3.94,132.79 v3(2.87,132.79)
CARD_SMBCLK: length 357.1
  TOP w0.102: v1(180.78,16.05) 180.03,15.3 180.03,12.46 v1(180.78,11.71) ; v1(182.83,102.21) 183.02,102.4 183.02,102.73 183.28,103 184.21,103 185.55,104.33 185.55,109.25 184.38,110.42 184.38,115.65 v2(180.47,119.55) 179.82,120.21 179.82,128.66 180.19,129.03 180.19,136.32 179.86,136.65 v1(179.86,136.67) ; U54.A49 170.47,153.01 170.93,153.47 171.33,153.47 v1(171.55,153.68) ; JIO1.48 37.16,31.75 37.34,31.56 37.58,31.56 v1(37.78,31.77)
  IN1 w0.109: v1(179.86,136.67) 180,136.8 180,141.86 179.39,142.47 179.39,145.19 177.82,146.75 177.82,148.04 177.47,148.39 177.02,148.39 176.26,149.15 176.26,151.47 175.03,152.71 172.46,152.71 172.08,153.09 172.08,153.15 v1(171.55,153.68) ; v1(180.78,11.71) 180.58,11.51 158.57,11.51 156.56,13.51 155.31,13.51 153.6,11.8 132.47,11.8 131.87,11.19 122.4,11.19 119.85,8.64 108.85,8.64 107.76,7.54 35.51,7.54 32.95,10.1 31.96,10.1 29.75,12.3 29.75,18.25 28.87,19.14 28.87,22.17 30.95,24.25 30.95,29 32.23,30.29 32.76,30.29 33.99,31.52 37.53,31.52 v1(37.78,31.77) ; v1(182.83,102.21) 182.62,102.41 182.38,102.41 180.26,100.29 180.26,97.4 180.92,96.74 180.92,95.79 180.39,95.25 180.39,90.84 178.85,89.31 178.85,83.24 180.6,81.49 180.6,75.57 181.93,74.24 181.93,68.98 180.22,67.27 180.22,63.78 177.82,61.38 177.82,54.41 178.62,53.61 178.62,51.18 166.79,39.35 166.79,26.24 176.97,16.05 v1(180.78,16.05)
CARD_SMBDAT: length 357.4
  TOP w0.102: v1(180.78,12.52) 180.61,12.7 180.61,15.16 v1(180.85,15.41) ; v1(183.5,102.22) 183.27,102.45 183.27,102.63 183.39,102.74 184.32,102.74 185.8,104.22 185.8,109.36 184.63,110.53 184.63,116.14 v2(183.37,117.4) 180.07,120.7 180.07,128.55 180.45,128.92 180.45,136.62 v1(180.49,136.67) ; v1(172.65,153.65) 172.19,153.18 171.77,153.18 170.72,152.13 U54.B52 ; v1(37.78,31.13) 37.58,31.34 37.32,31.34 37.13,31.15 JIO1.50
  IN1 w0.109: v1(180.78,12.52) 180.68,12.52 179.92,11.76 158.67,11.76 156.67,13.77 155.21,13.77 153.49,12.05 132.37,12.05 131.76,11.45 122.3,11.45 119.74,8.89 108.75,8.89 107.65,7.79 35.68,7.79 33.08,10.39 32.03,10.39 30.01,12.41 30.01,18.36 29.12,19.24 29.12,22.06 31.2,24.14 31.2,28.92 32.33,30.05 32.86,30.05 34.09,31.29 37.63,31.29 v1(37.78,31.13) ; v1(180.49,136.67) 180.25,136.91 180.25,141.94 179.62,142.57 179.62,145.33 178.12,146.83 178.12,148.07 177.54,148.65 177.1,148.65 176.52,149.23 176.52,151.57 175.16,152.93 172.57,152.93 172.32,153.18 172.32,153.31 v1(172.65,153.65) ; v1(183.5,102.22) 183.48,102.22 183.03,102.67 182.28,102.67 180.01,100.4 180.01,97.3 180.67,96.63 180.67,95.89 180.13,95.36 180.13,90.95 178.6,89.41 178.6,83.13 180.35,81.38 180.35,75.46 181.68,74.13 181.68,69.09 179.97,67.38 179.97,63.89 177.61,61.52 177.61,61.5 177.59,61.48 177.59,54.31 177.61,54.29 177.61,54.27 178.37,53.51 178.37,51.29 166.53,39.45 166.53,26.12 177.04,15.62 180.63,15.62 v1(180.85,15.41)
CARDCLK_REQ#: length 105.2
  TOP w0.102: JIO1.32 37.32,36.55 37.76,36.98 v1(37.76,37.44) ; v1(26.7,109.06) 26.58,109.06 26.2,108.68 UH4.V10
  IN3 w0.102: 26.25,103.19 26.24,103.2 26.24,108.62 26.68,109.06 v1(26.7,109.06)
  IN3 w0.127: v1(37.76,37.44) 37.15,37.44 36.42,38.16 36.42,42.28 36.74,42.6 36.74,46.96 33.14,50.56 33.14,59.6 25.11,67.63 18.39,67.63 15.72,70.3 15.72,72.84 15.47,73.09 15.47,84.4 14.57,85.31 14.57,92.47 16.57,94.48 16.57,94.91 17.59,95.92 19.29,95.92 20.89,97.52 20.89,97.96 20.88,97.97 20.88,98.41 21.78,99.31 21.78,99.72 22.27,100.21 25.17,100.21 26.57,101.61 26.57,102.66 26.25,102.98 26.25,103.19
  BOTTOM w0.102: RH87.2 27.28,101.63 27.05,101.86 v2(27.05,102.38) 27.05,102.68 26.74,102.98 26.74,104.84 27.13,105.22 27.13,108.63 v1(26.7,109.06)
CCD_OFF: length 294.7
  TOP w0.102: v1(152.69,98.15) 152.69,103.65 v1(153.22,104.18) ; v1(236.36,75.43) 235.88,75.91 235.88,76.24 235.19,76.92 232.99,76.92 231.55,75.49 228.13,75.49 227.5,74.87 224.99,74.87 222.42,72.3 222.09,72.3 221.62,71.83 218.73,71.83 215.4,75.16 215.4,79.19 213.41,81.18 v1(213.41,81.36)
  IN2 w0.127: v1(80.05,113.41) 80.48,112.98 80.92,112.98 81.19,113.25 81.19,113.77 81.75,114.33 83.75,114.33 84.15,113.93 92.62,113.93 94.16,112.4 99.61,112.4 101.07,110.94 101.07,109.39 102.44,108.01 122.02,108.01 123.19,106.85 129.02,106.85 130.72,105.14 144.13,105.14 144.36,105.37 149.97,105.37 151.83,103.51 152.63,103.51 153.19,104.06 153.19,104.14 v1(153.22,104.18)
  IN4 w0.109: v1(213.41,81.36) 213.41,81.37 212.39,82.39 206.72,82.39 206.62,82.48 204.58,82.48 204.05,83.01 198.45,83.01 194.43,87.03 194.43,87.55 192.63,89.35 183.37,89.35 182.61,90.11 175.98,90.11 174.62,91.47 171.83,91.47 171.36,91.93 164.12,91.93 159.53,96.52 159.12,96.52 159.12,96.52 157.49,96.52 155.86,98.15 v1(152.69,98.15)
  BOTTOM w0.102: v1(80.05,113.41) 80.05,113.59 79.77,113.87 79.67,113.87 72.15,121.39 72.15,123.9 71.26,124.79 71.26,129.59 73.04,131.37 73.04,135.47 71.96,136.54 70.95,136.54 67.91,139.59 65.11,139.59 64.57,140.13 54.53,140.13 54.27,139.87 53.41,139.87 53.1,140.17 53.1,140.5 52.88,140.72 51.33,140.72 50.92,140.31 48.82,140.31 45.52,137.01 45.52,136.54 44.51,135.53 41.7,135.53 37.38,139.85 35.08,139.85 34.45,140.48 34.45,142.22 34.01,142.66 19.72,142.66 v2(19.31,142.25) 16.41,139.34 14.18,139.34 12.24,137.4 5.74,137.4 5.38,137.05 Q24.2 ; U46.B43 236.83,76.45 236.78,76.4 236.78,75.84 v1(236.36,75.43)
CD3301_DCIN:
  vias: v2(174.29,67.95)
CD3301_SDC_IN: length 2.7
  TOP w0.254: PU1001.6 177.37,68.32 177.36,68.31 177.36,67.89 v2(177.37,67.88) 177.37,67.37 PR1015.2
CD_PBATT_OFF: length 2.7
  TOP w0.254: PR1016.1 175.37,76.29 PU1001.26
CEXT: length 2.8
  TOP w0.102: U9.1 46.77,143.51 46.9,143.38 46.9,143.15 v1(46.7,142.95)
  BOTTOM w0.102: C86.1 v1(46.7,142.95) 46.7,142.61 v2(46.9,142.41)
CFD_PWRBTN#_XDP: length 3.5
  BOTTOM w0.102: v2(71.52,88.84) 71.99,89.31 71.99,89.46 72.48,89.95 RC9.2 72.61,89.95 73.65,90.99 JXDP1.11
CFG0: length 21.1
  TOP w0.089: JCPU1.AK28 72.9,70.45 v5(72.39,70.96)
  BOTTOM w0.102: v5(72.39,70.96) 72.27,70.96 71.79,71.44 71.79,76.49 71.73,76.56 v2(71.73,76.76) 71.73,78.25 73.28,79.79 73.28,81.33 73.11,81.5 73.11,83.74 73.43,84.06 73.43,86.77 73.2,87 72.78,87 72.4,87.38 72.4,87.86 73.51,88.96 RC10.1
CFG1: length 1.5
  TOP w0.089: v5(71.38,70.96) 71.89,70.45 JCPU1.AK29
  BOTTOM w0.102: T60.1 71.45,70.96 v5(71.38,70.96)
CFG2: length 12.1
  TOP w0.089: v5(74.4,71.94) 74.89,71.45 JCPU1.AL26
  BOTTOM w0.102: RC52.1 73.93,81.29 v2(73.93,80.34) 73.93,79.63 73.16,78.87 73.16,78.23 73,78.07 73,77.51 73,77.51 73,77.18 73,77.17 73,76.14 72.76,75.9 72.76,75.5 73.82,74.44 73.82,72.96 74.4,72.39 v5(74.4,71.94)
CFG3: length 1.7
  TOP w0.089: JCPU1.AL27 73.9,71.45 v5(73.4,71.95)
  BOTTOM w0.089: T55.1 73.4,71.67 v5(73.4,71.95)
CFG4: length 15
  TOP w0.089: v5(74.4,70.93) 74.88,70.45 JCPU1.AK26
  BOTTOM w0.089: 72.49,71.45 72.87,71.07 72.87,70.68 73.13,70.42 73.89,70.42 74.4,70.93 v5(74.4,70.93)
  BOTTOM w0.102: 72.49,71.45 72.1,71.45 71.98,71.57 71.98,75.77 72.74,76.54 v2(72.74,78.44) 72.74,78.85 73.56,79.67 RC53.1
CFG5: length 12.3
  TOP w0.089: JCPU1.AL29 71.87,71.45 v5(71.38,71.94)
  BOTTOM w0.102: RC57.1 71.47,79.32 v2(71.2,79.05) 70.46,78.31 70.46,76.52 70.08,76.14 70.08,74.18 70,74.1 70,74.09 69.95,74.05 69.95,72.64 70.2,72.39 70.93,72.39 v5(71.38,71.94)
CFG6: length 13.7
  TOP w0.089: JCPU1.AL30 70.88,71.45 v5(70.38,71.95)
  BOTTOM w0.102: v5(70.38,71.95) 69.95,71.95 69.55,72.35 68.29,72.35 67.88,72.76 67.88,73.93 67.53,74.28 67.08,74.28 66.76,74.6 66.76,77.52 67.49,78.25 v2(67.49,79.77) 67.49,81.81 RC58.1
CFG7: length 10.5
  TOP w0.089: JCPU1.AM31 69.85,72.45 69.4,72.89 69.4,72.9 v1(69.38,72.93)
  BOTTOM w0.102: v1(69.38,72.93) 69.38,73.28 68.93,73.72 68.93,77.28 69.95,78.3 v2(69.95,80.59) 70.46,81.1 RC62.1
CFG8: length 1.4
  TOP w0.089: v1(68.34,72.94) 68.34,72.93 68.82,72.45 JCPU1.AM32
  BOTTOM w0.089: v1(68.34,72.94) 68.68,73.28 T64.1
CFG9: length 1.5
  TOP w0.089: JCPU1.AM30 70.89,72.45 v5(70.38,72.96)
  BOTTOM w0.102: T68.1 70.89,73.47 v5(70.38,72.96)
CFG10: length 1.4
  TOP w0.089: JCPU1.AM28 72.89,72.45 v5(72.39,72.95)
  BOTTOM w0.102: T69.1 72.74,73.3 v5(72.39,72.95)
CFG11: length 1.4
  TOP w0.089: JCPU1.AM26 74.9,72.45 v5(74.4,72.95)
  BOTTOM w0.102: T70.1 74.78,73.32 v5(74.4,72.95)
CFG12: length 1.7
  TOP w0.089: v1(72.39,73.94) 72.88,73.45 JCPU1.AN28
  BOTTOM w0.089: T7.1 72.39,74.64 v1(72.39,73.94)
CFG13: length 1.4
  TOP w0.089: JCPU1.AN31 69.85,73.45 69.38,73.92 v1(69.38,73.92)
  BOTTOM w0.102: T9.1 69.71,74.25 v1(69.38,73.92)
