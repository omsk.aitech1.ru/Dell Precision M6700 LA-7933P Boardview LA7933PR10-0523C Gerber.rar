# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CRT_11: length 3.2
  BOTTOM w0.102: T61.1 55.74,171.19 JCRT1.11
CRT_EN: length 3.3
  BOTTOM w0.102: v2(65.57,157.15) 65.57,157.04 65.92,156.69 R421.2 65.52,156.27 64.63,155.39 U19.2
CRT_IREF: length 7.6
  TOP w0.102: v1(24.75,125.68) 24.76,125.68 25.13,125.32 UH4.T43
  BOTTOM w0.102: RH126.1 23.72,130.25 23.18,129.71 23.18,127.99 23.98,127.19 v2(23.98,126.57) 23.98,126.29 24.59,125.68 v1(24.75,125.68)
CRT_SWITCH: length 249.6
  TOP w0.102: v1(242.04,76.48) 242.04,76.51 240.6,77.94 233.15,77.94 233.04,78.05 231.71,78.05 230.92,77.27 229.98,77.27 229.63,77.61 229.63,78.03 229.16,78.5 228.61,78.5 227.45,79.66 226.4,79.66 221.91,84.15 221,84.15 220.58,84.57 220.58,85.46 v2(221.38,86.26) v1(222.11,86.98)
  IN2 w0.127: v1(183.84,140.83) 183.84,140.84 184.57,141.57 185.04,141.57 185.5,142.02 187.1,142.02 191.57,137.56 191.57,113.27 194.25,110.58 194.25,108.23 195.95,106.53 195.95,105.65 195.63,105.33 195.63,103.56 197.46,101.73 197.46,98.73 200.32,95.87 204.81,95.87 206.03,94.65 206.03,93.78 209.8,90.02 213.05,90.02 213.56,89.51 217.07,89.51 219.26,87.31 221.78,87.31 v1(222.11,86.98)
  IN4 w0.109: v1(183.84,140.83) 183.74,140.83 181.58,138.67 177.72,138.67 177.48,138.43 165.07,138.43 163.82,139.68 163.82,140.4 162.62,141.59 161.76,141.59 160.52,142.84 159.81,142.84 157.6,145.05 156.04,145.05 153.61,147.48 153.61,149.03 149.55,153.1 147.06,153.1 146.29,153.87 143.19,153.87 142.52,153.2 128.6,153.2 128.58,153.22 116.85,153.22 116.31,152.68 105.33,152.68 104.73,152.08 97.79,152.08 95.85,150.14 86.27,150.14 85.71,149.58 82.11,149.58 80.85,150.84 77.77,150.84 73.62,154.99 72.14,154.99 69.52,157.6 67.28,157.6 66.95,157.93 66.06,157.93 65.95,158.04 65.01,158.04 64.5,157.53 v1(63.41,157.53) 62.84,158.1 v1(62.84,158.2)
  BOTTOM w0.102: v1(62.84,158.2) 62.57,157.93 U19.38 ; U19.40 63.37,157.49 v1(63.41,157.53) ; v1(242.04,76.48) 241.76,76.2 U46.B52
CS_1.5V: length 2.2
  BOTTOM w0.203: PR202.2 231.33,42.3 v2(231.33,42.89) 231.33,42.9 231.3,42.93 PU201.13
CSS_GC: length 324.4
  TOP w0.102: 180.07,69.22 180.53,69.22 v2(180.96,68.78)
  TOP w0.127: v1(3.47,100.19) 3.64,100.36 PR903.1
  TOP w0.254: PU1001.10 180.28,70.18 180.53,69.93 180.53,69.67 180.07,69.22 v1(179.67,69.22)
  IN1 w0.254: v1(179.67,69.22) 179.67,69.04 176.93,66.31 174.93,66.31 173.35,64.73 173.35,64.29 174.5,63.14 174.5,51.28 170.01,46.8 168.84,46.8 167.21,45.16 167.21,44.32 163.38,40.5 163.38,24.19 163.65,23.93 163.65,16.35 164.9,15.1 165.68,15.1 165.95,15.37 v1(165.95,16.07)
  IN2 w0.254: v1(3.47,100.19) 3.16,99.89 3.16,85.65 3.99,84.82 3.99,77.66 5.26,76.39 5.26,66.75 11.02,60.99 22.49,60.99 26.67,56.81 26.67,47.8 29.02,45.45 29.02,41.14 28.51,40.63 28.49,40.63 27.96,40.1 27.96,35.3 28.19,35.08 28.19,30.18 30.33,28.04 30.33,11.02 31.53,9.81 31.53,9.15 31.97,8.71 33.23,8.71 33.33,8.81 35.07,8.81 35.59,8.29 104.04,8.29 107.55,11.8 108.16,11.8 108.16,11.8 109.62,11.8 110.58,12.75 111.64,12.75 114.25,15.35 117.11,15.35 117.33,15.13 117.8,15.13 119.16,13.77 121,13.77 121.38,13.39 125.7,13.39 125.74,13.35 126.57,13.35 127.34,12.58 127.81,12.12 130.91,12.12 131.81,13.01 154.63,13.01 158.39,16.78 159.88,16.78 159.91,16.8 159.97,16.87 161.87,16.87 162.37,16.36 162.62,16.36 164.41,16.36 165.28,17.23 165.85,17.23 166.13,16.95 166.13,16.24 v1(165.95,16.07)
CSSN_1: length 443.1
  TOP w0.254: v3(127.18,119.11) 126.91,119.11 126.6,118.81 126.6,113.07 134.97,104.7 140.38,104.7 146.11,98.97 146.11,95.06 v1(145.98,94.93) ; v1(6.7,96.24) 8.34,96.24 8.79,96.69 PQ902.3 ; PR908.1 PQ904.2 112.93,118.68 113.26,119.02 113.26,119.21 113.57,119.52 v1(113.57,120.82) ; v1(174.27,39.38) PR906.1 173.46,40.29 PR904.1 173.3,41.3 173.18,41.42 173.18,46.57 168.5,51.25 168.5,53.4 168.82,53.72 170.72,53.72 172.52,55.51 172.52,62.65 170.79,64.38 170.79,69.14 169.44,70.49 169.44,79.64 172.53,82.73 173.34,82.73 v1(173.52,82.55)
  IN1 w0.254: v1(6.7,96.24) 7.19,95.76 7.19,95.28 6.93,95.02 6.93,93.88 7.69,93.13 11.71,93.13 12.15,92.69 12.15,86.64 8.88,83.37 8.88,74.07 7.74,72.93 7.74,65.33 13.81,59.26 24.18,59.26 26.63,56.81 26.63,44.96 27.37,44.22 27.37,42.23 26.74,41.61 26.74,37.63 v1(25.98,36.87)
  IN2 w0.254: v1(173.52,82.55) 173.36,82.71 172.36,82.71 171.88,83.19 171.88,86 172.26,86.38 172.26,88.91 171.55,89.62 149.59,89.62 146.11,93.1 146.11,94.81 v1(145.98,94.93)
  IN3 w0.254: v1(125.82,9.92) 125.82,10.39 125.35,10.86 120.25,10.86 118.48,9.09 115.59,9.09 115.58,9.1 111.5,9.1 111.17,8.78 108.77,8.78 106.63,6.63 35.55,6.63 35.41,6.49 34.49,6.49 33.41,5.41 33.41,4.4 v1(33.29,4.28)
  IN4 w0.254: v3(127.18,119.11) 127.11,119.11 125.66,117.67 117.3,117.67 115.57,119.39 113.99,119.39 113.61,119.77 113.61,120.78 v1(113.57,120.82) ; v1(33.29,4.28) 33.4,4.39 33.4,4.76 32.82,5.33 31.59,5.33 29.53,7.39 28.03,7.39 27.21,8.21 27.21,10.6 24.85,12.96 24.85,19.36 25.29,19.8 25.85,19.8 26.53,20.48 26.53,23.22 23.95,25.79 23.95,34.58 25.61,36.25 25.61,36.5 v1(25.98,36.87) ; v1(125.82,9.92) 125.93,10.03 125.93,10.2 126.1,10.36 132.35,10.36 133.47,11.48 163.79,11.48 167.98,15.67 167.98,19.2 168.5,19.72 168.5,24.22 166.85,25.88 166.85,32.67 169.3,35.12 172.47,35.12 173.06,35.71 173.06,39.13 173.32,39.38 v1(174.27,39.38)
CSSP_1: length 442.3
  TOP w0.254: PQ904.5 113.7,118.68 113.28,118.26 113.28,116.88 v1(113.4,116.76) ; v1(6.68,95.52) 6.58,95.62 6.44,95.62 6.2,95.86 6.2,96.23 5.05,97.37 PQ903.3 ; v1(110.65,120.36) 110.24,119.94 PR907.1 ; v1(171.48,39.38) PR905.1 172.35,39.4 PR904.2 172.35,41.12 172.8,41.57 172.8,46.41 168.12,51.09 168.12,53.56 168.66,54.1 170.57,54.1 172.13,55.67 172.13,62.49 170.41,64.22 170.41,68.98 169.06,70.33 169.06,79.8 172.37,83.11 173.38,83.11 v1(173.52,83.25) ; v1(127.18,118.45) 127.18,113.04 135.13,105.08 140.54,105.08 146.49,99.13 146.49,95.06 v3(146.62,94.93)
  IN1 w0.254: v1(26.01,37.8) 26.01,37.86 26.36,38.21 26.36,41.76 26.95,42.35 26.95,44.1 26.26,44.79 26.26,56.62 26.25,56.63 26.25,56.65 24.02,58.88 13.65,58.88 7.36,65.17 7.36,73.09 8.5,74.23 8.5,83.53 11.75,86.77 11.75,92.37 11.36,92.75 7.53,92.75 6.53,93.75 6.53,95.36 v1(6.68,95.52)
  IN2 w0.254: v1(173.52,83.25) 173.36,83.09 172.51,83.09 172.26,83.34 172.26,85.84 172.64,86.22 172.64,89.07 171.71,90.01 149.75,90.01 146.49,93.26 146.49,94.81 v3(146.62,94.93)
  IN3 w0.254: v1(33.92,4.28) 33.79,4.41 33.79,5.25 34.64,6.11 35.57,6.11 35.71,6.25 106.79,6.25 108.93,8.4 111.33,8.4 111.66,8.72 115.57,8.72 115.58,8.71 118.64,8.71 120.41,10.48 124.81,10.48 v1(125.2,10.1)
  IN4 w0.254: v1(125.2,10.1) 125.2,10.33 125.61,10.74 132.19,10.74 133.31,11.86 163.63,11.86 167.6,15.83 167.6,19.36 168.12,19.88 168.12,24.07 166.47,25.72 166.47,32.83 169.14,35.5 172.31,35.5 172.68,35.87 172.68,39.13 172.43,39.38 v1(171.48,39.38) ; v1(33.92,4.28) 33.78,4.42 33.78,4.92 32.98,5.72 31.75,5.72 29.69,7.77 28.19,7.77 27.6,8.37 27.6,10.76 25.23,13.12 25.23,19.2 25.45,19.42 26.01,19.42 26.91,20.32 26.91,23.37 24.33,25.95 24.33,34.42 26.52,36.6 26.52,37.25 26.47,37.3 26.47,37.34 v1(26.01,37.8) ; v1(127.18,118.45) 127.14,118.45 125.96,117.27 117.03,117.27 115.97,118.33 114.9,118.33 113.4,116.83 v1(113.4,116.76) 113.28,116.88 113.28,117.73 v1(110.65,120.36)
D_CLKRUN#: length 155
  IN2 w0.127: v1(225.25,74.02) 224.7,73.46 218.52,73.46 216.2,75.77 216.2,78.49 214.64,80.05 206.79,80.05 204.74,82.09 198.92,82.09 192.07,88.95 191.25,88.95 188.83,91.37 188.83,92.34 186.76,94.41 185.72,94.41 185.01,95.12 183.55,95.12 183.13,95.55 183.13,97.53 181.38,99.28 180.97,99.28 179.94,100.31 179.94,100.63 179.53,101.04 179.13,101.04 178.64,101.54 178.64,105.86 177.99,106.51 177.99,108.67 177.63,109.03 176.8,109.03 174.6,111.23 168.98,111.23 168.58,110.82 166.05,110.82 165.3,111.58 130.49,111.58 128.67,113.4 116.47,113.4 115.97,113.89 114.87,113.89 112.29,116.47 112.29,117.02 111.91,117.4 111,117.4 v1(110.95,117.45)
  BOTTOM w0.102: v1(225.25,74.02) 225.25,73.71 224.38,72.84 v2(224.38,72.43) 224.38,71.68 225.77,70.3 225.77,68.59 226.5,67.86 227.64,67.86 R777.1 228.39,68.62 228.92,68.62 229.75,69.45 U46.A19
  BOTTOM w0.127: v1(110.95,117.45) 110.95,117.48 111.24,117.77 JDOCK1.111
D_DLDRQ1#: length 156.5
  TOP w0.102: v2(234.25,69.44) 234.25,70.04 233.72,70.57 v1(233.72,70.6)
  IN2 w0.127: v1(233.72,70.6) 233.72,70.71 233.28,71.15 232.6,71.15 231.24,72.5 229.63,72.5 v1(229.08,71.96) 226.69,74.35 226.06,74.35 225.68,74.73 224.14,74.73 223.33,73.92 218.71,73.92 216.66,75.96 216.66,78.78 214.93,80.51 206.98,80.51 204.93,82.55 199.11,82.55 192.12,89.54 191.97,89.54 190.66,90.86 190.66,92.38 188.18,94.87 185.91,94.87 185.62,95.16 185.62,97.03 184.61,98.04 183.56,98.04 181.86,99.73 181.16,99.73 180.4,100.5 180.4,102.04 179.97,102.47 179.97,103.14 179.1,104.01 179.1,106.05 178.45,106.7 178.45,109.54 176.25,111.74 168.5,111.74 168.04,111.28 166.24,111.28 165.49,112.03 130.68,112.03 128.79,113.92 117.3,113.92 114.36,116.85 v1(114.2,116.85)
  BOTTOM w0.102: v1(114.2,116.85) 113.99,116.85 113.52,117.32 113.22,117.32 112.74,117.8 JDOCK1.117 ; v1(233.72,70.6) 233.72,70.71 233.28,71.15 232.61,71.15 232.56,71.2 U46.B24 ; v1(229.08,71.96) 229.34,71.7 229.34,71.18 228.87,70.71 228.87,70.47 228.64,70.24 R782.1
D_LAD0: length 169.3
  TOP w0.102: v1(233.62,74.23) 233.61,74.19 232.88,73.46 232.13,73.46 231.81,73.14 v2(231.19,73.14) 231.16,73.14 230.68,73.62 229.75,73.62 229.51,73.38 228.57,73.38 227.59,72.4 225.9,72.4 225.32,71.82 224.29,71.82 223.24,70.78 v1(222.73,70.78)
  IN2 w0.127: v1(222.73,70.78) 221.7,70.78 221.58,70.9 217.63,70.9 213.27,66.55 205.3,66.55 203.27,68.58 191.52,68.58 190.63,69.48 190.63,86.15 189.14,87.63 189.14,88.14 188.31,88.96 187.81,88.96 184.2,92.58 184.2,92.86 181.98,95.08 181.98,97.05 180.9,98.13 179.89,98.13 177.49,100.53 177.49,105.38 176.41,106.47 176.41,107.4 175.39,108.42 169.98,108.42 168.72,109.68 165.44,109.68 164.69,110.43 130.01,110.43 128.55,111.9 112.08,111.9 107.96,116.02 v1(107.96,116.64)
  BOTTOM w0.102: v1(107.96,116.64) 107.5,117.09 107.5,117.63 107.74,117.87 JDOCK1.97 ; v1(233.62,74.23) 233.61,74.23 233.61,74.08 233.24,73.7 U46.B29
D_LAD1: length 161.4
  TOP w0.102: v2(234.3,72.38) 234.26,72.34 233.72,72.34 v1(233.68,72.38)
  IN2 w0.127: v1(233.68,72.38) 233.77,72.29 233.82,72.29 234.34,71.77 234.34,70.55 233.95,70.16 232.79,70.16 231.91,69.28 226.38,69.28 224.08,71.58 218.71,71.58 215.29,75 215.29,78.09 214.25,79.13 203.41,79.13 201.37,81.18 197.34,81.18 191.15,87.37 190.06,87.37 189.74,87.68 189.74,88.43 187.26,90.91 187.26,92.62 186.48,93.4 183.98,93.4 182.21,95.17 182.21,97.15 181,98.36 179.98,98.36 177.72,100.62 177.72,105.48 176.64,106.56 176.64,107.5 175.49,108.65 171.14,108.65 170.43,109.36 169.37,109.36 168.82,109.91 165.67,109.91 164.92,110.66 130.11,110.66 128.65,112.13 113.79,112.13 112.21,113.7 110.6,113.7 108.43,115.87 108.43,116.87 v1(107.96,117.34)
  BOTTOM w0.102: JDOCK1.99 108.24,117.78 107.96,117.5 v1(107.96,117.34) ; U46.B28 233.09,73.2 233.68,72.61 v1(233.68,72.38)
D_LAD2: length 156.4
  IN2 w0.127: v1(111.21,116.66) 111.4,116.47 111.4,116.47 114.36,113.51 115.82,113.51 116.15,113.17 128.57,113.17 130.39,111.35 165.2,111.35 165.96,110.59 168.67,110.59 169.07,110.99 169.13,110.99 169.14,111 174.45,111 174.46,110.99 174.51,110.99 176.69,108.8 177.54,108.8 177.76,108.58 177.76,106.41 178.41,105.76 178.41,100.91 180.27,99.05 181.28,99.05 182.9,97.43 182.9,95.45 183.46,94.89 184.91,94.89 185.62,94.18 186.66,94.18 187.95,92.9 187.95,91.94 191.16,88.72 191.97,88.72 198.83,81.86 203.64,81.86 205.68,79.82 214.55,79.82 215.97,78.39 215.97,75.68 218.42,73.23 223.39,73.23 226.66,69.96 230.73,69.96 231.06,70.3 231.06,70.82 229.97,71.91 v3(229.97,71.93)
  BOTTOM w0.102: v1(111.21,116.66) 111.2,116.66 110.54,116 109,116 108.65,116.36 108.65,116.78 109.24,117.37 JDOCK1.103 ; v3(229.97,71.93) 230.49,72.45 U46.A25
D_LAD3: length 155.7
  TOP w0.102: v1(109.24,116.7) 108.85,116.7 v2(108.67,116.52)
  IN2 w0.127: v1(109.24,116.7) 109.24,115.7 110.79,114.16 112.4,114.16 113.98,112.58 119.92,112.58 120.28,112.94 128.48,112.94 130.3,111.12 165.11,111.12 165.86,110.36 168.83,110.36 169.24,110.77 174.36,110.77 175.49,109.64 175.49,109.3 177.09,107.69 177.09,106.75 178.18,105.67 178.18,100.81 180.17,98.82 181.19,98.82 182.67,97.34 182.67,95.36 183.36,94.67 184.82,94.67 185.53,93.96 186.57,93.96 187.72,92.81 187.72,91.84 191.06,88.49 191.06,88.1 197.53,81.64 203.54,81.64 205.59,79.59 214.45,79.59 215.75,78.3 215.75,75.58 218.33,73 223.3,73 226.57,69.74 230.85,69.74 231.3,70.19 231.3,71.26 v1(230.61,71.95)
  BOTTOM w0.102: v1(230.61,71.95) U46.A24 ; JDOCK1.105 109.74,117.39 109.24,116.89 v1(109.24,116.7)
D_LFRAME#: length 157.9
  TOP w0.102: v1(110.58,116.73) 110.58,116.48 v2(110.87,116.19)
  IN2 w0.127: v1(110.58,116.73) 110.11,117.2 109.09,117.2 108.66,116.76 108.66,115.96 110.69,113.93 112.3,113.93 113.88,112.35 128.74,112.35 130.2,110.89 165.01,110.89 165.77,110.13 168.91,110.13 169.36,109.69 170.55,109.69 171.05,109.18 175.28,109.18 176.87,107.59 176.87,106.66 177.95,105.57 177.95,100.72 180.08,98.59 181.09,98.59 182.44,97.24 182.44,95.26 183.27,94.44 184.72,94.44 185.43,93.73 186.47,93.73 187.49,92.71 187.49,91.61 190.77,88.33 190.77,88.08 197.43,81.41 201.46,81.41 203.51,79.36 214.34,79.36 215.52,78.19 215.52,75.09 218.81,71.81 224.17,71.81 226.47,69.51 231.81,69.51 v1(233.01,70.7)
  BOTTOM w0.102: JDOCK1.109 110.74,117.89 110.45,117.6 110.45,116.85 v1(110.58,116.73) ; U46.B23 v1(233.01,70.7)
D_SERIRQ: length 152.8
  IN2 w0.127: v1(229.4,70.63) 229.36,70.59 228.9,70.59 228.64,70.84 228.05,71.43 228.05,72.57 226.57,74.05 225.94,74.05 225.54,74.46 224.2,74.46 223.43,73.69 218.61,73.69 216.43,75.87 216.43,78.68 214.84,80.28 206.88,80.28 204.84,82.32 199.02,82.32 192.16,89.18 191.57,89.18 189.06,91.68 189.06,92.43 186.85,94.64 185.81,94.64 185.07,95.38 183.62,95.38 183.35,95.64 183.35,97.62 181.47,99.51 181.07,99.51 180.17,100.4 180.17,101.94 179.75,102.36 179.12,102.36 178.87,102.62 178.87,105.95 178.22,106.6 178.22,109.44 176.15,111.51 168.6,111.51 168.14,111.05 166.15,111.05 165.39,111.8 130.58,111.8 128.7,113.69 116.58,113.69 116.11,114.16 115.28,114.16 112.75,116.69 v1(112.75,116.76)
  BOTTOM w0.102: U46.A20 229.52,69.95 v2(229.39,69.81) 228.89,69.32 R780.1 228.16,69.32 229.4,70.56 v1(229.4,70.63) ; JDOCK1.115 112.24,117.2 112.67,116.76 v1(112.75,116.76)
DAI_12MHZ#: length 345.9
  TOP w0.102: v1(100.3,110.6) 100.52,110.6 v2(101.17,109.95) 103.08,108.04 103.08,98.65 108.42,93.32 125.01,93.32 132.13,100.44 138.69,100.44 143.37,95.77 143.37,95.25 v1(143.32,95.2) ; JIO1.17 v1(32.31,40.75)
  IN3 w0.127: v1(143.32,95.2) 143.32,95.8 143.71,96.19 144.42,96.19 145.27,97.04 151.39,97.04 151.7,96.74 158.39,96.74 160.91,94.22 160.91,90.21 168.04,83.07 168.04,69.18 170.86,66.36 170.86,55.51 168.4,53.05 168.4,50.93 162.83,45.35 162.83,44.01 161.63,42.81 161.63,27.06 161.06,26.49 161.06,20.24 157.19,16.36 157.19,14.58 156.16,13.55 153.25,13.55 153.03,13.77 131.66,13.77 130.96,14.47 119.02,14.47 117.51,15.98 114.17,15.98 110.31,12.12 110.31,11.62 v1(110.4,11.53)
  IN4 w0.109: v1(110.4,11.53) 110.37,11.56 108.72,11.56 108.14,10.97 105.93,10.97 103.64,8.69 37.35,8.69 34.92,11.11 32.25,11.11 31.55,11.82 31.55,19.88 32.14,20.47 32.51,20.47 33.36,21.32 33.36,27.17 33.24,27.29 33.24,32.38 33.68,32.82 33.68,39.37 32.31,40.74 v1(32.31,40.75)
  BOTTOM w0.102: JDOCK1.89 104.74,117.64 105,117.37 RE11.1 104.37,113.06 101.94,110.63 100.33,110.63 v1(100.3,110.6)
DAI_BCLK#: length 346.1
  TOP w0.102: JIO1.25 30.23,38.35 29.79,38.79 v1(29.73,38.79) ; v1(144.7,95.61) 144.55,95.76 144.09,95.76 138.91,100.94 131.84,100.94 v2(128.83,97.93) 124.71,93.82 108.62,93.82 103.58,98.86 103.58,111.09 102.97,111.7 102.97,113.37 102.53,113.82 102.53,115.84 v1(102.64,115.95)
  IN3 w0.127: v1(107.78,10.06) 107.97,10.25 107.97,10.78 108.58,11.39 108.91,11.39 113.96,16.43 117.73,16.43 119.23,14.94 131.29,14.94 132,14.22 153.24,14.22 153.45,14.01 155.95,14.01 156.73,14.78 156.73,16.57 160.59,20.43 160.59,26.69 161.16,27.26 161.16,42.99 162.37,44.2 162.37,45.37 162.37,46.72 163.81,48.16 164.97,48.16 167.94,51.14 167.94,53.24 170.36,55.65 170.36,66.2 167.57,68.98 167.57,82.89 160.36,90.11 160.36,94.11 158.19,96.28 151.51,96.28 151.23,96.56 146.87,96.56 146.38,96.06 145.05,96.06 144.7,95.72 v1(144.7,95.61)
  IN4 w0.109: v1(107.78,10.06) 107.39,10.45 106.08,10.45 103.86,8.23 37.04,8.23 34.62,10.66 32.05,10.66 30.76,11.95 30.76,20.3 30.96,20.51 30.96,22.46 31.88,23.37 31.88,31.7 33.22,33.04 33.22,37.34 33.18,37.38 33.18,38.56 32.54,39.21 30.15,39.21 v1(29.73,38.79)
  BOTTOM w0.102: RE12.1 101.95,115.27 v1(102.64,115.95) 102.11,116.48 101.26,116.48 101.07,116.68 101.07,117.29 101.74,117.96 JDOCK1.77
DAI_DI: length 340.2
  TOP w0.102: JIO1.21 29.82,39.55 v1(29.7,39.43) ; v1(103.91,115.95) 104.04,115.82 104.04,99.05 108.81,94.27 124.38,94.27 131.5,101.4 139.1,101.4 143.99,96.51 v2(144.68,96.51) v1(145.59,96.51)
  IN3 w0.127: v1(108.41,10.15) 108.47,10.21 109,10.21 109.49,10.69 109.49,11.63 114.06,16.21 117.63,16.21 119.12,14.71 131.15,14.71 131.86,14 153.14,14 153.35,13.78 156.06,13.78 156.96,14.68 156.96,16.46 160.82,20.32 160.82,26.59 161.39,27.16 161.39,42.89 162.6,44.1 162.6,45.46 168.17,51.04 168.17,53.14 170.61,55.58 170.61,66.27 167.8,69.08 167.8,82.99 160.58,90.21 160.58,94.2 158.28,96.51 151.6,96.51 151.32,96.79 145.87,96.79 v1(145.59,96.51)
  IN4 w0.109: v1(29.7,39.43) 32.64,39.43 33.45,38.62 33.45,32.92 33.01,32.48 33.01,27.19 33.13,27.06 33.13,21.42 32.42,20.7 32.04,20.7 31.32,19.98 31.32,11.72 32.16,10.88 34.73,10.88 37.16,8.46 103.74,8.46 105.97,10.68 108,10.68 108.41,10.27 108.41,10.16 v1(108.41,10.15)
  BOTTOM w0.102: v1(103.91,115.95) 103.91,116.17 103.36,116.71 103.36,117.63 103.24,117.75 JDOCK1.83
DAI_DO#: length 336.6
  TOP w0.102: v1(103.81,117.06) 103.81,117.07 103.44,116.7 v2(103.44,115.39) 103.44,111.55 103.81,111.18 103.81,98.95 108.72,94.04 124.47,94.04 131.6,101.17 139.01,101.17 144.12,96.05 144.91,96.05 v1(145.34,95.62) ; JIO1.23 32.17,38.95 v1(32.36,38.76)
  IN3 w0.127: v1(145.34,95.62) 145.35,95.63 146.89,95.63 147.01,95.5 149.91,95.5 150.46,96.05 158.09,96.05 160.13,94.01 160.13,90.02 167.35,82.8 167.35,68.89 170.11,66.12 170.11,55.73 167.71,53.33 167.71,51.23 164.87,48.39 163.72,48.39 162.14,46.81 162.14,45.65 162.14,44.29 160.93,43.08 160.93,27.35 160.36,26.78 160.36,20.59 156.5,16.73 156.5,14.88 155.85,14.24 153.55,14.24 153.34,14.45 132.1,14.45 131.39,15.16 119.34,15.16 117.84,16.66 113.85,16.66 108.94,11.75 108.6,11.75 107.14,10.29 v1(107.14,10.01)
  IN4 w0.109: v1(107.14,10.01) 105.97,10.01 103.96,8 36.92,8 34.49,10.43 31.96,10.43 30.53,11.86 30.53,20.4 30.74,20.6 30.74,22.64 31.18,23.08 31.65,23.56 31.65,31.79 32.99,33.13 32.99,37.22 32.9,37.31 32.9,38.21 v1(32.36,38.76)
  BOTTOM w0.102: JDOCK1.85 103.74,117.12 v1(103.81,117.06)
DAI_LRCK#: length 337.7
  TOP w0.102: JIO1.27 32.06,37.75 v1(32.29,37.99) ; v1(144.07,95.23) 144.07,95.45 138.85,100.67 132.04,100.67 124.91,93.55 108.51,93.55 103.31,98.75 103.31,108.13 102.49,108.96 v2(102.49,112.8) 102.49,113.45 102.04,113.89 102.04,116.71 v1(101.59,117.17)
  IN3 w0.127: v1(144.07,95.23) 144.21,95.09 145.45,95.09 145.77,95.4 146.79,95.4 147.1,95.09 149.95,95.09 150.32,95.46 151.13,95.46 151.81,94.78 153.88,94.78 154.72,93.94 157.63,93.94 158.19,94.5 159.32,94.5 159.86,93.96 159.86,89.96 167.12,82.7 167.12,68.79 169.86,66.05 169.86,55.8 167.49,53.43 167.49,51.32 164.79,48.63 163.63,48.63 161.91,46.9 161.91,45.75 161.91,45.75 161.91,45.18 161.91,45.18 161.91,44.38 160.69,43.17 160.69,27.44 160.13,26.88 160.13,20.7 156.17,16.74 156.17,14.95 155.69,14.47 153.66,14.47 153.44,14.68 132.21,14.68 131.49,15.39 119.49,15.39 117.99,16.89 113.75,16.89 108.9,12.04 108.56,12.04 107.1,10.58 106.88,10.58 106.32,10.02 v1(106.32,9.45)
  IN4 w0.109: v1(32.29,37.99) 32.29,37.52 32.76,37.05 32.76,36.6 31.42,35.26 31.42,23.65 31.13,23.35 30.51,22.74 30.51,20.7 30.3,20.49 30.3,11.76 31.87,10.2 34.36,10.2 36.79,7.77 104.65,7.77 v1(106.32,9.45)
  BOTTOM w0.102: v1(101.59,117.17) 101.59,117.23 102.24,117.89 JDOCK1.79
DAT_DDC2_CRT: length 26.3
  IN3 w0.127: v1(63.47,172.06) 58.6,172.06 58.03,172.63 JCRT1.12
  BOTTOM w0.102: U19.34 60.97,158.2 60.96,158.21 60.96,160.44 v2(61.68,161.16) 66.67,166.15 66.67,168.15 66.24,168.58 R47.2 66.24,168.73 65.05,169.93 65.05,170.31 63.68,171.68 63.68,171.86 v1(63.47,172.06)
DAT_DDC2_DOCK: length 66
  IN3 w0.127: v3(55.55,149.94) 55.35,149.73 55.35,149.38 58.89,145.83 58.89,145.09 64.05,139.93 68.51,139.93 69.4,140.82 70.22,140.82 70.48,140.56 70.48,140.55 70.75,140.28 71.54,140.28 72.19,139.64 73.3,139.64 73.84,139.1 74.65,139.1 75.12,138.63 75.12,138.4 75.78,137.74 75.78,135.67 75.23,135.12 75.23,134.53 81.14,128.63 81.14,127.66 81.88,126.92 86.97,126.92 90.53,123.37 91.81,123.37 92.14,123.7 v1(92.15,123.7)
  BOTTOM w0.102: v3(55.55,149.94) 55.33,150.15 55.33,150.31 55.04,150.6 54.19,150.6 53.36,151.42 53.36,151.92 53.76,152.31 54.27,152.31 55.77,153.81 58.43,153.81 58.46,153.79 U19.25 ; JDOCK1.46 92.74,124.48 92.18,123.91 92.18,123.72 v1(92.15,123.7)
DAT_KBD: length 136.9
  TOP w0.102: v1(170.58,146.1) 170.6,146.1 170.62,146.13 171.32,146.13 U54.B41
  IN2 w0.127: v1(116.39,129.79) 117.75,129.79 118.26,130.3 122.01,130.3 122.3,130.01 129.61,130.01 130.72,131.12 152.61,131.12 156.82,126.9 164.67,126.9 165.04,127.27 168.12,127.27 168.77,126.61 v1(168.77,126.26) ; v1(185,135.93) 185,135.26 182.8,133.06 182.8,125.39 v1(183.35,124.84)
  IN4 w0.109: v1(170.58,146.1) 170.79,146.1 171.5,146.81 171.5,148.16 172.21,148.87 173.48,148.87 173.7,148.65 175.4,148.65 176.59,147.46 176.59,147.44 176.93,147.1 178.07,147.1 178.78,147.82 180.58,147.82 181.06,147.33 186.13,147.33 188.52,144.95 188.52,141.91 189.53,140.89 189.53,136.93 188.92,136.32 187.46,136.32 187.2,136.58 185.65,136.58 v1(185,135.93)
  BOTTOM w0.102: v1(116.39,129.79) 116.01,130.18 104.41,130.18 102.24,128.01 JDOCK1.80 ; v1(170.58,146.1) 170.85,146.37 R846.1 ; v1(168.77,126.26) 169.05,125.98 v2(179.96,125.98) 181.48,125.98 182.62,124.84 v1(183.35,124.84)
DAT_MSE: length 189.3
  TOP w0.102: v1(196.56,99.95) 196.27,99.95 196.02,100.19 196.02,104.35 196.36,104.69 v1(196.53,104.69) ; v1(169.9,146.1) 170.34,146.55 170.84,146.55 170.93,146.63 U54.B42
  IN2 w0.127: v1(187.74,95.68) 187.74,95.71 186.76,96.69 186.76,97.08 184.49,99.35 183.89,99.35 183.49,99.75 183.49,100.53 183.13,100.89 182.81,100.89 181.24,102.46 181.24,103.88 180.24,104.89 180.24,106.2 179.31,107.13 179.31,110.37 177.18,112.5 168.79,112.5 168.54,112.75 157.17,112.75 156.91,112.49 131.55,112.49 129.57,114.47 120.22,114.47 118.57,116.11 116.2,116.11 114.11,118.2 107.55,118.2 107,117.64 106.01,117.64 104.9,118.75 104.9,119.45 102.84,121.51 102.84,122.06 102.27,122.63 101.84,122.63 v1(101.26,122.05) ; v1(169.9,146.1) 169.91,146.1 170.36,146.55 174.61,146.55 175.04,146.98 177.71,146.98 179.13,145.56 184.81,145.56 192.4,137.97 192.4,114.12 196.32,110.2 196.32,107.25 196.67,106.89 196.67,104.83 v1(196.53,104.69)
  IN4 w0.109: v1(187.74,95.68) 188.8,95.68 189.22,96.1 192.8,96.1 195.43,98.73 195.43,98.83 196.54,99.95 v1(196.56,99.95)
  BOTTOM w0.102: R852.1 171,145.1 170.88,144.97 170.22,144.97 169.9,145.29 v2(169.9,145.48) v1(169.9,146.1) ; v1(101.26,122.05) 101.74,121.56 101.74,121.11 100.74,120.11 JDOCK1.73
DAT_TP_SIO: length 269
  TOP w0.102: v1(40.61,13.55) 40.56,13.5 37.33,13.5 37.08,13.75 JIO1.108 ; v1(172.12,135.15) v2(172.12,133.99) 172.12,133.46 172.32,133.26 172.32,117.04 179,110.36 179,107.26 177.66,105.91 177.66,102.71 176.8,101.84 176.8,96.85 177.09,96.56 177.09,93.31 177.04,93.26 v1(177.04,92.99) ; v1(170.57,145.42) 170.79,145.63 U54.B40
  IN1 w0.109: v1(40.61,13.55) 40.83,13.77 43.86,13.77 44.77,12.87 44.77,11.89 45.32,11.34 101.66,11.34 106.86,16.54 111.67,16.54 113.3,18.17 118.41,18.17 120.43,16.14 128.37,16.14 128.96,16.73 145.59,16.73 150.68,21.82 153.34,21.82 155.95,24.43 155.95,26.49 158.45,28.99 158.89,28.99 159.53,29.63 159.53,43.17 160.12,43.76 160.12,45.57 161.89,47.34 161.89,49.3 164.61,52.02 169.51,52.02 170.2,52.72 170.2,52.74 170.29,52.83 170.29,60.78 169.13,61.94 169.13,75.82 176.07,82.77 176.07,88.67 177.35,89.95 177.35,92.67 v1(177.04,92.99) ; v1(172.12,135.15) 173.23,136.25 173.23,142.7 170.57,145.35 v1(170.57,145.42)
DC_BLOCK_GC: length 304.4
  TOP w0.254: v1(2.01,81.09) 1.71,81.38 1.71,84.63 v2(2.06,84.98) 2.53,85.45 PR902.2 ; PU1001.7 v1(177.87,68.1)
  IN1 w0.381: v1(162.67,14.87) 163.18,15.38 163.18,16.9 163.22,16.93 163.22,17.41 163.18,17.45 163.18,23.74 162.96,23.95 162.96,40.67 166.79,44.5 166.79,45.53 168.84,47.59 170.05,47.59 174.01,51.55 174.01,63.02 172.88,64.15 172.88,65 174.97,67.08 176.85,67.08 v1(177.87,68.1)
  IN2 w0.381: v1(162.67,14.87) 162.67,14.73 161.86,13.92 158.52,13.92 156.86,12.26 155.15,12.26 155.05,12.36 132.07,12.36 131.15,11.44 127.34,11.44 127.21,11.57 122.01,11.57 119.69,9.24 119.41,9.24 111.54,9.24 110.76,10.02 109.44,10.02 108.72,9.3 108.18,9.3 107.4,8.51 105.61,8.51 104.51,7.42 104.46,7.42 104.37,7.33 35.25,7.33 34.72,7.86 33.76,7.86 32.95,7.05 31.79,7.05 30.29,8.55 30.29,8.61 28.95,9.94 28.95,10.54 29.28,10.87 29.28,18.46 28.24,19.5 28.24,21.48 28.09,21.63 28.09,23.87 27.88,24.08 27.11,24.85 27.11,25.96 26.35,26.72 25.45,26.72 24.94,27.23 24.94,32.71 24.93,32.72 24.93,33.19 24.94,33.21 24.94,38.89 25.7,39.65 26.08,39.65 27.21,40.78 27.21,41.58 27.24,41.6 27.24,43.71 27.99,44.46 27.99,45.24 25.79,47.43 25.79,47.49 25.59,47.69 25.59,56.13 25.59,56.13 25.59,56.42 25.56,56.45 25.56,56.49 22.46,59.59 7.18,59.59 2.92,63.85 2.92,73.75 1.71,74.96 1.71,76.94 2.39,77.61 2.39,80.19 2.01,80.58 v1(2.01,81.09)
DDR3_DRAMRST#: length 23
  TOP w0.102: RD3.2 RD4.2 131.21,30.28 131.21,33.43 127.72,36.92 v2(124.15,36.92) 123.26,36.92 120.97,39.22 118.11,39.22 116.81,40.52 QC2.1
DDR3_DRAMRST#_CPU: length 35.5
  TOP w0.089: JCPU1.R8 92.9,55.42 v1(92.4,54.92)
  TOP w0.102: QC2.3 115.02,42.91 115.2,43.09 RC23.1
  TOP w0.127: RC23.1 114.39,43.75 113.9,44.24 113.9,44.25 113.52,44.63 v1(113.52,45.38)
  BOTTOM w0.102: v1(113.52,45.38) 111.87,45.38 v2(111.54,45.71) 110.83,46.42 94.09,46.42 93.84,46.67 93.36,46.67 92.87,47.16 92.87,49.21 92.75,49.34 92.05,49.34 91.92,49.47 91.92,51.25 92.87,52.2 92.87,54.34 92.4,54.82 v1(92.4,54.92)
DDR3_DRAMRST#_R: length 40.1
  TOP w0.102: RD3.1 132.1,29.2 JDIMM1.30 135.81,29.2 137.51,27.5 v1(137.74,27.5) ; v1(155.5,29.13) 155.37,29.26 155.22,29.26 154.75,29.73 151.01,29.73 150.48,29.2 JDIMM3.30
  IN4 w0.109: v1(137.74,27.5) 137.74,27.96 138.43,28.65 155.01,28.65 v1(155.5,29.13)
  BOTTOM w0.102: v1(137.74,27.5) 138.63,28.39 141.35,28.39 142.16,29.2 JDIMM2.30 ; v1(155.5,29.13) 155.56,29.2 JDIMM4.30
DDR_1.5V_CNTRL0: length 38.8
  IN1 w0.254: v1(242.57,76.84) 245.69,73.71 245.69,70.08 247.08,68.69 247.08,66.38 244.87,64.17 244.87,60.96 v1(245.03,60.8)
  BOTTOM w0.127: U46.A49 242.56,75.95 242.73,76.12 242.73,76.67 v1(242.57,76.84)
  BOTTOM w0.254: PR216.2 237.23,50.1 PR219.1 237.23,53.03 238.23,54.03 244.77,54.03 246.02,55.28 v2(246.02,58.89) 246.02,59.8 v1(245.03,60.8)
DDR_1.5V_CNTRL1: length 49.3
  TOP w0.254: v1(246.43,64.63) 246.43,61.05 243.77,58.4 243.77,52.18 244.6,51.36 v2(244.6,44.55) 244.6,43.82 244.05,43.27 237.53,43.27 236.99,43.8 v1(236.99,43.87)
  IN2 w0.254: v1(246.43,64.63) 245.83,65.23 241.06,65.23 239.57,63.74 234.14,63.74 233.78,64.1 233.78,65.18 233.44,65.52 v1(233.44,65.95)
  BOTTOM w0.127: U46.A16 233.08,66.29 233.44,65.93 v1(233.44,65.95)
  BOTTOM w0.254: v1(236.99,43.87) PR223.1 236.99,41.89 PR222.2
DDR_A_BS0: length 66.9
  TOP w0.089: JCPU1.AE10 90.87,65.45 v3(90.4,65.92)
  TOP w0.102: JDIMM1.109 142.14,55.3 141.4,54.56 141.4,54.19 141.12,53.91 138.83,53.91 v1(138.4,54.35)
  IN1 w0.089: v3(90.4,65.92) 90.72,65.6 90.72,64.74 91.09,64.37 94.1,64.37 94.15,64.32 97.66,64.32 98.88,65.54 103.98,65.54 104.49,66.06
  IN1 w0.267: 104.49,66.06 112.64,66.06 112.65,66.06 113.27,66.06 114.13,65.19 117.9,65.19 126.59,56.5 129.5,56.5 130.2,55.8 131.36,55.8 132.11,55.05 132.72,55.05 132.79,54.98 137.18,54.98 137.19,54.97 137.97,54.97 138.4,54.54 v1(138.4,54.35)
  BOTTOM w0.102: JDIMM2.109 139.05,55.3 139.18,55.17 139.18,54.92 139.05,54.79 138.7,54.79 138.4,54.49 v1(138.4,54.35)
DDR_A_BS1: length 66.4
  TOP w0.089: v1(91.39,65.91) 90.9,66.4 JCPU1.AF10
  TOP w0.102: v1(139.67,54.35) 139.02,55 JDIMM1.108
  IN1 w0.089: v1(91.39,65.91) 90.99,65.51 90.99,64.8 91.2,64.59 91.21,64.59 91.24,64.56 92.26,64.56 92.26,64.56 94.16,64.56 94.22,64.5 97.58,64.5 98.84,65.76 103.57,65.76 104.43,66.62 104.49,66.62
  IN1 w0.267: v1(139.67,54.35) 139.55,54.47 139.55,54.56 138.58,55.53 137.43,55.53 137.41,55.54 133.02,55.54 132.96,55.6 132.35,55.6 131.59,56.36 130.43,56.36 129.73,57.06 126.82,57.06 118.13,65.75 114.36,65.75 113.49,66.62 104.49,66.62
  BOTTOM w0.102: JDIMM2.108 141.51,55 141.39,54.87 141.39,54.09 141.2,53.9 140.11,53.9 v1(139.67,54.35)
DDR_A_BS2: length 68.1
  TOP w0.089: v3(94.39,57.95) 94.89,58.45 JCPU1.V6
  TOP w0.102: v1(139.7,45.14) 139.7,45.17 140.13,45.61 140.57,45.61 140.8,45.38 140.8,45 140.84,44.96 141.12,44.96 141.21,45.05 141.21,45.5 141.27,45.57 141.51,45.57 142.24,46.3 JDIMM1.79
  IN1 w0.089: v3(94.39,57.95) 94.39,57.52 94.78,57.14 94.78,56.82 94.91,56.7 95.69,56.7 96.06,56.33 96.55,56.33 96.79,56.09 96.79,55.96 97.28,55.47 100.92,55.47 103.6,52.79 104.49,52.79
  IN1 w0.267: 104.49,52.79 105.23,52.79 115.36,42.67 116.74,42.67 117.32,42.08 121.93,42.08 122.3,41.71 133.57,41.71 135.68,43.83 140.89,43.83 141.02,43.96 141.02,44.49 140.89,44.62 139.79,44.62 139.69,44.73 139.69,45.12 v1(139.7,45.14)
  BOTTOM w0.102: v1(139.7,45.14) 139.27,45.57 136.46,45.57 135.73,46.3 JDIMM2.79
DDR_A_CAS#: length 70.6
  TOP w0.089: JCPU1.AE8 92.9,65.45 92.4,65.94 v3(92.4,65.99)
  TOP w0.102: JDIMM1.115 141.28,57.1 140.89,57.48 139.28,57.48 139.16,57.36 139.16,56.77 139.28,56.64 v1(139.29,56.64)
  IN1 w0.089: 104.48,68.29 104.13,67.95 104.13,67.69 104.05,67.62 103.55,67.62 103.34,67.41 103.34,66.87 103.23,66.75 103.07,66.75 102.96,66.87 102.96,67.19 102.85,67.29 102.7,67.29 102.6,67.19 102.6,66.42 102.5,66.32 102.35,66.32 102.24,66.42 102.24,67.17 102.12,67.29 101.94,67.29 101.82,67.17 101.82,66.46 101.69,66.33 95.96,66.33 95.83,66.2 95.83,65.82 95.71,65.7 95.59,65.7 95.46,65.82 95.46,66.2 95.37,66.29 95.23,66.29 95.13,66.2 95.13,65.9 95.04,65.81 94.91,65.81 94.82,65.9 94.82,66.23 94.69,66.36 93.9,66.36 93.74,66.52 93.23,66.52 93.1,66.39 93.1,66.3 92.98,66.18 92.81,66.18 92.68,66.3 92.68,66.39 92.56,66.52 92.12,66.52 91.99,66.39 91.99,65.87 92.12,65.75 92.25,65.75 92.37,65.87 92.37,65.96 v3(92.4,65.99)
  IN1 w0.267: 104.48,68.29 114.19,68.29 114.66,67.83 119.57,67.83 126.3,61.1 126.3,60.71 127.42,59.59 129.24,59.59 130.09,58.74 130.43,58.74 131.13,58.04 132.98,58.04 133.75,57.26 138.94,57.26 139.29,56.92 v1(139.29,56.64)
  BOTTOM w0.102: JDIMM2.115 135.7,57.1 136.59,56.21 138.98,56.21 139.29,56.52 v1(139.29,56.64)
DDR_A_D0: length 75.8
  TOP w0.089: v3(95.4,42.96) 95.4,42.92 95.9,43.42 JCPU1.C5
  TOP w0.14: v1(141.67,20.63) 141.67,21.06 142.31,21.7 JDIMM1.5
  IN1 w0.089: 95.48,39.69 95.8,40.02 95.8,42.52 95.4,42.92 v3(95.4,42.96)
  IN1 w0.147: 95.48,39.69 93.91,38.12 93.91,36.55 92.9,35.54 92.9,34.5 93.46,33.95 93.46,27.81 97.71,23.56 106.32,23.56 106.87,23.01 108.61,23.01 111.55,20.07 119.61,20.07 120.37,19.31 121.69,19.31 122.21,19.83 123.56,19.83 123.83,19.56 134.86,19.56 136.75,21.46 139.36,21.46 139.51,21.6 139.51,21.92 139.64,22.05 139.97,22.05 140.1,21.92 140.1,21.35 140.23,21.22 141.07,21.22 v1(141.67,20.63)
  BOTTOM w0.14: JDIMM2.4 142.05,21.4 141.67,21.02 v1(141.67,20.63)
DDR_A_D1: length 77.8
  TOP w0.089: JCPU1.D5 95.9,44.42 95.4,43.92 v1(95.4,43.95)
  TOP w0.14: v1(140.15,20.63) 140.65,21.13 140.77,21.13 141.93,22.3 JDIMM1.7
  IN1 w0.089: v1(95.4,43.95) 95.05,43.95 94.92,43.82 94.92,43.47 95,43.39 95,40.56 94.14,39.69
  IN1 w0.147: v1(140.15,20.63) 139.69,21.08 136.91,21.08 134.7,18.87 120.27,18.87 119.46,19.69 111.32,19.69 108.38,22.63 106.72,22.63 106.17,23.19 97.55,23.19 93.08,27.65 93.08,33.66 92.43,34.31 92.43,37.21 93.72,38.51 93.72,39.28 94.14,39.69
  BOTTOM w0.14: JDIMM2.6 141.76,22 140.91,21.15 140.64,21.15 140.15,20.65 v1(140.15,20.63)
DDR_A_D2: length 77.6
  TOP w0.089: JCPU1.D3 97.9,44.42 97.4,43.92 v1(97.4,43.95)
  TOP w0.14: JDIMM1.16 135.86,25 136.37,24.49 136.37,24.03 137.06,23.34 138.01,23.34 138.48,23.82 138.5,23.82 v1(138.62,23.95)
  IN1 w0.089: 97.48,39.69 97.48,39.9 97.82,40.24 97.82,43.29 97.7,43.42 97.36,43.42 97.23,43.55 97.23,43.82 97.36,43.95 v1(97.4,43.95)
  IN1 w0.147: v1(138.62,23.95) 138.82,23.95 138.95,23.82 138.95,23.59 138.82,23.47 137.41,23.47 137.28,23.34 137.28,23.24 137.16,23.11 136.87,23.11 136.75,23.22 136.75,23.37 136.64,23.48 136.49,23.48 136.21,23.2 134.94,21.93 134.8,21.93 134.67,21.8 134.67,21.57 134.54,21.44 134.22,21.44 134.09,21.57 134.09,21.8 133.97,21.93 132.91,21.93 132.77,21.79 132.77,21.73 132.66,21.63 132.45,21.63 132.33,21.74 132.33,21.8 132.21,21.93 131.86,21.93 131.79,21.86 131.79,21.45 131.72,21.38 122.45,21.38 122.21,21.62 112.43,21.62 109.49,24.56 108.87,24.56 108.74,24.69 108.74,24.91 108.61,25.04 107.1,25.04 106.98,25.16 106.98,25.61 106.85,25.74 97.94,25.74 95.25,28.43 95.25,35.26 95.47,35.48 95.47,37.48 97.48,39.49 97.48,39.69
  BOTTOM w0.14: JDIMM2.15 135.67,24.7 136.94,23.43 138.25,23.43 138.5,23.68 138.5,23.82 v1(138.62,23.95)
DDR_A_D3: length 74.3
  TOP w0.089: v3(98.4,43.95) 98.4,43.92 98.9,44.42 JCPU1.D2
  TOP w0.14: v1(137.1,23.95) 137.08,23.96 137.08,24.33 135.82,25.6 JDIMM1.18
  IN1 w0.089: v3(98.4,43.95) 98.3,43.95 98,43.65 98,40.13 97.86,39.98 97.86,39.69
  IN1 w0.147: v1(137.1,23.95) 136.42,23.95 134.78,22.31 131.59,22.31 131.41,22.13 131.41,21.84 131.33,21.76 125.7,21.76 125.57,21.89 125.57,22.09 125.44,22.21 125.11,22.21 124.98,22.09 124.98,21.89 124.85,21.76 124.52,21.76 124.39,21.89 124.39,22.18 124.26,22.31 123.93,22.31 123.8,22.18 123.8,21.89 123.67,21.76 123.34,21.76 123.21,21.89 123.21,22.18 123.08,22.31 122.75,22.31 122.62,22.18 122.62,22.12 122.5,22 122.08,22 121.95,22.12 121.95,22.18 121.82,22.31 121.49,22.31 121.36,22.18 121.36,22.12 121.24,22 120.9,22 120.77,22.12 120.77,22.18 120.65,22.31 120.31,22.31 120.18,22.18 120.18,22.12 120.06,22 119.72,22 119.59,22.12 119.59,22.18 119.47,22.31 119.13,22.31 119.01,22.18 119.01,22.12 118.88,22 118.54,22 118.42,22.12 118.42,22.18 118.29,22.31 117.95,22.31 117.83,22.18 117.83,22.12 117.7,22 117.36,22 117.24,22.12 117.24,22.18 117.11,22.31 116.77,22.31 116.65,22.18 116.65,22.12 116.52,22 116.19,22 116.06,22.12 116.06,22.18 115.93,22.31 115.6,22.31 115.47,22.18 115.47,22.12 115.34,22 115.01,22 114.88,22.12 114.88,22.18 114.75,22.31 114.42,22.31 114.29,22.18 114.29,22.15 114.14,22 113.85,22 113.7,22.15 113.7,22.16 113.55,22.31 113.26,22.31 113.11,22.16 113.11,22.15 112.96,22 112.59,22 109.12,25.46 108.73,25.46 108.6,25.59 108.6,25.98 108.48,26.11 108.1,26.11 107.97,25.98 107.97,25.57 107.85,25.44 107.48,25.44 107.35,25.57 107.35,25.98 107.22,26.11 98.09,26.11 95.62,28.58 95.62,35.07 95.84,35.29 95.84,37.32 97.86,39.34 97.86,39.69
  BOTTOM w0.14: JDIMM2.17 135.87,25.3 137.08,24.09 137.08,23.96 v1(137.1,23.95)
DDR_A_D4: length 80.5
  TOP w0.089: v3(94.4,43.95) 94.4,43.92 94.9,44.42 JCPU1.D6
  TOP w0.14: v1(138.62,20.63) 138.62,20.59 138.15,20.12 136.52,20.12 136.28,20.36 136.28,21.06 135.94,21.4 JDIMM1.4
  IN1 w0.089: 93.07,39.69 93.97,40.59 93.97,43.51 v3(94.4,43.95)
  IN1 w0.147: 93.07,39.69 92.76,39.37 92.76,38.63 91.01,36.88 91.01,34.12 92.33,32.79 92.33,27.21 97.11,22.43 105.85,22.43 106.4,21.88 107.91,21.88 110.85,18.94 119.14,18.94 119.97,18.11 136.09,18.11 138.61,20.63 v1(138.62,20.63)
  BOTTOM w0.14: v1(138.62,20.63) 138.62,20.58 138.14,20.09 136.94,20.09 136.24,20.79 136.24,21.37 135.92,21.7 JDIMM2.5
DDR_A_D5: length 77.2
  TOP w0.089: JCPU1.C6 94.9,43.42 94.4,42.92 v1(94.4,42.96)
  TOP w0.14: JDIMM1.6 136.02,22 136.75,21.27 136.75,20.75 136.88,20.63 v1(137.1,20.63)
  IN1 w0.089: v1(94.4,42.96) 94.4,42.92 94.8,42.52 94.8,40.75 94.24,40.19 94.1,40.19 93.6,39.69
  IN1 w0.147: 93.6,39.69 93.31,39.4 93.31,38.64 92.02,37.35 92.02,36.47 91.91,36.35 91.62,36.35 91.49,36.23 91.49,35.89 91.62,35.77 91.91,35.77 92.06,35.62 92.06,35.32 91.91,35.18 91.53,35.18 91.38,35.03 91.38,34.27 92.71,32.95 92.71,27.37 97.27,22.81 106.01,22.81 106.56,22.26 108.13,22.26 111.07,19.32 119.3,19.32 120.12,18.49 134.85,18.49 135.26,18.9 135.47,18.9 135.82,18.55 136,18.55 136.24,18.79 136.24,18.97 135.89,19.32 135.89,19.52 136.1,19.73 136.3,19.73 136.65,19.38 136.83,19.38 137.07,19.62 137.07,19.8 136.72,20.15 136.72,20.36 136.99,20.63 v1(137.1,20.63)
  BOTTOM w0.14: JDIMM2.7 135.88,22.3 136.99,21.18 136.99,20.73 v1(137.1,20.63)
DDR_A_D6: length 72.8
  TOP w0.089: JCPU1.C2 98.9,43.42 98.4,42.92 v1(98.4,42.96)
  TOP w0.14: v1(141.67,23.95) 141.58,24.04 141.58,24.55 141.73,24.7 JDIMM1.15
  IN1 w0.089: v1(98.4,42.96) 98.4,42.74 98.8,42.34 98.8,41.19 98.23,40.62 98.23,39.69
  IN1 w0.147: v1(141.67,23.95) 141.67,24.94 141.54,25.07 141.01,25.07 140.88,24.94 140.88,24.53 140.75,24.4 140.27,24.4 140.14,24.53 140.14,25.03 140.02,25.15 139.6,25.15 139.48,25.03 139.48,24.53 139.35,24.4 136.35,24.4 134.63,22.68 131.25,22.68 130.71,22.14 126.2,22.14 125.65,22.68 112.44,22.68 108.63,26.49 98.39,26.49 96,28.87 96,34.84 96.22,35.06 96.22,37.17 98.23,39.18 98.23,39.69
  BOTTOM w0.14: v1(141.67,23.95) 141.78,24.06 141.78,24.69 142.09,25 JDIMM2.16
DDR_A_D7: length 75.9
  TOP w0.089: v5(97.42,42.96) 97.4,42.93 97.4,42.92 97.9,43.42 JCPU1.C3
  TOP w0.14: JDIMM1.17 140.94,25.3 140.31,24.67 140.31,24.11 v1(140.15,23.95)
  IN1 w0.089: v5(97.42,42.96) 97.4,42.93 97.4,40.68 97,40.28 97,39.69
  IN1 w0.147: 97,39.69 97,39.55 95.09,37.64 95.09,35.67 94.87,35.45 94.87,28.27 97.78,25.36 106.19,25.36 106.89,24.66 108.24,24.66 108.71,24.19 109.33,24.19 112.28,21.25 122.05,21.25 122.29,21.01 132.58,21.01 133.12,21.55 133.58,21.55 133.83,21.3 133.83,21.12 133.98,20.97 134.6,20.97 136.36,22.73 137.31,22.73 137.67,23.09 139.16,23.09 139.29,23.22 139.29,23.36 139.42,23.49 139.76,23.49 139.89,23.36 139.89,23.19 139.99,23.09 140.36,23.09 140.47,23.2 140.47,23.82 140.34,23.95 v1(140.15,23.95)
  BOTTOM w0.14: v1(140.15,23.95) 140.2,24 140.2,24.52 141.29,25.6 JDIMM2.18
DDR_A_D8: length 83.2
  TOP w0.089: JCPU1.F10 90.9,46.42 90.4,45.92 v3(90.4,45.93)
  TOP w0.14: JDIMM1.22 135.86,26.8 136.98,25.68 138.05,25.68 138.42,26.06 v1(138.42,26.18)
  IN1 w0.089: 98.69,39.69 98.69,40.5 99.48,41.29 99.48,42.29 98.92,42.85 98.92,43.99 98.57,44.35 92.43,44.35 91.88,44.9 91.88,45.03 91.5,45.4 90.5,45.4 90.37,45.53 90.37,45.9 v3(90.4,45.93)
  IN1 w0.147: 98.69,39.69 98.69,38.99 96.67,36.98 96.67,34.85 96.45,34.63 96.45,29.06 98.57,26.94 108.92,26.94 112.72,23.13 125.84,23.13 126.39,22.59 130.52,22.59 131.07,23.13 134.44,23.13 136.16,24.85 138.9,24.85 139.03,24.98 139.03,25.6 138.9,25.73 138.83,25.73 138.42,26.14 v1(138.42,26.18)
  BOTTOM w0.14: v1(138.42,26.18) 138.42,25.92 138.02,25.51 136.89,25.51 135.91,26.5 JDIMM2.21
DDR_A_D9: length 79.4
  TOP w0.089: JCPU1.F8 92.9,46.42 92.4,45.92 v3(92.4,45.93)
  TOP w0.14: v1(137.15,26.18) 137.15,26.34 136.1,27.4 JDIMM1.24
  IN1 w0.089: 99.73,41.04 99.81,41.12 99.81,43.36 98.63,44.54 94.24,44.54 93.8,44.97 93.8,45.1 93.54,45.36 92.97,45.36 v3(92.4,45.93)
  IN1 w0.147: v1(137.15,26.18) 137.11,26.18 136.98,26.05 136.98,25.83 137.11,25.71 138.33,25.71 138.46,25.58 138.46,25.35 138.33,25.23 136,25.23 135.09,24.31 134.33,24.31 134.21,24.18 134.21,23.64 134.08,23.51 130.81,23.51 130.26,22.96 126.59,22.96 126.32,23.23 126.32,23.34 126.15,23.51 112.88,23.51 108.93,27.45 98.61,27.45 96.83,29.23 96.83,34.43 97.05,34.65 97.05,36.82 99.06,38.84 99.06,39.15 99.19,39.28 99.5,39.28 99.63,39.4 99.63,39.76 99.5,39.89 99.11,39.89 98.98,40.02 98.98,40.46 99.11,40.59 99.6,40.59 99.73,40.71 99.73,41.04
  BOTTOM w0.14: JDIMM2.23 136.39,27.1 136.73,26.76 136.73,26.48 137.03,26.18 v1(137.15,26.18)
DDR_A_D10: length 81.4
  TOP w0.089: JCPU1.G10 90.9,47.42 v1(90.4,46.92)
  TOP w0.14: JDIMM1.33 141.41,30.1 141,29.69 v1(141,29.23)
  IN1 w0.089: 103.29,39.69 103.29,40.29 102.52,41.06 102.52,42.97 100.98,44.51 100.98,45.18 100.64,45.52 100.24,45.52 99.99,45.77 99.99,46.42 99.81,46.6 99.81,47.07 99.57,47.32 98.32,47.32 98.13,47.51 97.25,47.51 96.67,48.09 96.05,48.09 95.64,48.5 93.41,48.5 92.98,48.07 92.98,47.93 92.48,47.43 90.91,47.43 v1(90.4,46.92)
  IN1 w0.147: v1(141,29.23) 142.34,29.23 142.47,29.35 142.47,33.21 142.34,33.34 141.93,33.34 141.8,33.21 141.8,30.19 141.67,30.06 136.51,30.06 133.91,27.46 132.37,27.46 131.99,27.84 125.67,27.84 125.29,27.46 116.01,27.46 115.51,27.97 112.88,27.97 108.6,32.25 108.6,34.3 103.29,39.61 103.29,39.69
  BOTTOM w0.14: v1(141,29.23) 141,29.41 141.99,30.4 JDIMM2.34
DDR_A_D11: length 82.4
  TOP w0.089: v3(91.4,46.92) 91.9,47.42 JCPU1.G9
  TOP w0.14: JDIMM1.35 140.59,30.7 139.73,29.84 v1(139.73,29.23)
  IN1 w0.089: v3(91.4,46.92) 91.4,46.77 91.66,46.52 92.66,46.52 93.48,47.34 96.61,47.34 96.81,47.14 96.81,46.69 97.19,46.32 97.45,46.32 98.24,45.53 99.01,45.53 99.83,44.71 99.83,44.7 100.55,43.97 100.76,43.97 101.98,42.76 101.98,39.69
  IN1 w0.147: v1(139.73,29.23) 139.8,29.23 139.93,29.1 139.93,28.89 139.8,28.77 136.81,28.77 134.38,26.34 132.18,26.34 131.98,26.13 131.74,26.13 131.61,26.26 131.61,26.5 131.48,26.62 131.19,26.62 131.06,26.5 131.06,25.72 130.93,25.59 129.41,25.59 128.9,26.1 127.27,26.1 127.05,25.89 125.74,25.89 125.53,26.1 125.11,26.1 124.46,25.45 117.62,25.45 116.97,26.11 114.57,26.11 114.42,25.96 114.42,25.57 114.29,25.44 113.96,25.44 113.83,25.57 113.83,25.96 113.68,26.11 113.14,26.11 109.87,29.39 100.99,29.39 100.33,30.05 100.33,32.76 99.92,33.17 99.92,36.92 101.98,38.98 101.98,39.69
  BOTTOM w0.14: JDIMM2.36 141.93,31 141.22,30.29 140.49,30.29 139.73,29.54 v1(139.73,29.23)
DDR_A_D12: length 80.1
  TOP w0.089: v1(91.4,45.93) 91.4,45.92 91.9,46.42 JCPU1.F9
  TOP w0.14: v1(141.09,26.18) 141.42,26.5 JDIMM1.21
  IN1 w0.089: v1(91.4,45.93) 91.41,45.93 91.81,46.33 93.57,46.33 93.97,45.93 93.97,45.69 94.14,45.52 96.73,45.52 97.34,44.92 98.75,44.92 100.27,43.4 100.53,43.4 100.8,43.13 100.8,42.77 100.54,42.51 100.54,39.69
  IN1 w0.147: v1(141.09,26.18) 141.41,26.18 141.76,26.52 141.76,26.9 141.63,27.03 136.74,27.03 134.87,25.16 132.67,25.16 131.93,24.41 128.08,24.41 127.78,24.71 127.09,24.71 126.64,24.26 113.19,24.26 109.24,28.21 98.93,28.21 97.58,29.56 97.58,32.49 98.74,33.65 98.74,37.41 100.54,39.21 100.54,39.69
  BOTTOM w0.14: JDIMM2.22 141.71,26.8 v1(141.09,26.18)
DDR_A_D13: length 80.4
  TOP w0.089: v1(93.4,45.93) 93.4,45.92 93.9,46.42 JCPU1.F7
  TOP w0.14: JDIMM1.23 141.74,27.1 141.55,26.91 140.4,26.91 139.69,26.21 v1(139.69,26.18)
  IN1 w0.089: 100,39.69 100,43.42 98.72,44.7 98.68,44.71 97.29,44.71 96.66,45.34 93.99,45.34 v1(93.4,45.93)
  IN1 w0.147: 100,39.69 100,39.25 97.42,36.67 97.42,34.46 97.2,34.24 97.2,29.39 98.76,27.83 109.09,27.83 113.03,23.89 126.8,23.89 127.24,24.33 127.63,24.33 127.86,24.1 127.86,23.47 127.99,23.34 128.33,23.34 128.46,23.47 128.46,23.91 128.59,24.03 128.98,24.03 129.11,23.91 129.11,23.47 129.24,23.34 129.57,23.34 129.7,23.47 129.7,23.74 129.85,23.89 133.7,23.89 133.83,24.01 133.83,24.6 133.96,24.72 134.97,24.72 136.89,26.65 139.57,26.65 139.69,26.52 v1(139.69,26.18)
  BOTTOM w0.14: v1(139.69,26.18) 139.69,26.22 140.16,26.68 141.03,26.68 141.75,27.4 JDIMM2.24
DDR_A_D14: length 79.9
  TOP w0.089: v1(92.4,46.92) 92.9,47.42 JCPU1.G8
  TOP w0.14: JDIMM1.34 135.71,30.4 136.31,29.81 137.12,29.81 137.19,29.74 v1(137.19,29.23)
  IN1 w0.089: 102.54,39.69 102.54,40.36 102.16,40.73 102.16,42.82 100.83,44.16 100.61,44.16 100,44.77 100,44.79 98.9,45.89 98.9,46.25 98.82,46.33 97.83,46.33 97.65,46.51 97.25,46.51 97,46.75 97,47.23 96.72,47.52 92.82,47.52 92.4,47.1 v1(92.4,46.92)
  IN1 w0.147: v1(137.19,29.23) 136.74,29.23 134.22,26.71 131.93,26.71 131.8,26.84 131.8,26.97 131.68,27.09 130.28,27.09 130.15,26.97 130.15,26.09 130.02,25.96 129.66,25.96 129.53,26.09 129.53,26.38 129.38,26.53 127.58,26.53 127.19,26.92 126.81,26.92 126.36,26.47 124.95,26.47 124.31,25.83 119.93,25.83 119.81,25.96 119.81,26.27 119.54,26.54 119.03,26.54 118.9,26.41 118.9,25.96 118.77,25.83 117.78,25.83 117.12,26.48 113.3,26.48 110.02,29.76 108.3,29.76 108.18,29.89 108.18,31.07 108.05,31.2 107.59,31.2 107.47,31.07 107.47,29.89 107.34,29.76 102.56,29.76 100.73,31.59 100.73,33.73 100.29,34.17 100.29,35.17 100.42,35.29 101.2,35.29 101.33,35.42 101.33,35.87 101.2,36 100.56,36 100.43,36.13 100.43,36.73 100.56,36.86 101.49,36.86 101.62,36.98 101.62,38.09 102.54,39.01 102.54,39.69
  BOTTOM w0.14: v1(137.19,29.23) 137.31,29.35 137.31,29.66 137.15,29.82 136.18,29.82 135.9,30.1 JDIMM2.33
DDR_A_D15: length 80.8
  TOP w0.089: v3(93.4,47.92) 93.43,47.92 JCPU1.G7
  TOP w0.14: v1(138.46,29.23) 138.46,29.41 137.69,30.18 136.63,30.18 135.8,31 JDIMM1.36
  IN1 w0.089: 102.91,39.69 102.91,40.27 102.34,40.84 102.34,42.9 100.8,44.44 100.8,45.1 100.56,45.34 100.17,45.34 99.81,45.7 99.81,46.27 99.58,46.51 98.25,46.51 98,46.75 98,46.89 97.57,47.32 97.17,47.32 96.58,47.91 95.98,47.91 95.57,48.32 93.82,48.32 93.43,47.92 v3(93.4,47.92)
  IN1 w0.147: 102.91,39.69 102.91,39.45 108.22,34.14 108.22,31.56 108.35,31.43 108.88,31.43 109.01,31.31 109.01,30.94 108.88,30.81 108.69,30.81 108.56,30.68 108.56,30.26 108.69,30.14 110.18,30.14 112.73,27.58 112.93,27.58 113.06,27.46 113.06,27.25 113.19,27.13 113.56,27.13 113.69,27.25 113.69,27.46 113.82,27.59 114.17,27.59 114.3,27.46 114.3,26.99 114.43,26.86 114.76,26.86 114.89,26.99 114.89,27.46 115.02,27.58 115.36,27.58 115.49,27.46 115.49,27.02 115.64,26.86 117.72,26.86 117.84,26.73 117.84,26.33 117.97,26.2 118.4,26.2 118.52,26.33 118.52,26.96 118.65,27.09 119.82,27.09 119.94,26.96 119.94,26.67 120.07,26.55 120.41,26.55 120.54,26.67 120.54,26.96 120.66,27.09 120.97,27.09 121.09,26.96 121.09,26.53 121.22,26.4 121.51,26.4 121.64,26.53 121.64,26.96 121.77,27.09 122.31,27.09 122.44,26.96 122.44,26.58 122.49,26.53 122.49,26.33 122.61,26.2 123.22,26.2 123.35,26.33 123.35,26.96 123.48,27.09 123.75,27.09 123.88,26.96 123.88,26.46 124.01,26.33 124.28,26.33 124.41,26.46 124.41,26.96 124.53,27.09 124.77,27.09 125.01,26.85 126.2,26.85 126.33,26.98 126.33,27.34 126.46,27.47 127.58,27.47 127.73,27.32 127.73,27.04 127.85,26.91 128.19,26.91 128.31,27.04 128.31,27.32 128.46,27.47 128.76,27.47 128.9,27.32 128.9,27.04 129.03,26.91 129.37,26.91 129.49,27.04 129.49,27.32 129.64,27.47 131.83,27.47 132.21,27.09 134.07,27.09 136.67,29.69 138.53,29.69 138.66,29.56 138.66,29.35 138.53,29.23 v1(138.46,29.23)
  BOTTOM w0.14: v1(138.46,29.23) 138.46,29.41 137.68,30.19 136.47,30.19 135.96,30.7 JDIMM2.35
DDR_A_D16: length 69.8
  TOP w0.089: v1(96.4,49.93) 96.4,49.92 96.9,50.42 JCPU1.K4
  TOP w0.14: JDIMM1.40 135.78,32.2 136.37,31.61 136.37,31.12 136.87,30.62 137.96,30.62 138.23,30.89 v1(138.23,31.35)
  IN1 w0.089: 104.49,40.64 103.23,41.9 103.23,43.27 101.69,44.81 101.69,46.73 100.75,47.67 100.22,47.67 99.81,48.08 98.67,48.08 97.99,48.76 97.99,49.16 97.65,49.51 97.26,49.51 96.85,49.92 96.41,49.92 v1(96.4,49.93)
  IN1 w0.147: 104.49,40.64 110.18,34.95 110.18,32.9 112.86,30.22 118.61,30.22 119.02,29.82 122.09,29.82 122.69,29.21 124.8,29.21 125.01,29.42 129.24,29.42 129.8,29.99 131.93,29.99 132.41,29.51 133.72,29.51 136.06,31.84 137.95,31.84 138.34,32.24 139.9,32.24 140.03,32.11 140.03,31.93 139.9,31.8 138.68,31.8 138.23,31.35 v1(138.23,31.35)
  BOTTOM w0.14: v1(138.23,31.35) 138.23,30.89 137.97,30.63 136.89,30.63 136.33,31.19 136.33,31.66 136.09,31.9 JDIMM2.39
DDR_A_D17: length 68.8
  TOP w0.089: v3(95.4,49.93) 95.4,49.92 95.9,50.42 JCPU1.K5
  TOP w0.14: JDIMM1.42 135.92,32.8 136.96,31.76 v1(136.96,31.35)
  IN1 w0.089: v3(95.4,49.93) 95.4,50.02 95.28,50.15 95.06,50.15 94.94,50.02 94.94,49.44 95.06,49.31 95.56,49.31 95.78,49.53 96.99,49.53 97.19,49.32 97.57,49.32 97.8,49.08 97.8,48.68 98.6,47.89 99.75,47.89 100.15,47.5 100.67,47.5 101.51,46.66 101.51,44.73 103.05,43.19 103.05,41.54 104.49,40.1
  IN1 w0.147: 104.49,40.1 109.8,34.8 109.8,32.75 112.7,29.85 113.47,29.85 113.61,29.7 113.61,29.3 113.74,29.18 114.08,29.18 114.2,29.3 114.2,29.7 114.35,29.85 114.65,29.85 114.79,29.7 114.79,29.3 114.92,29.18 115.26,29.18 115.38,29.3 115.38,29.7 115.53,29.85 115.82,29.85 115.97,29.7 115.97,29.22 116.1,29.09 116.43,29.09 116.56,29.22 116.56,29.7 116.71,29.85 117,29.85 117.15,29.7 117.15,29.2 117.28,29.07 117.61,29.07 117.74,29.2 117.74,29.7 117.89,29.85 118.45,29.85 118.61,29.68 118.61,29.5 118.67,29.44 121.44,29.44 121.57,29.31 121.57,28.84 121.69,28.72 124.84,28.72 125.17,29.05 130.33,29.05 130.48,29.2 130.48,29.48 130.6,29.61 130.94,29.61 131.06,29.48 131.06,29.2 131.21,29.05 131.99,29.05 132.07,29.12 133.87,29.12 136.09,31.35 v1(136.96,31.35)
  BOTTOM w0.14: v1(136.96,31.35) 136.96,31.87 136.33,32.5 JDIMM2.41
DDR_A_D18: length 64.6
  TOP w0.089: JCPU1.K1 99.9,50.42 v1(100.4,49.92)
  TOP w0.14: v1(140.8,34.75) 141.55,35.5 JDIMM1.51
  IN1 w0.089: 104.49,42.3 103.8,42.99 103.8,43.53 102.26,45.07 102.26,47.05 100.84,48.48 100.28,48.48 100,48.76 100,49.51 v1(100.4,49.92)
  IN1 w0.147: 104.49,42.3 111.36,35.44 111.36,33.41 112.69,32.07 114.58,32.07 115.25,31.4 118.62,31.4 118.98,31.77 119.43,31.77 120.2,31 122.57,31 123.16,30.41 124.33,30.41 124.52,30.6 128.75,30.6 129.81,31.66 134.21,31.66 135.57,33.02 137.46,33.02 138.35,33.92 139.89,33.92 140.07,34.1 141.97,34.1 142.09,34.23 142.09,35.15 141.97,35.28 140.71,35.28 140.6,35.16 140.6,34.87 140.73,34.75 v1(140.8,34.75)
  BOTTOM w0.14: JDIMM2.50 141.67,35.2 141.5,35.03 141.5,34.82 141.43,34.75 v1(140.8,34.75)
DDR_A_D19: length 65.5
  TOP w0.089: JCPU1.J1 99.9,49.42 100.4,48.91 v3(100.4,48.92)
  TOP w0.14: JDIMM1.53 141.53,36.1 140.94,35.52 139.7,35.52 139.53,35.34 v1(139.53,34.75)
  IN1 w0.089: v3(100.4,48.92) 100.4,48.77 100.52,48.65 100.69,48.65 100.8,48.77 100.8,50.02 100.93,50.15 101.08,50.15 101.19,50.03 101.19,48.37 102.44,47.12 102.44,45.15 103.98,43.61 103.98,43.35 104.49,42.84
  IN1 w0.147: 104.49,42.84 111.73,35.6 111.73,33.57 112.85,32.45 114.74,32.45 115.41,31.78 118.46,31.78 118.82,32.14 119.59,32.14 120.34,31.39 124.06,31.39 124.19,31.27 124.19,31.13 124.32,31 124.75,31 124.88,31.13 124.88,31.27 125,31.39 125.44,31.39 125.59,31.24 125.59,31.11 125.72,30.98 126.05,30.98 126.18,31.11 126.18,31.24 126.33,31.39 126.73,31.39 126.86,31.27 126.86,31.26 126.87,31.25 126.87,31.11 126.99,30.98 127.38,30.98 127.5,31.11 127.5,31.26 127.63,31.39 127.97,31.39 128.09,31.26 128.09,31.11 128.22,30.98 128.6,30.98 129.65,32.04 134.05,32.04 135.41,33.4 137.29,33.4 138.18,34.29 139.43,34.29 139.53,34.39 v1(139.53,34.75)
  BOTTOM w0.14: JDIMM2.52 141.74,35.8 141.6,35.66 139.65,35.66 139.47,35.48 139.47,34.81 v1(139.53,34.75)
