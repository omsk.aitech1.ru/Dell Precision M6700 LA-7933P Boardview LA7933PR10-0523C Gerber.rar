# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_RAS#: length 90.5
  TOP w0.089: v1(92.4,61.92) 92.9,62.42 JCPU1.AB8
  TOP w0.102: v1(152.35,55.12) 152.35,54.73 152.35,54.63 152.27,54.55 152.27,54.12 152.16,54 151.99,54 151.88,54.12 151.88,54.55 151.75,54.68 151.57,54.68 151.47,54.57 151.47,54.36 151.35,54.24 151.19,54.24 151.08,54.36 151.08,54.57 150.97,54.68 150.76,54.68 150.37,55.07 150.37,55.33 150.1,55.6 JDIMM3.110
  IN3 w0.089: 104.49,66.27 102.69,66.27 102.14,65.72 101.39,65.72 101.23,65.56 99.2,65.56 98.7,65.06 98.7,64.37 97.99,63.66 97.99,62.56 97.76,62.33 97.13,62.33 97,62.2 97,60.65 96.88,60.52 93.11,60.52 92.99,60.65 92.99,62.21 92.86,62.34 92.53,62.34 92.4,62.21 v1(92.4,61.92)
  IN3 w0.229: 104.49,66.27 110.39,66.27 112.9,63.75 114.41,63.75 114.54,63.63 114.54,62.56 114.67,62.43 115.33,62.43 115.46,62.56 115.46,63.63 115.58,63.75 116.24,63.75 116.37,63.63 116.37,62.56 116.5,62.43 117.16,62.43 117.28,62.56 117.28,63.63 117.41,63.75 117.79,63.75 123.89,57.66 126.25,57.66 126.75,57.16 126.75,56.79 126.88,56.67 129.76,56.67 129.89,56.79 129.89,57.17 130.01,57.29 130.68,57.29 130.8,57.17 130.8,56.79 130.93,56.67 131.59,56.67 131.72,56.79 131.72,57.09 131.84,57.21 141.78,57.21 141.91,57.09 141.91,56.54 142.04,56.41 145.57,56.41 145.87,56.11 145.87,55.79 146,55.66 151.74,55.66 152.29,55.12 v1(152.35,55.12)
  BOTTOM w0.102: v1(152.35,55.12) 152.35,55.12 152.82,55.59 153.3,55.59 154.27,56.55 155.52,56.55 156.47,55.6 JDIMM4.110
DDR_B_WE#: length 93.4
  TOP w0.089: JCPU1.AB9 91.9,62.46 v5(91.4,62.96)
  TOP w0.102: v1(155.53,57.44) 155.09,57.01 153.48,57.01 153.35,56.88 153.35,56.63 153.48,56.5 JDIMM3.113
  IN3 w0.089: v5(91.4,62.96) 91.4,63.37 91.53,63.5 94.64,63.5 94.81,63.33 96.39,63.33 97.81,64.76 97.81,65.43 98.9,66.51 100.09,66.51 101.2,67.63 101.33,67.63 102.26,68.55 104.49,68.55
  IN3 w0.229: v1(155.53,57.44) 158.8,57.44 158.93,57.57 158.93,57.82 158.8,57.95 147.73,57.95 146.32,59.36 143.69,59.36 142.76,60.29 135.76,60.29 134.48,61.57 133.46,61.57 132.89,61 131.73,61 131.17,61.57 129.96,61.57 129.5,62.03 127.14,62.03 126.59,62.58 122.21,62.58 117.66,67.12 114.44,67.12 113.01,68.55 104.49,68.55
  BOTTOM w0.102: JDIMM4.113 153.63,56.5 154.11,56.99 155.07,56.99 v1(155.53,57.44)
DDR_CKE0_DIMM2: length 68.2
  TOP w0.089: JCPU1.V9 91.9,58.37 91.44,57.92 91.43,57.91 91.46,57.91 91.45,57.91 v3(91.42,57.91)
  IN1 w0.089: v3(91.42,57.91) 91.42,57.58 91.82,57.18 91.82,56.72 91.99,56.55 91.99,55.77 92.27,55.49 93.41,55.49 93.58,55.32 95.57,55.32 96.13,54.76 100.63,54.76 104.34,51.05 104.34,50.89 104.49,50.74
  IN1 w0.178: v1(141.07,43.23) 141.07,43.11 140.64,42.69 140.64,41.79 140.37,41.51 136.16,41.51 133.75,39.1 122.11,39.1 121.57,39.65 118.87,39.65 118.41,40.11 115.13,40.11 104.66,50.57 104.49,50.74
  BOTTOM w0.102: JDIMM2.73 135.79,44.5 136.49,43.8 140.5,43.8 v1(141.07,43.23)
DDR_CKE1_DIMM2: length 67.1
  TOP w0.089: JCPU1.V10 90.87,58.45 v1(90.34,57.92)
  IN1 w0.089: 104.49,51.77 104.13,51.77 100.78,55.12 96.38,55.12 95.81,55.69 95.81,56.08 95.55,56.34 93.97,56.34 93.81,56.49 93.07,56.49 92.84,56.72 92.84,57.08 92.53,57.39 92.18,57.39 92.01,57.56 92.01,58.19 91.66,58.54 90.96,58.54 v1(90.34,57.92)
  IN1 w0.178: 104.49,51.77 104.83,51.77 115.53,41.07 121.51,41.07 121.88,40.7 122.41,40.7 122.58,40.53 122.58,40.35 122.76,40.18 123.12,40.18 123.3,40.35 123.3,40.53 123.47,40.7 126.45,40.7 126.63,40.53 126.63,40.25 126.81,40.07 127.16,40.07 127.34,40.25 127.34,40.53 127.52,40.7 127.88,40.7 128.05,40.53 128.05,40.25 128.23,40.07 128.59,40.07 128.76,40.25 128.76,40.53 128.94,40.7 133.99,40.7 135.76,42.48 137.89,42.48 138.53,43.11 v1(138.53,43.22)
  BOTTOM w0.102: v1(138.53,43.22) 138.96,42.79 141.23,42.79 141.81,43.36 141.81,44.53 142.08,44.8 JDIMM2.74
DDR_CKE2_DIMM4: length 91.8
  TOP w0.089: JCPU1.R9 91.9,55.44 v3(91.41,54.95)
  IN3 w0.089: 104.49,54.41 104.23,54.41 103.7,53.88 101.61,53.88 100.79,54.7 96.04,54.7 95.67,54.33 92.92,54.33 92.81,54.44 92.81,55.08 92.57,55.32 92.05,55.32 91.93,55.45 91.1,55.45 90.97,55.32 90.97,55.08 91.1,54.95 v3(91.41,54.95)
  IN3 w0.152: v1(150.77,43.15) 150.76,43.17 150.56,43.17 150.43,43.04 150.43,42.81 150.3,42.68 149.93,42.68 149.81,42.81 149.81,43.04 149.68,43.17 149.34,43.17 149.21,43.04 149.21,42.49 149.08,42.36 148.7,42.36 148.58,42.49 148.58,43.04 148.45,43.17 148.15,43.17 147.71,42.73 147.71,42.5 148.38,41.84 148.38,41.66 148.04,41.32 147.48,41.32 147.36,41.45 147.36,41.92 147.23,42.05 147.04,42.05 146.84,41.86 145.92,41.86 145.79,41.73 145.79,41.45 145.67,41.32 145.19,41.32 145.07,41.45 145.07,41.73 144.94,41.86 144.31,41.86 144.18,41.73 144.18,41.52 144.06,41.39 143.67,41.39 142.47,40.19 142.39,40.19 142.26,40.06 142.26,39.86 142.14,39.73 141.75,39.73 141.62,39.86 141.62,40.06 141.49,40.19 136.67,40.19 134.27,37.79 129.04,37.79 127.59,36.34 121.65,36.34 121.47,36.51 121.47,37.2 121.33,37.34 120.57,37.34 120.45,37.47 120.45,37.82 120.57,37.95 121.35,37.95 121.47,38.08 121.47,38.43 121.35,38.56 120.25,38.56 120.13,38.43 120.13,38.15 120,38.03 119.66,38.03 119.53,38.15 119.53,39.04 119.66,39.17 121.33,39.17 121.47,39.31 121.47,40.91 121.35,41.03 118.93,41.03 116.47,43.5 116.47,43.62 116.69,43.85 116.69,44.15 116.57,44.28 116.37,44.28 116.24,44.4 116.24,44.6 106.44,54.41 104.49,54.41
  BOTTOM w0.102: JDIMM4.73 150.53,44.5 150.93,44.11 150.93,43.3 v1(150.77,43.15)
DDR_CKE3_DIMM4: length 93.3
  TOP w0.089: JCPU1.R10 90.89,55.45 v1(90.39,54.95)
  IN3 w0.102: v1(90.39,54.95) 90.39,54.34 91.4,53.34 93.64,53.34 93.65,53.34 95.64,53.34 95.99,53.69 95.99,54.11 96.22,54.34 100.64,54.34 101.58,53.41 106.14,53.41 106.37,53.18
  IN3 w0.152: v1(155.35,43.15) 155.17,43.15 155.04,43.28 155.04,45.04 155.17,45.16 157.16,45.16 157.29,45.04 157.29,42.55 157.16,42.42 152.91,42.42 152.78,42.29 152.78,41.9 152.65,41.77 149.78,41.77 148.41,40.4 144.11,40.4 142.52,38.81 136.59,38.81 134.65,36.87 129.42,36.87 127.97,35.42 121.11,35.42 120.56,35.98 120.56,36.3 120.43,36.42 118.74,36.42 118.61,36.55 118.61,40.06 115.3,43.37 115.3,44.25 106.37,53.17 106.37,53.18
  BOTTOM w0.102: v1(155.35,43.15) 155.35,44.22 155.92,44.8 JDIMM4.74
DDR_CKE4_DIMM1: length 65.4
  TOP w0.089: JCPU1.W9 91.9,59.43 v1(91.4,58.94)
  TOP w0.165: v1(137.26,43.22) 137.26,43.24 137.77,43.75 140.82,43.75 141.56,44.5 JDIMM1.73
  IN1 w0.089: 104.49,52.27 103.88,52.27 100.85,55.3 96.45,55.3 95.99,55.76 95.99,56.15 95.62,56.52 94.3,56.52 93.85,56.98 93.85,57.17 93.55,57.47 93.25,57.47 92.91,57.81 92.91,58.09 92.56,58.45 92.04,58.45 91.81,58.67 91.81,59.59 91.68,59.72 90.87,59.72 90.75,59.59 90.75,59.06 90.87,58.94 v1(91.4,58.94)
  IN1 w0.178: 104.49,52.27 104.51,52.25 105.03,52.25 115.73,41.55 115.9,41.55 116.02,41.67 116.02,41.95 116.14,42.08 116.58,42.08 116.71,41.95 116.71,41.68 116.84,41.55 121.71,41.55 122.08,41.19 133.79,41.19 135.77,43.17 136.11,43.17 136.32,42.96 136.58,42.96 136.84,43.22 v1(137.26,43.22)
DDR_CKE5_DIMM1: length 68.6
  TOP w0.089: JCPU1.W10 90.88,59.45 v3(90.37,58.94)
  TOP w0.165: JDIMM1.74 135.7,44.8 136.5,44.01 136.5,43.24 137.01,42.74 139.33,42.74 139.62,43.03 139.62,43.05 v1(139.8,43.22)
  IN1 w0.089: 104.49,51.29 104.36,51.29 100.7,54.94 96.2,54.94 95.64,55.5 94.28,55.5 93.8,55.98 93.8,56.07 93.56,56.31 92.94,56.31 91.83,57.42 91.83,58.12 91.64,58.31 91.26,58.31 90.88,57.93 90.88,57.89 90.51,57.52 90.18,57.52 89.94,57.75 89.94,58.51 v3(90.37,58.94)
  IN1 w0.178: v1(139.8,43.22) 139.63,43.05 139.63,43.02 138.6,41.99 135.96,41.99 133.55,39.59 122.31,39.59 121.31,40.59 115.33,40.59 104.63,51.29 104.49,51.29
DDR_CKE6_DIMM3: length 84.7
  TOP w0.089: v1(91.41,55.93) 91.42,55.93 91.9,56.41 JCPU1.T9
  TOP w0.102: JDIMM3.73 155.9,44.5 154.99,43.59 154.26,43.59 v1(153.82,43.15)
  IN3 w0.089: 104.49,54.88 104.24,54.88 103.58,54.22 101.55,54.22 100.88,54.88 95.97,54.88 95.6,54.51 93.27,54.51 92.99,54.78 92.99,55.19 92.68,55.5 92.13,55.5 92,55.62 92,56.22 91.87,56.35 91.54,56.35 91.41,56.22 v1(91.41,55.93)
  IN3 w0.152: v1(153.82,43.15) 154.02,43.15 154.15,43.28 154.15,43.5 154.02,43.63 147.96,43.63 146.67,42.33 143.95,42.33 142.27,40.65 136.48,40.65 134.08,38.25 128.86,38.25 127.41,36.79 122.15,36.79 121.93,37.01 121.93,41.36 121.8,41.49 121.25,41.49 121.1,41.64 121.1,41.8 120.98,41.92 120.62,41.92 120.49,41.8 120.49,41.64 120.34,41.49 119.12,41.49 118.51,42.1 118.51,42.49 118.39,42.61 118,42.61 117.15,43.46 117.15,44.34 106.61,54.88 104.49,54.88
DDR_CKE7_DIMM3: length 86.3
  TOP w0.089: v3(90.4,55.99) 90.86,56.45 JCPU1.T10
  TOP w0.102: JDIMM3.74 149.95,44.8 151.17,43.58 151.72,43.58 152.15,43.15 v1(152.3,43.15)
  IN3 w0.089: 104.49,53.94 104.26,53.7 101.54,53.7 100.72,54.52 96.14,54.52 95.8,54.18 95.8,53.76 95.56,53.53 93.57,53.53 93.57,53.52 93.24,53.52 92.82,53.93 92.82,54.05 92.55,54.32 91.47,54.32 90.79,55 90.79,55.6 v3(90.4,55.99)
  IN3 w0.152: 104.49,53.94 106.26,53.94 115.78,44.41 115.78,43.54 118.74,40.58 120.89,40.58 121.02,40.45 121.02,39.75 120.89,39.62 119.2,39.62 119.07,39.5 119.07,37.57 119.2,37.44 119.86,37.44 119.99,37.32 119.99,37.01 120.12,36.88 120.89,36.88 121.02,36.75 121.02,36.16 121.3,35.88 127.78,35.88 129.23,37.33 134.46,37.33 136.41,39.27 142.34,39.27 143.93,40.87 148.23,40.87 149.59,42.23 151.96,42.23 152.3,42.57 v1(152.3,43.15)
DDR_CS0_DIMM2#: length 56.9
  TOP w0.089: JCPU1.AK3 97.9,70.42 v1(98.4,69.92)
  IN1 w0.089: v1(98.4,69.92) 98,69.51 98,67.76 98.24,67.52 98.57,67.52 98.91,67.86 98.91,68.26 98.96,68.32 99.68,68.32 100.03,68.67 100.31,68.67 101.09,69.46 101.09,69.97 102.44,71.31 104.49,71.31
  IN1 w0.178: v1(141.36,58.36) 141.19,58.53 141.19,58.55 139.92,59.82 138.38,59.82 137.64,60.56 134.73,60.56 133.31,61.98 131.13,61.98 129.67,63.43 128.23,63.43 120.35,71.31 104.49,71.31
  BOTTOM w0.102: JDIMM2.114 141.99,56.8 141.36,57.43 v1(141.36,58.36)
DDR_CS1_DIMM2#: length 56.2
  TOP w0.089: JCPU1.AL3 97.9,71.42 98.4,70.92 v3(98.4,70.92)
  IN1 w0.089: v3(98.4,70.92) 98.4,70.92 98.4,70.81 97.8,70.21 97.8,67.59 98.05,67.34 99.39,67.34 99.88,67.83 99.88,67.96 100.24,68.32 100.47,68.32 101.44,69.29 101.44,69.31 102.48,70.35 104.49,70.35
  IN1 w0.178: 104.49,70.35 119.95,70.35 127.84,62.46 129.28,62.46 130.95,60.79 131.28,60.79 131.52,60.55 133.38,60.55 134.33,59.59 136.65,59.59 136.91,59.34 137.4,59.34 137.88,58.86 138.34,58.86 138.65,58.55 138.65,58.52 v1(138.82,58.35)
  BOTTOM w0.102: JDIMM2.121 138.75,58.9 138.82,58.83 v1(138.82,58.35)
DDR_CS2_DIMM4#: length 81.9
  TOP w0.089: v3(97.41,64.92) 97.89,64.45 JCPU1.AD3
  IN3 w0.089: v3(97.41,64.92) 97.41,65.28 98,65.86 98,67.08 98.25,67.33 100.64,67.33 101.17,67.86 101.31,67.86 102.5,69.05 104.49,69.05
  IN3 w0.152: v1(159.54,57.91) 159.61,57.84 159.61,57.57 159.74,57.44 160.51,57.44 160.64,57.57 160.64,57.67 160.77,57.8 162.79,57.8 162.91,57.93 162.91,58.92 162.79,59.04 162.51,59.04 162.38,58.92 162.38,58.57 162.25,58.44 147.97,58.44 146.56,59.86 143.89,59.86 142.96,60.79 142.15,60.79 141.69,61.24 135.5,61.24 134.68,62.07 130.17,62.07 129.71,62.52 127.35,62.52 126.8,63.07 122.41,63.07 117.87,67.62 114.65,67.62 113.21,69.05 104.49,69.05
  BOTTOM w0.165: JDIMM4.114 159.25,56.8 159.54,57.09 v1(159.54,57.91)
DDR_CS3_DIMM4#: length 84.8
  TOP w0.089: JCPU1.AE3 97.86,65.45 97.39,65.92 v1(97.41,65.92)
  IN3 w0.089: 104.49,69.5 104.43,69.5 104.21,69.29 104.13,69.29 104,69.42 104,69.56 103.87,69.69 103.69,69.69 103.57,69.56 103.57,69.35 103.46,69.24 103.32,69.24 103.21,69.35 103.21,69.52 103.14,69.6 103.04,69.6 102.94,69.5 102.71,69.5 101.25,68.04 101.1,68.04 100.58,67.52 97.95,67.52 97.82,67.39 97.82,66.52 97.69,66.4 97.29,66.4 97.17,66.27 97.17,66.05 97.29,65.92 v1(97.41,65.92)
  IN3 w0.152: v1(150.75,59.21) 150.75,59.02 150.63,58.9 148.25,58.9 146.84,60.31 144.19,60.31 144.06,60.44 144.06,60.73 143.93,60.86 143.54,60.86 143.01,61.38 142.87,61.38 142.73,61.24 142.34,61.24 142.21,61.37 142.21,61.89 142.08,62.02 141.73,62.02 141.6,61.89 141.6,61.83 141.48,61.7 141.12,61.7 140.99,61.83 140.99,61.89 140.87,62.02 140.51,62.02 140.38,61.89 140.38,61.83 140.26,61.7 139.9,61.7 139.77,61.83 139.77,61.89 139.65,62.02 139.29,62.02 139.16,61.89 139.16,61.83 139.04,61.7 138.68,61.7 138.55,61.83 138.55,61.89 138.43,62.02 138.07,62.02 137.94,61.89 137.94,61.83 137.82,61.7 137.55,61.7 137.43,61.83 137.43,61.89 137.3,62.02 137.06,62.02 136.93,61.89 136.93,61.83 136.8,61.7 136.35,61.7 136.22,61.83 136.22,62.52 136.09,62.64 135.77,62.64 135.65,62.52 135.65,62.32 135.52,62.19 135.2,62.19 135.08,62.32 135.08,62.62 134.82,62.88 134.82,63.81 134.69,63.94 134.26,63.94 134.14,63.81 134.14,63.6 134.31,63.42 134.31,62.65 134.19,62.52 133.81,62.52 133.68,62.65 133.68,63.31 133.55,63.44 133.2,63.44 133.07,63.31 133.07,62.65 132.94,62.52 132.62,62.52 132.5,62.65 132.5,63.31 132.37,63.44 132.03,63.44 131.91,63.31 131.91,62.65 131.78,62.52 131.37,62.52 131.24,62.65 131.24,63.25 131.09,63.4 131.09,63.82 130.96,63.94 130.64,63.94 130.52,63.82 130.52,63.35 130.67,63.2 130.67,62.6 130.59,62.52 130.36,62.52 129.91,62.97 129.91,63.77 129.78,63.89 129.41,63.89 129.29,63.77 129.29,63.11 129.16,62.98 128.76,62.98 128.63,63.11 128.63,63.77 128.51,63.89 128.15,63.89 128.03,63.77 128.03,63.11 127.9,62.98 127.54,62.98 127.41,63.11 127.41,63.75 127.28,63.88 126.97,63.88 126.82,63.73 126.82,63.65 126.69,63.53 126.39,63.53 126.26,63.65 126.26,63.77 126.13,63.89 125.78,63.89 125.65,63.77 125.65,63.65 125.52,63.53 125.19,63.53 125.04,63.68 125.04,64.07 124.91,64.19 124.56,64.19 124.43,64.07 124.43,63.65 124.3,63.53 123.95,63.53 123.82,63.65 123.82,64.29 123.69,64.41 123.34,64.41 123.21,64.29 123.21,63.65 123.09,63.53 122.77,63.53 122.64,63.65 122.64,64.25 122.49,64.4 121.73,64.4 118.06,68.07 114.84,68.07 114.57,68.34 114.57,68.53 114.98,68.94 114.98,69.12 114.73,69.37 114.55,69.37 114.13,68.96 113.95,68.96 113.4,69.5 104.49,69.5
  BOTTOM w0.102: JDIMM4.121 150.15,58.9 150.34,58.71 150.72,58.71 150.85,58.84 150.85,59.11 v1(150.75,59.21)
DDR_CS4_DIMM1#: length 57.7
  TOP w0.089: v3(100.4,67.92) 99.93,67.45 JCPU1.AG1
  TOP w0.102: v1(137.55,58.35) 137.49,58.35 137.37,58.22 137.37,57.8 137.49,57.67 137.78,57.67 137.91,57.54 137.91,57.3 137.78,57.17 137.49,57.17 137.37,57.05 137.37,56.15 137.24,56.03 136.4,56.03 136.27,56.15 136.27,56.67 136.15,56.8 JDIMM1.114
  IN1 w0.089: 104.49,69.86 104.29,69.86 104.21,69.79 104.21,69.63 104.11,69.52 103.96,69.52 103.84,69.64 103.84,70 103.7,70.14 103.56,70.14 103.43,70.01 103.43,69.71 103.31,69.58 103.15,69.58 103.02,69.71 103.02,69.98 102.89,70.11 102.58,70.11 102.45,69.98 102.45,69.83 102.7,69.59 102.7,69.4 102.57,69.28 102.48,69.28 102.35,69.4 102.35,69.4 102.17,69.58 101.99,69.58 101.86,69.45 101.86,69.28 102.66,68.48 102.66,67.93 102.57,67.84 102.38,67.84 102.32,67.91 102.32,68.25 101.57,69 101.41,69 101.3,68.89 101.3,68.73 101.96,68.08 101.96,67.94 101.86,67.84 101.72,67.84 101.12,68.45 100.99,68.45 100.46,67.92 v3(100.4,67.92)
  IN1 w0.178: v1(137.55,58.35) 137.55,58.51 137.2,58.86 136.71,58.86 136.45,59.11 135.5,59.11 135.22,58.83 134.41,58.83 133.63,59.61 131.78,59.61 131.08,60.31 130.74,60.31 129.07,61.98 127.64,61.98 119.75,69.86 104.49,69.86
DDR_CS5_DIMM1#: length 58.8
  TOP w0.089: JCPU1.AH1 99.9,68.46 v3(99.44,68.92)
  TOP w0.102: v1(138.78,60.79) 138.78,60.57 139.37,59.98 140.76,59.98 141.84,58.9 JDIMM1.121
  IN1 w0.089: 104.49,72.28 104.27,72.28 104.06,72.07 102.62,72.07 100.89,70.35 100.01,70.35 99.88,70.22 99.88,69.37 v3(99.44,68.92)
  IN1 w0.178: 104.49,72.28 111.02,72.28 111.2,72.45 111.2,72.64 111.38,72.81 111.73,72.81 111.91,72.64 111.91,72.45 112.09,72.28 112.45,72.28 112.62,72.45 112.62,72.64 112.8,72.81 113.16,72.81 113.33,72.64 113.33,72.45 113.51,72.28 115.28,72.28 115.46,72.45 115.46,72.64 115.64,72.81 115.99,72.81 116.17,72.64 116.17,72.45 116.35,72.28 120.77,72.28 121.01,72.52 121.45,72.52 122.71,71.26 122.71,71.01 122.46,70.75 122.46,70.57 122.78,70.25 122.96,70.25 123.22,70.51 123.47,70.51 124.56,69.41 124.56,69.2 124.28,68.93 124.28,68.75 124.65,68.39 124.83,68.39 125.12,68.68 125.3,68.68 125.69,68.28 125.69,68.1 125.4,67.81 125.4,67.63 125.77,67.27 125.95,67.27 126.24,67.56 126.42,67.56 127.04,66.93 127.04,66.75 126.75,66.46 126.75,66.28 127.08,65.95 127.26,65.95 127.51,66.21 127.76,66.21 128.99,64.98 128.99,64.59 129.19,64.4 130.07,64.4 131.53,62.94 133.71,62.94 135.13,61.52 138.71,61.52 138.92,61.31 138.92,60.93 v1(138.78,60.79)
DDR_CS6_DIMM3#: length 80.4
  TOP w0.089: v5(95.4,64.92) 94.93,64.45 JCPU1.AD6
  TOP w0.102: JDIMM3.114 151.13,56.8 152.7,58.37 153.41,58.37 153.82,58.78 154.38,58.78 v1(154.82,59.21)
  IN3 w0.089: v5(95.4,64.92) 95.4,64.92 95.25,64.92 95.12,65.05 95.12,65.35 95.3,65.53 96.49,65.53 96.62,65.66 96.62,66.33 96.49,66.46 96.12,66.46 95.96,66.62 95.96,67.11 96.28,67.42 96.47,67.42 98,68.95 98,69.08 98.25,69.33 101.58,69.33 103.12,70.88 104.49,70.88
  IN3 w0.152: v1(154.82,59.21) 155.01,59.21 155.28,59.49 155.28,60.3 155,60.58 148.78,60.58 147.07,62.29 144.05,62.29 142.49,63.85 140.57,63.85 140.45,63.97 140.45,64.48 140.32,64.61 139.9,64.61 139.77,64.48 139.77,63.97 139.64,63.85 136.83,63.85 134.89,65.79 133.84,65.79 133.32,65.27 132.32,65.27 131.8,65.79 127.44,65.79 126.92,65.27 125.78,65.27 125.26,65.79 122.28,65.79 117.2,70.87 114.06,70.87 114.05,70.88 104.49,70.88
DDR_CS7_DIMM3#: length 80.7
  TOP w0.089: v1(94.41,64.93) 94.36,64.93 94.87,65.45 JCPU1.AE6
  TOP w0.165: v3(160.41,59.77) 160.41,59.35 159.68,58.62 158.49,58.62 158.21,58.9 JDIMM3.121
  IN3 w0.089: 104.49,72.25 103.19,72.25 101.45,70.51 97.16,70.51 95.82,69.17 95.82,68.78 95.48,68.43 95.35,68.43 94.82,67.91 94.82,65.7 94.41,65.29 v1(94.41,64.93)
  IN3 w0.152: v3(160.41,59.77) 159.95,60.23 159.73,60.23 158,61.96 149.46,61.96 147.76,63.66 144.61,63.66 142.17,66.1 136.59,66.1 135.53,67.16 122.85,67.16 122.25,67.76 117.76,72.25 104.49,72.25
DDR_HVREF_RST: length 73.7
  TOP w0.102: RC25.2 RC26.2 CC68.1 116.35,42.45 QC2.2 116.32,41.81 116.11,41.61 115.21,41.61 110.89,37.29 110.89,24.42 108.46,21.98 108.46,19.47 108.16,19.18 108.16,11.48 108.66,10.99 v1(108.66,10.83) ; QD1.2 125.78,15.45 126.31,15.99 126.31,17.14 v1(126.3,17.15) 126.31,17.17 126.31,19.42 125.78,19.95 QD2.2
  BOTTOM w0.102: v1(108.66,10.83) v2(110.02,12.2) 110.74,12.92 110.74,14.39 113.91,17.56 118.17,17.56 122.6,13.12 122.6,12.38 123.11,11.88 124.83,11.88 126.31,13.36 126.31,17.14 v1(126.3,17.15)
DDR_HVREF_RST_GATE: length 162.6
  TOP w0.102: v1(172.78,140.46) 173.33,141.01 173.33,141.66 173.06,141.92 173.06,143.39 172.57,143.88 U54.A34 ; v1(119.8,40.12) 119.8,40.17 RC26.1 ; v1(172.09,135.8) 171.68,135.39 v2(171.68,131.78) 171.68,130.03 171.87,129.84 171.87,116.05 178.57,109.34 178.57,107.4 177.23,106.06 177.23,103.86 176.94,103.57 176.9,103.57 176.36,103.04 176.36,96.67 176.63,96.41 176.63,93.54 176.4,93.31 v1(176.4,93.28)
  IN1 w0.109: v1(172.09,135.8) 172.12,135.83 172.19,135.83 172.79,136.44 172.79,140.45 v1(172.78,140.46) ; v1(158.79,44.13) 159.7,45.05 159.7,46.8 161.33,48.43 161.33,49.68 164.73,53.09 168.15,53.09 168.74,52.49 169.37,52.49 169.87,53 169.87,60.6 168.71,61.77 168.71,76.03 175.66,82.97 175.66,88.84 176.54,89.72 176.54,93.15 v1(176.4,93.28)
  IN4 w0.109: v1(158.79,44.13) 156.89,42.24 149.87,42.24 146.38,45.73 130.08,45.73 126.59,42.24 121.92,42.24 v1(119.8,40.12)
DDR_HVREF_RST_PCH: length 265.8
  TOP w0.102: v1(107.59,6.29) 107.5,6.38 107.5,6.81 109.1,8.41 109.1,15.99 108.6,16.5 108.6,19 109.04,19.44 109.04,21.89 111.5,24.35 v2(111.5,32.65) 111.5,37.28 115.38,41.15 116.88,41.15 118.36,39.66 120.03,39.66 120.29,39.93 120.29,40.41 119.48,41.22 RC25.1 ; RH300.1 14.95,109.28 v1(15.02,109.21) 15.1,109.28 16.83,109.28 17.45,109.91 UH4.A12
  IN1 w0.109: v1(107.59,6.29) 107.54,6.29 107.34,6.49 106.72,6.49 106.71,6.5 37.36,6.5 36.87,6.01 34.25,6.01 33.53,6.73 28.83,6.73 26.63,8.93 26.63,18.23 26.41,18.44 26.41,23.6 24.4,25.62 24.4,41.76 25.02,42.38 25.96,42.38 26.43,42.85 26.43,43.88 25.72,44.59 25.72,56.44 23.81,58.34 13.26,58.34 12.52,59.08 10.31,59.08 6.87,62.52 6.87,82.59 11.25,86.97 11.25,91.91 11.09,92.08 7.37,92.08 5.56,93.89 5.56,100.38 7.92,102.74 10.41,102.74 11.38,103.71 14.97,103.71 16.57,105.32 16.57,107.66 v1(15.02,109.21)
DDR_ON: length 191.3
  TOP w0.102: v1(171.64,88.58) 171.51,88.58 170.57,89.52 163.32,89.52 160.58,92.27 160.58,101.94 161.3,102.66 161.3,110.14 162.51,111.35 162.51,133.4 162.34,133.57 162.34,136.88 v1(162.49,137.03) ; v1(163.46,144.92) 163.46,144.86 163.03,144.42 162.63,144.42 162.43,144.63 U54.B14
  IN1 w0.109: v1(162.49,137.03) 162.25,137.27 162.25,143.68 163.46,144.88 v1(163.46,144.92)
  IN2 w0.127: v1(171.64,88.58) 171.04,87.99 171.04,63.63 172.13,62.54 178.89,62.54 181.7,59.73 186.95,59.73 187.24,60.02 190.43,60.02 190.54,60.12 198.6,60.12 199.08,59.64 202.79,59.64 204.85,61.7 225.58,61.7 225.69,61.58 230.78,61.58 231.81,62.61 235.37,62.61 235.94,62.04 235.94,58.62 241.45,53.11 241.45,48.11 240.9,47.56 v1(236.56,47.56)
  BOTTOM w0.102: 161.24,143.85 160.6,143.22 160.6,142.2 159.69,141.29 R876.2 ; 161.24,143.85 161.82,144.44 162.99,144.44 163.46,144.91 v1(163.46,144.92) ; 161.24,143.85 v2(161.25,143.85) ; v1(236.56,47.56) PR210.1
DDR_XDP_WAN_SMBCLK: length 341.5
  TOP w0.102: v1(145.13,93.68) 145.2,93.61 145.2,92.72 142.31,89.84 134.71,89.84 133.96,90.59 v1(133.96,90.78) ; R1157.2 v1(109.47,155) ; v1(117.77,115.51) 118.92,114.35 118.92,96.16 119.49,95.59 123.11,95.59 125.92,98.41 R502.2 125.92,99.33 v1(126.1,99.51) 126.31,99.71 126.31,100.39 126.33,100.42 U88.4 ; v1(132.59,84.05) 131.68,83.15 130.71,83.15 RD11.2 ; QH5.1 4.98,107.9 v1(4.53,107.46) ; v1(64.68,114.81) 63.96,114.81 62.46,113.31 RH285.1
  IN3 w0.127: v1(117.77,115.51) 117.21,116.07 116.62,116.07 115.42,114.86 111.21,114.86 110.35,114 96.38,114 96.34,113.96 96.34,113.96 95.83,113.45 95.83,113.45 87.08,104.7 81.29,104.7 77.93,108.06 72.43,108.06 68.11,112.39 68.11,113.53 66.72,114.91 64.88,114.91 64.78,114.81 v1(64.68,114.81) 64.68,114.91 64.48,115.11 64.48,118.51 65.2,119.24 65.2,122.48 66.37,123.65 66.37,130.87 65.72,131.52 65.72,132.5 65.38,132.84 62.42,132.84 62.05,133.21 60.98,133.21 60.62,132.84 57.24,132.84 55.95,134.14 52.07,134.14 50.77,132.84 46.35,132.84 40.79,138.41 40.19,138.41 38.64,139.95 38.64,141.69 37.29,143.05 35.33,143.05 34.64,143.73 34.64,146.5 32.42,148.72 22.25,148.72 21.88,148.35 14.74,148.35 14.13,147.74 v1(14.03,147.74)
  IN4 w0.109: v1(14.03,147.74) 13.77,147.47 11.86,147.47 11.29,146.91 11.29,137.3 8.61,134.62 8.61,134.08 4.65,130.12 4.65,128.9 4.02,128.27 4.02,128.27 3.21,127.46 3.21,122.06 3.08,121.93 3.08,119.63 3.68,119.04 3.68,108.31 v1(4.53,107.46) ; v1(126.1,99.51) 126.66,100.06 127.39,100.06 129.03,98.43 129.03,95.71 v1(133.96,90.78) 132.32,89.14 131.15,89.14 130.41,88.41 130.41,85.18 130.76,84.84 131.87,84.84 132.59,84.12 v1(132.59,84.05)
  BOTTOM w0.102: v1(117.77,115.51) 117.77,115.82 117.96,116.02 119,116.02 119.87,116.89 119.87,118.92 120.27,119.32 120.74,119.32 121.11,119.69 121.43,119.69 121.88,120.13 124.89,120.13 126.03,121.27 126.03,128.95 123.87,131.11 123.87,131.56 123.02,132.41 112.96,132.41 111.01,134.37 110.74,134.37 110.16,134.95 v2(110.16,136.2) 110.16,138.18 111.36,139.38 111.36,146.37 109.88,147.85 109.88,149.76 110.34,150.22 110.34,151.73 111.07,152.46 111.07,154.67 110.29,155.46 109.93,155.46 v1(109.47,155) ; RD40.2 RD31.2 151.99,92.99 150.79,94.2 150.29,94.2 149.87,94.62 147.28,94.62 147.17,94.5 145.96,94.5 v1(145.13,93.68) 145.01,93.55 RD22.2
DDR_XDP_WAN_SMBCLK_R2: length 3.5
  TOP w0.102: JXDP2.53 63.57,109.61 v2(62.64,110.53) 62.46,110.72 RH285.2
DDR_XDP_WAN_SMBDAT: length 358.1
  TOP w0.102: v1(110.11,154.99) 110.11,155 110.6,155.5 110.6,156.44 109.55,157.49 108.03,157.49 R1158.2 ; v1(117.05,115.56) 118.59,114.02 118.59,95.81 119.34,95.06 123.28,95.06 126.74,98.52 126.74,99.45 v1(126.83,99.54) 126.97,99.4 128.52,99.4 128.79,99.67 128.79,100.11 128.66,100.25 R501.2 128.65,102.05 U88.6 ; RH284.1 63.47,113.64 v1(64.12,114.29) ; v1(131.95,84.06) 131.9,84.06 131.21,83.38 130.14,83.38 129.16,82.4 129.16,81.61 RD10.2 ; v1(133.25,90.79) 133.26,90.79 134.5,89.55 142.38,89.55 146.82,93.99 147.05,93.99 147.24,94.18 v1(147.83,94.18)
  TOP w0.127: QH5.4 6.81,106.6 v1(6.74,106.54)
  IN1 w0.109: v1(147.83,94.18) 147.88,94.23 150.25,94.23 150.53,93.96 v1(153.35,93.96)
  IN3 w0.127: v1(14.2,147.02) 14.3,147.02 15.4,148.12 22.17,148.12 22.45,148.4 32.33,148.4 34.33,146.41 34.33,143.69 35.2,142.81 37.11,142.81 38.35,141.57 38.35,139.88 38.39,139.84 38.39,139.84 40.08,138.15 40.69,138.15 46.25,132.59 50.88,132.59 52.17,133.88 55.84,133.88 57.14,132.59 60.72,132.59 61.09,132.96 61.95,132.96 62.31,132.59 65.27,132.59 65.47,132.39 65.47,131.41 66.11,130.77 66.11,123.75 64.95,122.58 64.95,119.34 64.22,118.62 64.22,114.39 v1(64.12,114.29) 64.86,114.29 65.23,114.66 66.62,114.66 67.85,113.42 67.85,112.28 72.32,107.81 77.82,107.81 81.19,104.45 87.19,104.45 96.09,113.34 96.09,113.35 96.44,113.7 110.46,113.7 111.33,114.57 115.53,114.57 116.52,115.56 v1(117.05,115.56)
  IN4 w0.109: v1(131.95,84.06) 131.43,84.58 130.63,84.58 130.12,85.09 130.12,88.79 130.91,89.57 132.28,89.57 133.25,90.54 v1(133.25,90.79) 133.25,91.11 128.78,95.58 128.78,98.34 127.4,99.71 127,99.71 v1(126.83,99.54) ; v1(6.74,106.54) 6.08,106.54 3.94,108.68 3.94,119.14 3.34,119.74 3.34,121.83 3.47,121.95 3.47,127.35 4.28,128.17 4.28,128.17 4.9,128.79 4.9,130.01 8.86,133.97 8.86,134.52 11.54,137.2 11.54,146.8 11.96,147.22 14,147.22 v1(14.2,147.02)
  BOTTOM w0.102: v1(153.35,93.96) 153.69,93.96 154.02,93.62 RD39.2 ; RD21.2 146.02,93.98 146.28,94.23 147.23,94.23 147.28,94.18 v1(147.83,94.18) 147.85,94.21 149.76,94.21 150.6,93.37 RD30.2 ; v1(110.11,154.99) 110.21,154.99 110.81,154.39 110.81,152.53 110.11,151.83 110.11,150.35 109.62,149.86 109.62,147.75 111.11,146.26 111.11,139.64 109.68,138.2 109.68,132.44 109.99,132.12 122.79,132.12 v2(123.2,131.71) 123.62,131.29 123.62,131 125.8,128.82 125.8,121.4 124.79,120.38 121.77,120.38 121.33,119.94 121,119.94 120.64,119.57 120.17,119.57 119.62,119.02 119.62,116.99 119.02,116.4 117.89,116.4 v1(117.05,115.56)
DDR_XDP_WAN_SMBDAT_R2: length 3.3
  TOP w0.102: JXDP2.51 v2(64.06,110.48) 64.06,111.01 RH284.2
DEVICE_DET#: length 341.9
  TOP w0.102: JODD1.8 24.32,27.75 25.58,27.75 25.69,27.86 25.69,28.04 25.26,28.47 25.26,32.72 v1(25.5,32.96) ; U54.A17 162.97,140.84 v2(162.78,140.65) 162.32,140.18 162.32,139.6 162.48,139.43 v1(162.91,139.43) R1125.1
  IN1 w0.109: v1(96.32,158.14) 96.32,157.73 95.97,157.38 95.97,154.56 93.03,151.61 81.72,151.61 77.68,155.65 77.68,161.28 77.9,161.49 77.9,162.07 77.62,162.34 77.2,162.34 75.74,160.88 68.64,160.88 67.89,161.63 v1(66.17,161.63)
  IN2 w0.127: v1(66.17,161.63) 65.68,161.63 65.57,161.75 57.12,161.75 55.98,160.6 48.76,160.6 47.45,159.3 45.27,159.3 43.94,160.63 39.92,160.63 36.39,157.1 30.92,157.1 26.97,153.15 17.73,153.15 14.22,149.64 13.83,149.64 11.33,147.14 11.33,142.13 9.46,140.26 7.97,140.26 7.28,139.57 4.1,139.57 1.31,136.78 1.31,134.26 1.38,134.19 1.38,124.52 2.01,123.9 2.01,123.51 1.33,122.83 1.33,104.92 3.55,102.69 3.55,101.99 1.99,100.43 1.99,85.5 3.28,84.21 3.28,64.17 7.26,60.19 22.55,60.19 26.15,56.59 26.15,47.58 28.42,45.31 28.42,41.29 27.44,40.31 27.44,37.15 26.96,36.67 26.96,34.42 v1(25.5,32.96)
  IN3 w0.127: v1(96.32,158.14) 96.48,158.31 108.81,158.31 110.04,159.54 116.77,159.54 118.87,157.44 118.87,151.68 120.12,150.43 132.69,150.43 134.59,148.53 141.07,148.53 145.01,144.59 150.21,144.59 150.93,143.88 159.31,143.88 159.92,143.27 161.75,143.27 163.32,141.69 163.32,139.84 v1(162.91,139.43)
DF_TVS: length 3.4
  TOP w0.102: RH358.2 v2(37.18,102.13) 37.18,104.45 UH4.AY1
DF_TVS_R: length 2
  TOP w0.102: RH149.2 RH150.2 RH358.1
DGPU_ALERT#: length 85.4
  TOP w0.102: Q5.1 211.96,147.96 212.87,147.05 212.87,124.11 v1(212.61,123.85)
  IN1 w0.109: v1(235.57,85.28) 234.08,85.28 233.15,86.22 231.49,86.22 219.82,97.89 219.82,98.62 219.19,99.25 219.19,99.52 215.8,102.91 215.8,103.05 214.27,104.57 214.27,106.57 212.61,108.23 212.61,110.48 211.4,111.68 211.4,114.31 212.47,115.38 212.47,118.44 212.13,118.78 212.13,123.37 v1(212.61,123.85)
  BOTTOM w0.102: v1(235.57,85.28) v2(236.59,84.27) 236.59,82.4 236.13,81.94 236.13,80.81 236.57,80.37 R788.2 236.57,79.1 236.82,78.85 237.17,78.85 237.5,78.52 237.5,78.25 237.58,78.17 U46.A42
DGPU_HOLD_RST#: length 241.6
  TOP w0.102: v1(22.21,103.44) 22.21,104.51 UH4.K1 ; v1(180.66,123.08) 180.62,123.11 180.62,123.14 180.38,123.38 180.38,128.53 180.71,128.86 180.71,135.72 181.03,136.04 v1(181.03,137.17) ; v1(152.04,98.15) 152.46,98.57 152.46,103.75 152.78,104.07 152.78,120.9 v1(155.05,123.18) ; v1(209.92,138.58) 210.25,138.25 R36.2 210.68,135.65 U16.1
  IN2 w0.102: 22.21,103.19 v1(22.21,103.44)
  IN2 w0.127: 22.21,103.19 22.21,102.63 22.64,102.2 22.64,101.49 23.03,101.1 24.12,101.1 24.85,100.37 27.33,100.37 28.29,99.42 30.3,99.42 30.67,99.05 33.13,99.05 33.69,99.61 38.97,99.61 39.34,99.24 47.5,99.24 48.63,100.37 58.57,100.37 59.51,99.43 63.28,99.43 66.82,95.89 74.21,95.89 75.82,97.5 82.53,97.5 82.81,97.78 108.97,97.78 109.68,97.07 128.83,97.07 131.9,100.14 148.89,100.14 150.44,98.59 151.6,98.59 v1(152.04,98.15)
  BOTTOM w0.102: v1(155.05,123.18) 155.46,123.58 163.66,123.58 164.49,122.76 174.05,122.76 174.37,123.08 v2(178.08,123.08) 180.54,123.08 v1(180.66,123.08) ; v1(181.03,137.17) 181.99,138.13 189.9,138.13 190.3,137.73 203.15,137.73 203.72,138.3 203.72,139.08 203.85,139.21 209.42,139.21 209.92,138.71 v1(209.92,138.58)
DGPU_PEX_RST#: length 11.8
  TOP w0.102: v1(208.7,128.87) 208.7,128.46 208.18,127.94 208.18,125.34 207.36,124.52 JMXM1.184 ; v1(208.6,131.51) 208.72,131.38 R38.2 209.38,131.43 U16.4
  BOTTOM w0.102: v1(208.6,131.51) 209.08,131.03 v2(209.08,130.53) 209.08,129.35 208.7,128.97 v1(208.7,128.87)
DGPU_PWR_EN: length 134.7
  TOP w0.102: JMXM1.44 206.57,161.52 207.16,160.93 v1(207.16,159.77) ; v1(213,159.91) 212.82,160.09 211.9,160.09 211.68,159.87 U8.2
  IN2 w0.127: v1(213,159.91) 212.81,160.1 207.49,160.1 v1(207.16,159.77) 210.08,156.85 210.08,155.45 212.55,152.98 212.55,129.78 211.68,128.91 211.68,117.36 212.42,116.62 212.42,115.05 212.02,114.66 212.02,113.27 212.41,112.89 212.41,106.96 211.67,106.22 211.67,105.44 212.14,104.97 213.4,104.97 218.39,99.98 218.39,98.4 227.57,89.21 228.52,89.21 231.98,85.75 v1(232.29,85.75) 232.61,85.43 234.48,85.43 235.53,84.38 235.53,84.36 238.65,81.24 244.1,81.24 244.45,80.89 244.45,80.33 244.32,80.2 242.16,80.2 241.78,79.82 241.78,78.15 240.42,76.78 239.07,76.78 238.61,76.32 238.61,75.25 238.35,74.99 237.69,74.99 v1(237.25,75.44)
  BOTTOM w0.102: U46.B45 237.83,76.51 237.69,76.38 237.69,75.88 v1(237.25,75.44) ; v1(232.29,85.75) 232.61,85.43 v2(233.6,85.43) 234.53,85.43 236.13,83.83 236.13,83.49 235.44,82.8 235.44,82.51 235.02,82.09 235.02,80.89 R1582.2
DGPU_PWR_GOOD: length 10.2
  TOP w0.102: JMXM1.42 206.65,162.02 206.91,161.76 206.91,161.47 207.4,160.97 207.4,160.36 207.61,160.16 v2(207.61,159.11) 208.51,158.2 R8.2 209.4,158.69 210.48,158.69 210.73,158.43 212.19,158.43 212.33,158.57 U8.1
DGPU_PWROK: length 416.6
  TOP w0.102: v1(242.99,72.24) 242.78,72.45 241.77,72.45 241.25,72.97 v2(238.3,72.97) 236.85,72.97 235.81,71.93 233.25,71.93 233.14,72.05 231.91,72.05 231.32,71.46 229.8,71.46 229.53,71.74 229.53,72.14 229.27,72.39 228.89,72.39 228.07,71.57 226.21,71.57 225.66,71.01 224.63,71.01 223,69.38 v1(222.81,69.38) ; v1(188.34,88.18) 188.36,88.18 188.58,88.39 190.9,88.39 191.24,88.72 191.24,89.41 191.7,89.88 192.67,89.88 193.15,89.4 193.15,88.57 193.36,88.37 193.36,87.64 193.65,87.35 U27.1 ; v1(210.73,155.64) 210.73,156.49 211.03,156.79 U8.4 ; UH4.B41 18.18,124.4 v1(17.37,124.4)
  IN2 w0.102: 18.73,129.35 17.37,127.99 v1(17.37,124.4)
  IN2 w0.127: v1(242.99,72.24) 242.47,72.76 242.47,74.88 243.18,75.59 243.98,75.59 245.17,76.78 245.17,80.49 244.07,81.6 238.99,81.6 238.52,82.07 238.52,82.96 235.49,85.99 233.28,85.99 233.02,86.26 231.79,86.26 228.61,89.44 227.67,89.44 218.62,98.49 218.62,100.07 213.44,105.25 212.51,105.25 v1(212.11,105.64) 212.11,106.31 212.65,106.85 212.65,113.51 v1(212.52,113.64) 212.52,114.26 212.72,114.47 212.72,116.64 211.91,117.45 211.91,128.82 212.77,129.68 212.77,153.08 210.73,155.12 v1(210.73,155.64) ; 18.73,129.35 19.47,130.09 19.47,130.62 20.34,131.5 22.35,131.5 22.76,131.91 28.73,131.91 29.84,133.02 38.07,133.02 38.68,133.63 45.93,133.63 47.86,135.56 48.35,135.56 48.69,135.9 48.69,136.39 49.17,136.86 50.96,136.86 51.64,136.18 52.3,136.18 52.95,135.53 55.14,135.53 55.96,136.35 61.84,136.35 62.46,136.97 63.44,136.97 64.49,135.92 65.85,135.92 66.19,135.57 67.1,135.57 68.97,133.7 68.97,132.82 71.65,130.14 72.12,130.14 73.29,128.97 73.29,120.67 76.27,117.69 79.42,117.69 80.71,118.97 92.21,118.97 95.62,115.57 100.25,115.57 103.31,112.51 104.96,112.51 107.19,110.29 122.71,110.29 123.22,109.78 128.52,109.78 129.33,108.97 131.43,108.97 133.2,107.2 142.43,107.2 144.02,108.79 165.33,108.79 165.99,109.45 168.63,109.45 169.89,108.19 174.36,108.19 177.27,105.29 177.27,100.43 181.75,95.94 181.75,94.98 183.97,92.77 183.97,92.35 187.6,88.71 187.8,88.71 v1(188.34,88.18) 188.7,87.82 188.7,87.71 190.4,86.02 190.4,69.38 191.43,68.35 203.17,68.35 205.21,66.32 213.37,66.32 217.35,70.3 221.89,70.3 v1(222.81,69.38)
  BOTTOM w0.102: v1(212.11,105.64) 212.11,105.44 211.76,105.08 U14.1 ; v1(212.52,113.64) 212.11,113.23 212.11,109.56 211.93,109.38 U25.1 ; U46.A56 242.78,72.45 v1(242.99,72.24)
DGPU_SELECT#: length 389.4
  TOP w0.102: v1(61.4,131.03) 61.4,131.13 60.77,131.76 U13.27 ; v1(83.22,150.5) 83.07,150.34 83.07,143.03 84.39,141.71 84.39,133.35 85.05,132.69 85.05,131.86 85.98,130.94 85.98,129.32 84.26,127.61 82.8,127.61 82.32,128.09 82.32,129.41 81.75,129.99 v1(81.71,129.99) 80.71,129.99 79.71,130.98 U3.1 79.71,132.81 79.68,132.84 79.22,132.84 76.45,130.07 73.56,130.07 73.22,130.42 U11.27
  IN1 w0.109: v1(233.8,73.34) 233.83,73.3 233.83,73.27 234.28,72.82 234.28,69.52 233.83,69.08 v1(233.83,68.96) ; v1(63.79,158.28) 64.18,158.67 65.02,158.67 66.19,157.51 66.19,157.3 66.57,156.92 70.76,156.92 72.19,155.49 76.7,155.49 81.69,150.5 v1(83.22,150.5)
  IN2 w0.127: v1(151.03,116.89) 150.02,115.89 140.69,115.89 139.74,116.84 133.77,116.84 133.29,117.32 133.29,121.61 133.87,122.19 133.87,127.22 133.11,127.98 125.14,127.98 124.81,128.31 120.09,128.31 119.42,127.64 115.86,127.64 113.09,130.4 106.89,130.4 106.62,130.67 104.11,130.67 103.23,131.55 84.86,131.55 83.3,129.99 v1(81.71,129.99) ; v1(181.91,104.5) 182,104.5 182.22,104.28 182.22,103.49 182.85,102.86 183.69,102.86 183.97,102.59 183.97,101.77 184.95,100.78 184.95,99.64 187.27,97.32 187.27,96.84 187.76,96.36 188.05,96.36 189.88,94.53 190.37,94.53 192.54,92.35 192.54,89.78 199.31,83.01 205.12,83.01 205.76,82.37 214.31,82.37 217.12,79.57 217.12,76.15 218.89,74.37 223.14,74.37 223.95,75.18 225.92,75.18 226.08,75.03 227.97,75.03 228.64,75.69 229.7,75.69 230.26,75.13 231.04,75.13 232.8,73.38 233.7,73.38 233.75,73.34 v1(233.8,73.34) ; v1(61.4,131.03) 61.4,131.04 61.87,130.57 64.3,130.57 64.79,130.08 64.79,129.22 65.23,128.78 65.23,128.33 64.67,127.78 64.67,118.21 65.34,117.54 70.48,117.54 72.62,115.41 73.76,115.41 74.04,115.13 86.54,115.13 86.64,115.23 92,115.23 94.37,112.85 99.81,112.85 101.52,111.14 101.52,109.84 102.7,108.66 122.27,108.66 123.59,107.34 130.02,107.34 131.72,105.64 143.91,105.64 144.1,105.83 150.71,105.83 v1(152.31,104.23) 152.44,104.36 152.44,104.76 153.05,105.37 157.02,105.37 157.45,105.8 164.79,105.8 v1(165.35,106.36)
  IN4 w0.109: v1(181.91,104.5) 181.91,104.59 181.58,104.92 179.55,104.92 176.42,108.05 176.12,108.05 175.07,109.09 171.68,109.09 171.37,109.4 169.65,109.4 169.33,109.72 167.19,109.72 165.34,107.86 165.34,106.38 v1(165.35,106.36)
  BOTTOM w0.102: U19.39 62.97,157.71 63.54,158.28 v1(63.79,158.28) ; v1(233.83,68.96) 234.33,68.46 U46.B14 ; v1(152.31,104.23) v2(152.31,113.07) 152.31,115.57 151.03,116.85 v1(151.03,116.89)
DGPU_THERMTRIP#: length 73.1
  TOP w0.102: v2(146.16,168.54) 146.71,167.99 R400.2 147.17,167.48 147.28,167.36 Q115.3 v1(147.28,166.15) ; v1(209.4,156.07) Q4.1 209.73,153.68 R11.2
  IN2 w0.127: v1(209.4,156.07) 209.27,156.07 207.25,158.09 202.06,158.09 196.62,163.53 192.71,163.53 191.68,164.55 174.95,164.55 174.48,165.02 157.39,165.02 156.71,164.34 152.81,164.34 152.12,165.02 148.41,165.02 v1(147.28,166.15)
DH_1.5V: length 10.6
  TOP w0.102: v1(228.88,45.02) v2(228.01,45.02)
  IN3 w1.016: 221.22,40.82 221.22,43 223.2,44.98 227.91,44.98 227.93,44.97
  vias: v1(221.36,40.83) v1(221.36,40.2) v1(228.69,44.39)
DIMM1_SA0: length 27.3
  TOP w0.102: v1(144.7,88.45) 144.7,84.04 145.79,82.95 145.79,81.89 145.6,81.7 JDIMM1.197 ; v1(131.37,88.16) 131.08,88.46 RD12.2 130.09,87.92 128.92,87.92 v2(128.74,88.09) 128.38,88.46 RD8.1
  IN4 w0.109: v1(144.7,88.45) 133.37,88.45 133.08,88.16 v1(131.37,88.16)
DIMM1_SA1: length 19.5
  TOP w0.102: JDIMM1.201 142.26,82.9 141.1,84.06 141.1,85.76 139.23,87.63 133.36,87.63 131.52,89.47 RD13.2 130.62,89.51 130.02,90.11 v2(128.78,90.11) 128.46,90.11 RD9.1
DIMM1_SMBCLK: length 4.8
  TOP w0.102: RD11.1 131.24,82.11 v1(131.58,82.45) 132.33,83.2 133.55,83.2 133.7,83.05 133.83,83.05 133.99,83.2 JDIMM1.202
DIMM1_SMBDAT: length 5.1
  TOP w0.102: JDIMM1.200 133.92,82.6 133.79,82.73 133.59,82.73 133.44,82.88 132.41,82.88 RD10.1
DIMM2_SA0: length 8.3
  BOTTOM w0.102: RD17.1 RD19.2 v2(131.71,77.86) 132.22,78.37 132.22,80.72 133.2,81.7 JDIMM2.197
DIMM2_SA1: length 11.8
  BOTTOM w0.102: JDIMM2.201 132.52,82.9 131.81,82.19 v2(131.81,81.41) 131.81,78.69 130.69,77.57 128.68,77.57 RD20.2 RD18.1
DIMM2_SMBCLK: length 11.4
  BOTTOM w0.102: JDIMM2.202 144.25,83.2 144.44,83.01 145.03,83.01 145.39,83.36 145.39,91.66 RD22.1
DIMM2_SMBDAT: length 11.7
  BOTTOM w0.102: RD21.1 145.62,91.64 145.62,83.27 145.13,82.78 144.42,82.78 144.24,82.6 JDIMM2.200
DIMM3_SA0: length 9
  TOP w0.102: JDIMM3.197 159.98,81.7 160.21,81.47 160.21,80.35 160.49,80.07 RD28.2 161.68,80.07 162.31,79.44 v2(163.55,79.44) 163.84,79.44 RD26.1
DIMM3_SA1: length 12.6
  TOP w0.102: RD27.1 164.47,76.73 164.18,76.44 v2(163.56,76.44) 162.26,76.44 RD29.2 v1(160.91,77.03)
  TOP w0.127: v1(159.61,82.24) 158.95,82.9 JDIMM3.201
  BOTTOM w0.102: v1(160.91,77.03) 160.8,77.03 160.37,77.45 160.37,79.46 159.61,80.22 v1(159.61,82.24)
DIMM3_SMBCLK: length 18.2
  TOP w0.102: JDIMM3.202 147.94,83.2 147.75,83.01 146.88,83.01 145.54,84.35 145.54,91.22 v1(145.77,91.45) 146.51,92.19 149.67,92.19 149.93,92.46 151.17,92.46 v1(151.38,92.24)
  BOTTOM w0.102: RD31.1 151.58,92.05 v1(151.38,92.24)
DIMM3_SMBDAT: length 19.4
  TOP w0.102: v3(151.38,92.88) 151.19,92.69 149.84,92.69 149.57,92.42 146.41,92.42 145.31,91.32 145.31,84.26 146.79,82.79 147.75,82.79 147.94,82.6 JDIMM3.200
  BOTTOM w0.102: v3(151.38,92.88) 151.38,92.86 150.6,92.07 RD30.1
DIMM4_SA0: length 16
  BOTTOM w0.102: v2(146.48,93.89) 146.48,92.44 146.88,92.05 RD35.1 RD37.2 147.94,91.91 147.94,88.68 146.96,87.71 146.96,86.72 146.44,86.2 146.44,82.79 147.53,81.7 JDIMM4.197
DIMM4_SA1: length 11.5
  BOTTOM w0.102: RD36.1 RD38.2 148.82,88.52 147.72,87.43 147.72,83.45 148.28,82.9 JDIMM4.201
DIMM4_SMBCLK: length 12.7
  BOTTOM w0.102: RD40.1 153.06,91.75 158.86,85.95 158.86,83.44 158.62,83.2 JDIMM4.202
DIMM4_SMBDAT: length 13.2
  BOTTOM w0.102: RD39.1 154.02,91.35 159.32,86.06 159.32,83.36 158.56,82.6 JDIMM4.200
DISP_ON: length 36.5
  TOP w0.102: JEDP1.2 66.74,157.43 v1(66.78,157.47) ; 81.58,149.66 v2(81.58,149.64) ; 81.58,149.66 82.76,148.48 82.76,145.61 81.74,144.58 JLVDS1.2 81.74,141.84 82.87,140.71 D64.1 D69.1 D67.1 82.87,136.28 82.24,135.65 82.24,134.91 82.45,134.7 R1138.1 ; 81.58,149.66 81.56,149.68 v1(79.72,149.68)
  IN2 w0.127: v1(79.72,149.68) 79.23,150.17 78.18,150.17 73.15,155.19 73.07,155.19 70.8,157.47 v1(66.78,157.47)
DK_AC_OFF: length 4.5
  TOP w0.127: v2(174.89,79.22) 174.89,77.78 PR1014.1
  TOP w0.254: PR1014.1 175.87,76.81 PU1001.25
DK_AC_OFF_EN: length 5.7
  TOP w0.127: v2(176.92,80.54) 176.92,77.76 177.37,77.31 PR1020.1
  TOP w0.254: PR1020.1 177.37,77.29 PU1001.22
DK_CSS_GC: length 106.3
  TOP w0.254: PR910.2 110.24,117.57 109.87,117.2 109.87,100.83 v2(113.56,97.14) v1(114.96,95.73) ; PU1001.11 180.53,70.68 180.81,70.4 v1(180.82,70.4)
  IN2 w0.254: v1(130.85,96.03) 130.26,95.44 119.57,95.44 119.1,95.91 115.14,95.91 v1(114.96,95.73)
  IN4 w0.254: v1(180.82,70.4) 180.08,70.4 170.86,79.62 170.86,86.41 168.63,88.65 166.11,88.65 166.1,88.65 162.05,88.65 160.22,90.48 136.4,90.48 v1(130.85,96.03)
DK_PWR_BAR: length 2.5
  TOP w0.254: PR1007.2 171.96,72.14 v2(172.69,72.14) 172.92,72.14 173.38,71.68 PU1001.33
DL_1.5V: length 12.5
  IN1 w1.016: 229.02,41.78 229,41.77 229,36.27 227.09,34.35 222.86,34.35
  vias: v1(221.82,34.66) v1(221.82,34.02) v1(229.45,41.97) v1(230.08,41.97) v2(229.58,42.55)
DMI_COMP_R: length 8.2
  TOP w0.102: UH4.BG25 40.57,116.35 41.07,115.85 UH4.BJ24
  TOP w0.254: 42.65,117.92 42.43,117.92 41.84,117.34 41.84,117.03 41.87,117.01 41.87,116.69 41.48,116.31 UH4.BJ24
  TOP w0.508: 42.65,117.92 43.8,117.92 43.89,118.01 v2(44.74,118.01) 45.08,118.01 45.36,118.29 45.36,118.47 45.79,118.89 RH111.2
DMI_CRX_PTX_N0: length 114.1
  TOP w0.089: JCPU1.B27 73.9,42.34 73.44,41.88 v1(73.38,41.88)
  TOP w0.102: v1(36.99,115.34) 36.94,115.38 36.73,115.59 UH4.AW24
  IN4 w0.089: v1(73.38,41.88) 73.22,41.72 72.92,41.72 72.86,41.78 72.86,41.94 73.2,42.28 73.67,42.28 74.28,42.89 74.28,45.92 75.12,46.76 75.12,50.18 75.39,50.44 75.68,50.44 75.68,50.45 75.69,50.45 76.71,51.48 76.71,52.81 76.82,52.92 76.82,68.44 77,68.62 77,76.38 76.98,76.4 76.98,76.48 76.62,76.84 76.62,77.56 75.63,78.55
  IN4 w0.102: 42.77,110.17 42.06,110.17 41.46,110.77 40.73,110.77 40.42,111.07 39.36,111.07 39.27,110.99 38.73,110.99 38.21,111.51 35.21,111.51 34.89,111.84 34.03,111.84 33.69,112.18 33.69,113.34 33.65,113.37 33.65,115.3 34.12,115.76 37.21,115.76 37.3,115.67 37.3,115.57 37.07,115.34 v1(36.99,115.34)
  IN4 w0.117: 75.63,78.55 75.63,78.61 75.55,78.69 75.55,83.39 75.88,83.72 75.88,89.99 74.26,91.61 74.26,93.31 73.81,93.76 73.81,94.6 69.76,98.65 68.92,98.65 66.76,100.81 65.84,100.81 65.8,100.86 64.32,100.86 64.01,101.17 64.01,101.74 59.82,105.93 58.26,105.93 58.26,105.93 57.91,105.93 56.48,107.36 51.76,107.36 51.16,107.96 48.55,107.96 48.36,107.77 47.17,107.77 44.77,110.17 42.77,110.17
DMI_CRX_PTX_N1: length 110.2
  TOP w0.089: JCPU1.B25 75.81,42.45 v3(75.32,41.96)
  TOP w0.102: UH4.AW20 36.73,114.04 37.01,114.31 v1(37.07,114.31)
  IN4 w0.089: 76.61,78.53 76.61,78.51 76.62,78.5 76.62,78.43 76.75,78.3 76.77,78.3 77.79,77.28 77.79,68.78 77.22,68.21 77.22,52.93 76.97,52.68 76.97,51.26 76.19,50.47 76.19,48.86 75.53,48.21 75.53,46.82 74.54,45.83 74.54,42.54 74.75,42.33 74.84,42.33 74.85,42.33 75.22,42.33 75.32,42.23 v3(75.32,41.96)
  IN4 w0.102: 42.77,110.69 42.61,110.69 42.02,111.28 41.23,111.28 40.71,111.8 35.34,111.8 34.91,112.23 34.91,112.97 35.8,113.86 37.08,113.86 37.22,114 37.22,114.16 v1(37.07,114.31)
  IN4 w0.117: 42.77,110.69 44.97,110.69 46.98,108.68 47.64,108.68 47.8,108.51 51.67,108.51 51.91,108.27 56.27,108.27 57.75,106.79 59.68,106.79 63.38,103.1 64.28,103.1 66.05,101.33 66.96,101.33 69.06,99.22 71.15,99.22 72,98.37 72,97.9 76.88,93.02 76.88,90.31 77.71,89.48 77.71,85.07 76.9,84.25 76.9,83.9 76.06,83.06 76.06,81.59 76.61,81.04 76.61,78.53
DMI_CRX_PTX_N2: length 107
  TOP w0.089: v3(76.46,40.88) 76.46,40.88 75.9,41.45 JCPU1.A25
  TOP w0.102: v1(38.29,112.43) 38.26,112.46 38.26,112.46 38,112.72 UH4.BB18
  IN4 w0.089: v3(76.46,40.88) 76.66,41.07 76.66,41.2 76.54,41.31 76,41.31 75.78,41.53 75.78,45.45 76.69,46.36 76.69,50.21 77.51,51.03 77.51,52.48 77.77,52.75 77.77,68 78.22,68.45 78.55,68.45 78.8,68.71 78.8,77.03 77.65,78.18 77.65,78.55
  IN4 w0.102: 42.57,112.02 42.56,112.03 42.56,112.04 42.51,112.09 42.51,112.1 41.99,112.62 40.06,112.62 39.58,113.1 38.16,113.1 37.96,112.9 37.96,112.72 38.25,112.43 v1(38.29,112.43)
  IN4 w0.117: 77.65,78.55 77.65,83.86 78.45,84.66 78.45,89.97 78.28,90.14 78.28,93.6 75.06,96.82 74.3,96.82 73.64,97.48 73.64,98.63 72.32,99.95 69.37,99.95 67.26,102.07 66.39,102.07 64.63,103.83 63.7,103.83 59.9,107.64 58.47,107.64 58.47,107.65 57.94,107.65 56.19,109.39 48.09,109.39 47.61,109.87 47.09,109.87 45.01,111.95 42.65,111.95 42.57,112.02
DMI_CRX_PTX_N3: length 109.4
  TOP w0.089: v1(77.35,41.95) 77.22,41.95 76.9,42.28 JCPU1.B24
  TOP w0.102: v5(36.4,112.46) 36.4,112.47 36.07,112.8 UH4.AV18
  IN4 w0.089: v1(77.35,41.95) 77.49,42.1 77.49,42.22 77.36,42.35 77,42.35 76.8,42.55 76.8,45.4 76.97,45.58 77.49,45.58 77.74,45.82 77.74,49.41 78.6,50.27 78.6,51.88 79.23,52.52 79.23,68.15 79.78,68.7 79.78,76.42 79.43,76.77 79.43,77.13 78.95,77.62 78.95,78.55
  IN4 w0.102: v5(36.4,112.46) 36.27,112.46 36.03,112.7 36.03,112.79 36.35,113.1 37.41,113.1 37.97,113.66 40.75,113.66 41.21,113.2 42.1,113.2 42.58,112.72 42.72,112.72
  IN4 w0.117: 42.72,112.72 45.33,112.72 47.44,110.61 47.91,110.61 48.37,110.15 58.02,110.15 58.94,109.23 58.94,108.78 59.33,108.38 60.22,108.38 63.53,105.07 64.8,105.07 65.14,104.73 65.14,104.36 66.68,102.82 67.6,102.82 67.91,102.52 68.67,102.52 70.48,100.72 72.71,100.72 74,99.43 74.48,99.43 75.48,98.43 75.48,98.04 79.03,94.48 79.03,90.7 79.45,90.27 79.45,88.68 79.69,88.44 79.69,84.69 78.95,83.95 78.95,78.55
DMI_CRX_PTX_P0: length 114.1
  TOP w0.089: JCPU1.B28 72.9,42.41 v3(72.4,41.9)
  TOP w0.102: UH4.AY24 37.37,115.64 v1(37.65,115.35)
  IN4 w0.089: 75.34,78.55 76.41,77.48 76.41,76.76 76.78,76.4 76.78,76.31 76.79,76.29 76.79,68.71 76.61,68.53 76.61,53 76.51,52.89 76.51,51.56 75.6,50.66 75.32,50.66 74.93,50.27 74.93,46.91 74.09,46.08 74.09,42.99 73.57,42.47 73.1,42.47 72.52,41.9 v3(72.4,41.9)
  IN4 w0.102: v1(37.65,115.35) 37.53,115.47 37.53,115.75 37.32,115.96 34.01,115.96 33.43,115.39 33.43,113.28 33.47,113.24 33.47,112.09 33.94,111.62 34.79,111.62 35.12,111.29 38.12,111.29 38.64,110.76 39.36,110.76 39.45,110.85 40.33,110.85 40.64,110.55 41.38,110.55 41.99,109.94 42.77,109.94
  IN4 w0.117: 75.34,78.55 75.31,78.57 75.31,83.49 75.64,83.82 75.64,89.89 74.03,91.51 74.03,93.21 73.57,93.67 73.57,94.5 69.66,98.42 68.82,98.42 66.66,100.58 65.74,100.58 65.7,100.62 64.22,100.62 63.77,101.07 63.77,101.64 59.72,105.69 58.5,105.69 58.5,105.69 57.81,105.69 56.38,107.13 51.66,107.13 51.06,107.73 48.65,107.73 48.46,107.53 47.07,107.53 44.67,109.94 42.77,109.94
DMI_CRX_PTX_P1: length 110.2
  TOP w0.089: JCPU1.B26 74.9,42.62 75.26,42.98 v1(75.33,42.98)
  TOP w0.102: v6(37.72,114.31) 37.72,114.33 37.37,113.98 UH4.AY20
  IN4 w0.089: v1(75.33,42.98) 75.46,42.85 75.46,42.67 75.33,42.54 74.84,42.54 74.75,42.63 74.75,45.74 75.74,46.74 75.74,48.12 76.39,48.77 76.39,50.38 77.18,51.17 77.18,52.59 77.43,52.84 77.43,68.12 78,68.7 78,77.37 76.85,78.53
  IN4 w0.102: 42.77,110.92 42.7,110.92 42.12,111.5 41.32,111.5 40.82,112 35.45,112 35.13,112.32 35.13,112.88 35.9,113.64 37.17,113.64 37.44,113.91 37.44,114.12 37.63,114.31 v6(37.72,114.31)
  IN4 w0.117: 76.85,78.53 76.85,81.14 76.29,81.69 76.29,82.96 77.13,83.8 77.13,84.16 77.95,84.97 77.95,89.57 77.12,90.4 77.12,93.11 72.24,98 72.24,98.47 71.25,99.45 69.16,99.45 67.05,101.56 66.15,101.56 64.38,103.34 63.48,103.34 59.78,107.03 57.85,107.03 56.37,108.51 52.01,108.51 51.77,108.75 47.9,108.75 47.74,108.92 47.07,108.92 45.07,110.92 42.77,110.92
DMI_CRX_PTX_P2: length 106.9
  TOP w0.089: JCPU1.A24 76.81,41.45 76.44,41.82 v1(76.44,41.95)
  TOP w0.102: UH4.AY18 37.65,112.6 v1(37.65,112.43)
  IN4 w0.089: 77.88,78.55 77.88,78.24 78.99,77.13 78.99,68.58 78.64,68.22 78.27,68.22 77.98,67.93 77.98,52.66 77.71,52.4 77.71,50.94 76.9,50.13 76.9,46.27 75.97,45.34 75.97,41.63 76.06,41.54 76.39,41.54 76.45,41.61 76.45,41.95 v1(76.44,41.95)
  IN4 w0.102: v1(37.65,112.43) 37.74,112.52 37.74,112.99 38.07,113.32 39.67,113.32 40.16,112.84 42.09,112.84 42.74,112.19
  IN4 w0.117: 77.88,78.55 77.88,83.76 78.69,84.57 78.69,90.07 78.52,90.24 78.52,93.7 75.16,97.05 74.4,97.05 73.87,97.57 73.87,98.73 72.41,100.19 69.47,100.19 67.36,102.31 66.49,102.31 64.73,104.07 63.8,104.07 59.99,107.87 58.71,107.87 58.71,107.88 58.03,107.88 56.29,109.63 48.19,109.63 47.71,110.1 47.18,110.1 45.11,112.18 42.74,112.18 42.74,112.19
DMI_CRX_PTX_P3: length 109.4
  TOP w0.089: JCPU1.B23 77.89,42.45 77.37,42.97 v3(77.37,42.96)
  TOP w0.102: v1(35.7,112.45) 35.64,112.45 35.38,112.71 UH4.AU18
  IN4 w0.089: v3(77.37,42.96) 77.37,42.76 77.17,42.56 77.17,42.56 77.08,42.56 76.99,42.65 76.99,45.23 77.13,45.37 77.58,45.37 77.93,45.72 77.93,49.3 78.81,50.18 78.81,51.8 79.44,52.43 79.44,68.06 79.97,68.59 79.97,76.53 79.64,76.86 79.64,77.21 79.18,77.67 79.18,78.55
  IN4 w0.102: 42.75,112.95 42.66,112.95 42.19,113.42 41.31,113.42 40.84,113.88 37.87,113.88 37.32,113.32 36.26,113.32 35.81,112.88 35.81,112.56 v1(35.7,112.45)
  IN4 w0.117: 79.18,78.55 79.18,83.85 79.93,84.59 79.93,88.54 79.69,88.77 79.69,90.37 79.27,90.8 79.27,94.58 75.72,98.13 75.72,98.53 74.58,99.67 74.09,99.67 72.81,100.95 70.58,100.95 68.77,102.76 68.01,102.76 67.7,103.06 66.78,103.06 65.38,104.46 65.38,104.83 64.9,105.31 63.63,105.31 60.32,108.62 59.43,108.62 59.18,108.87 59.18,109.33 58.12,110.39 48.46,110.39 48,110.85 47.53,110.85 45.43,112.95 42.75,112.95
DMI_CTX_PRX_N0: length 105.6
  TOP w0.089: v3(79.36,46.92) 79.9,47.45 JCPU1.G21
  TOP w0.102: UH4.BC24 38.64,115.74 v1(38.97,115.35)
  IN4 w0.089: v3(79.36,46.92) 79.37,46.92 80.04,47.59 80.04,51.43 81.21,52.6 81.21,53.48 81.66,53.93 81.66,54.82 81.48,55 81.48,67.8 82.01,68.32 82.01,78.29 82.07,78.35 82.07,78.55
  IN4 w0.102: v1(38.97,115.35) 38.97,115.87 39.34,116.23 40.83,116.23 41.32,115.74 41.32,115.3 41.74,114.87 42.77,114.87
  IN4 w0.117: 82.07,78.55 82.07,84.39 84.02,86.34 84.02,93.44 77.24,100.21 76.45,100.21 74.18,102.48 71.13,102.48 69.38,104.22 68.78,104.22 67.76,105.24 67.35,105.24 65.36,107.24 63.94,107.24 61.82,109.35 61.82,109.73 59.7,111.85 49.19,111.85 48.72,112.32 48.19,112.32 46.09,114.43 43.45,114.43 43,114.87 42.77,114.87
DMI_CTX_PRX_N1: length 104.7
  TOP w0.089: JCPU1.E22 78.9,45.39 v3(78.42,44.91)
  TOP w0.102: v1(39.65,114.31) 39.65,114.33 39.27,113.95 UH4.BE20
  IN4 w0.089: v3(78.42,44.91) 78.42,44.86 78.55,44.73 78.78,44.73 78.9,44.86 78.9,45.07 78.76,45.22 78.76,49.73 79.21,50.18 79.21,51.7 80.27,52.75 80.27,54.8 80.39,54.92 80.39,68.25 80.82,68.68 80.82,76.84 79.74,77.92 79.74,78.44 79.73,78.46 79.73,78.52 79.72,78.54 79.72,78.55
  IN4 w0.102: 42.62,113.88 42.61,113.89 41.53,113.89 40.69,114.72 39.54,114.72 39.4,114.58 39.4,114.45 39.53,114.31 v1(39.65,114.31)
  IN4 w0.117: 42.62,113.88 43.04,113.45 45.65,113.45 47.75,111.35 48.32,111.35 48.79,110.88 59.29,110.88 60.85,109.33 60.85,108.93 63.52,106.27 63.86,106.27 63.86,106.26 64.95,106.26 66.3,104.92 66.3,104.36 67.09,103.57 67.95,103.57 68.27,103.25 68.98,103.25 70.75,101.48 73.8,101.48 76.38,98.9 77.18,98.9 80.48,95.6 80.48,91.14 80.31,90.97 80.31,88.87 80.55,88.62 80.55,84.25 79.95,83.65 79.95,79.66 79.72,79.43 79.72,78.55
