# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D20: length 67.8
  TOP w0.089: v1(95.4,48.91) 95.4,48.92 95.9,49.42 JCPU1.J5
  TOP w0.14: v1(140.9,31.35) 141.1,31.14 141.53,31.14 141.69,31.31 141.69,31.8 141.79,31.9 JDIMM1.39
  IN1 w0.089: 103.85,39.69 103.74,39.79 103.74,40.31 102.7,41.35 102.7,43.05 101.16,44.59 101.16,45.74 100.55,46.35 100.41,46.35 99.99,46.76 99.99,47.15 99.63,47.51 98.38,47.51 97.57,48.32 96.07,48.32 95.47,48.92 95.41,48.92 v1(95.4,48.91)
  IN1 w0.147: 103.85,39.69 109.05,34.48 109.05,32.44 113.06,28.42 115.69,28.42 116.2,27.92 119.89,27.92 120.03,28.06 120.03,28.47 120.18,28.61 120.47,28.61 120.62,28.47 120.62,28.06 120.77,27.92 125.1,27.92 125.48,28.3 132.3,28.3 132.38,28.37 134.18,28.37 136.32,30.52 141.22,30.52 141.35,30.64 141.35,31.28 141.28,31.35 v1(140.9,31.35)
  BOTTOM w0.14: v1(140.9,31.35) 141.39,31.35 141.6,31.56 141.6,32.03 141.77,32.2 JDIMM2.40
DDR_A_D21: length 68.5
  TOP w0.089: v3(96.4,48.91) 96.4,48.91 96.9,49.41 JCPU1.J4
  TOP w0.14: v1(139.5,31.35) 139.5,31.63 139.8,31.93 140.96,31.93 141.53,32.5 JDIMM1.41
  IN1 w0.089: v3(96.4,48.91) 96.8,48.51 97.65,48.51 98.46,47.7 99.69,47.7 100.07,47.32 100.6,47.32 101.34,46.58 101.34,44.66 102.88,43.12 102.88,41.43 104.38,39.93 104.38,39.69
  IN1 w0.147: v1(139.5,31.35) 139.7,31.35 139.83,31.22 139.83,31.02 139.7,30.89 136.17,30.89 134.02,28.75 132.22,28.75 132.14,28.67 125.33,28.67 124.94,28.29 121.47,28.29 120.75,29.02 119.71,29.02 119.58,28.89 119.58,28.77 119.45,28.64 119.06,28.64 118.93,28.77 118.93,28.89 118.81,29.02 118.43,29.02 118.31,28.89 118.31,28.42 118.18,28.29 117.77,28.29 117.67,28.39 117.67,28.54 117.52,28.69 117.13,28.69 116.97,28.54 116.97,28.39 116.87,28.29 116.47,28.29 116.34,28.42 116.34,28.59 116.22,28.72 115.93,28.72 115.85,28.8 113.22,28.8 113.09,28.93 113.09,29.29 112.96,29.42 112.6,29.42 109.43,32.59 109.43,34.64 104.38,39.69
  BOTTOM w0.14: JDIMM2.42 141.85,32.8 140.85,31.8 140.07,31.8 139.62,31.35 v1(139.5,31.35)
DDR_A_D22: length 67.4
  TOP w0.089: JCPU1.J2 98.94,49.45 v3(99.4,49.91)
  TOP w0.14: v1(138.26,34.75) 138.26,34.3 138.09,34.13 136.84,34.13 136.47,34.49 136.47,34.75 136.02,35.2 JDIMM1.50
  IN1 w0.089: v3(99.4,49.91) 98.93,49.91 98.8,50.04 98.8,51.28 98.93,51.4 100.51,51.4 101.55,50.37 101.55,48.64 102.83,47.36 102.83,45.57 103.99,44.41
  IN1 w0.147: v1(138.26,34.75) 138.26,35.16 138.14,35.28 136.74,35.28 135.62,34.15 135.1,34.15 133.74,32.79 126.57,32.79 126.48,32.7 126.48,32.63 126.14,32.29 125.71,32.29 125.58,32.42 125.58,32.85 125.45,32.97 125.12,32.97 124.99,32.85 124.99,32.27 124.86,32.14 124.53,32.14 124.4,32.27 124.4,32.85 124.27,32.97 123.94,32.97 123.81,32.85 123.81,32.27 123.68,32.14 123.35,32.14 123.22,32.27 123.22,32.85 123.09,32.97 121.55,32.97 121.06,33.46 120.3,33.46 120,33.16 120,33.15 119.74,32.89 115.36,32.89 115.05,33.2 113.16,33.2 112.48,33.88 112.48,35.91 103.99,44.41
  BOTTOM w0.14: JDIMM2.51 135.95,35.5 136.5,34.95 136.5,34.6 136.94,34.15 137.81,34.15 138.26,34.6 v1(138.26,34.75)
DDR_A_D23: length 66.2
  TOP w0.089: JCPU1.K2 99.37,50.92 v1(99.4,50.92)
  TOP w0.14: v1(136.99,34.75) 136.99,35.2 136.97,35.22 136.97,35.23 136.8,35.4 136.35,35.4 135.95,35.8 JDIMM1.52
  IN1 w0.089: v1(99.4,50.92) 99.4,51.1 99.28,51.23 99.11,51.23 98.98,51.1 98.98,50.45 99.11,50.32 101.24,50.32 101.37,50.2 101.37,48.57 102.65,47.29 102.65,45.19 104.17,43.67 104.2,43.67 104.49,43.37
  IN1 w0.147: v1(136.99,34.75) 137.06,34.75 137.19,34.62 137.19,34.54 137.43,34.3 137.44,34.29 137.44,34.08 137.13,33.77 136.91,33.77 136.76,33.92 136.76,34.3 136.64,34.43 136.43,34.43 136.3,34.3 136.3,33.92 136.15,33.77 135.26,33.77 133.89,32.41 129.5,32.41 128.81,31.73 128.23,31.73 128.14,31.81 128.14,32.29 128.01,32.41 127.68,32.41 127.55,32.29 127.55,31.81 127.46,31.73 127.17,31.73 127.04,31.85 127.04,32.1 126.91,32.23 126.61,32.23 126.48,32.1 126.48,31.85 126.39,31.77 122.7,31.77 122.57,31.9 122.57,32.47 122.45,32.6 122.18,32.6 122.06,32.47 122.06,31.9 121.93,31.77 121.54,31.77 121.41,31.9 121.41,32.57 121.29,32.7 120.91,32.7 120.79,32.57 120.79,32.03 120.66,31.9 120.36,31.9 120.23,32.03 120.23,32.39 120.11,32.52 118.56,32.52 118.43,32.39 118.43,32.28 118.3,32.15 117.94,32.15 117.82,32.28 117.82,32.39 117.69,32.52 117.33,32.52 117.21,32.39 117.21,32.28 117.08,32.15 116.74,32.15 116.62,32.28 116.62,32.39 116.49,32.52 116.16,32.52 116.03,32.39 116.03,32.28 115.9,32.15 115.57,32.15 115.44,32.28 115.44,32.37 115.3,32.52 115.2,32.52 114.89,32.82 113.01,32.82 112.11,33.72 112.11,35.75 104.72,43.15 104.49,43.37
  BOTTOM w0.14: JDIMM2.53 136.02,36.1 136.99,35.13 v1(136.99,34.75)
DDR_A_D24: length 72
  TOP w0.089: v3(93.4,51.93) 93.4,51.93 92.9,52.43 JCPU1.M8
  TOP w0.14: v1(138.1,36.68) 138.1,36.21 137.98,36.08 136.33,36.08 136.2,36.21 136.2,36.79 135.99,37 JDIMM1.56
  IN1 w0.089: v3(93.4,51.93) 93.4,51.93 93.82,51.51 96.56,51.51 97.02,51.97 98.19,51.97 98.33,52.11 100.91,52.11 102.26,50.76 102.26,49.04 103.63,47.67 103.63,47.03 104.49,46.17
  IN1 w0.147: v1(138.1,36.68) 138.1,36.69 138.66,37.25 141.19,37.25 141.32,37.37 141.32,37.71 141.19,37.84 138.44,37.84 137.84,37.24 136.47,37.24 134.96,35.73 131.97,35.73 131,34.77 130.19,34.77 129.79,34.37 126.69,34.37 126.51,34.55 123.56,34.55 122.84,35.27 120.39,35.27 119.94,35.72 114.95,35.72 104.49,46.17
  BOTTOM w0.14: v1(138.1,36.68) 138.1,36.4 137.78,36.08 136.76,36.08 136.11,36.73 136.11,37.17 135.99,37.3 JDIMM2.57
DDR_A_D25: length 71.9
  TOP w0.089: v3(90.4,52.92) 90.9,53.42 JCPU1.N10
  TOP w0.14: JDIMM1.58 136.53,37.6 136.83,37.3 v1(136.83,36.68)
  IN1 w0.089: 104.49,45.64 103.45,46.68 103.45,47.6 102.08,48.97 102.08,50.67 100.82,51.94 98.4,51.94 98.26,51.8 97.1,51.8 96.63,51.33 92.81,51.33 91.62,52.52 90.45,52.52 90.4,52.57 v3(90.4,52.92)
  IN1 w0.147: 104.49,45.64 113.69,36.44 113.69,36.35 113.82,36.22 113.9,36.22 114.03,36.1 114.03,35.79 113.9,35.66 113.82,35.66 113.69,35.54 113.69,34.53 113.82,34.4 114.25,34.4 114.37,34.53 114.37,35.22 114.5,35.34 114.88,35.34 115.01,35.22 115.01,34.53 115.14,34.4 115.55,34.4 115.68,34.53 115.68,35.21 115.8,35.34 116.11,35.34 116.24,35.21 116.24,35.13 116.37,35.01 116.72,35.01 116.85,35.13 116.85,35.21 116.98,35.34 117.31,35.34 117.44,35.21 117.44,34.52 117.56,34.4 117.92,34.4 118.03,34.52 118.03,35.2 118.17,35.34 119.79,35.34 120.27,34.85 122.73,34.85 123.41,34.18 126.36,34.18 126.54,33.99 130.31,33.99 130.44,34.12 130.44,34.26 130.57,34.39 130.92,34.39 131.05,34.26 131.05,34.12 131.18,33.99 131.48,33.99 131.61,34.12 131.61,34.23 131.74,34.36 132.04,34.36 132.17,34.23 132.17,34.12 132.3,33.99 132.65,33.99 132.78,34.12 132.78,34.24 132.9,34.37 133.15,34.37 133.33,34.19 133.43,34.19 133.76,34.52 133.76,34.52 133.92,34.67 133.92,34.84 133.62,35.14 133.62,35.28 133.69,35.35 135.12,35.35 136.45,36.68 v1(136.83,36.68)
  BOTTOM w0.14: JDIMM2.59 136.08,37.9 136.83,37.14 v1(136.83,36.68)
DDR_A_D26: length 69.6
  TOP w0.089: v3(92.4,52.92) 92.9,53.42 JCPU1.N8
  TOP w0.14: JDIMM1.67 141.54,40.3 141.18,39.94 v1(141.18,39.73)
  IN1 w0.089: v3(92.4,52.92) 92.4,53.34 92.93,53.87 92.93,54.01 93.42,54.51 100.63,54.51 101.01,54.13 101.01,53.65 103.42,51.24 103.42,50.5 104.49,49.43
  IN1 w0.147: v1(141.18,39.73) 142.11,39.73 142.3,39.92 142.3,42.09 142.17,42.22 141.71,42.22 141.58,42.09 141.58,40.69 141.45,40.56 136.52,40.56 135.28,39.33 134.13,38.18 121.73,38.18 121.18,38.73 118.48,38.73 118.03,39.18 114.74,39.18 104.49,49.43
  BOTTOM w0.14: JDIMM2.68 142.05,40.6 v1(141.18,39.73)
DDR_A_D27: length 70.8
  TOP w0.089: v3(93.4,53.92) 93.4,53.92 93.87,53.45 JCPU1.N7
  TOP w0.14: v1(139.91,39.73) 139.91,39.82 140.8,40.71 141.9,40.71 142.09,40.9 JDIMM1.69
  IN1 w0.089: 104.49,48.9 103.25,50.15 103.25,51.17 100.84,53.58 100.84,54.05 100.56,54.33 93.81,54.33 v3(93.4,53.92)
  IN1 w0.147: 104.49,48.9 114.59,38.81 114.7,38.81 114.83,38.68 114.83,38.56 114.96,38.43 115.19,38.43 115.31,38.56 115.31,38.68 115.44,38.81 115.71,38.81 115.84,38.68 115.84,37.78 115.96,37.65 116.3,37.65 116.43,37.78 116.43,38.68 116.55,38.81 116.87,38.81 117,38.68 117,37.78 117.13,37.65 117.47,37.65 117.6,37.78 117.6,38.53 117.73,38.66 118.02,38.66 118.33,38.35 120.82,38.35 120.94,38.22 120.94,37.93 121.07,37.8 121.42,37.8 121.54,37.68 121.54,37.33 121.67,37.2 122.04,37.2 122.17,37.33 122.17,37.68 122.29,37.8 122.66,37.8 122.78,37.68 122.78,37.33 122.91,37.2 123.28,37.2 123.4,37.33 123.4,37.68 123.53,37.8 134.29,37.8 135.66,39.17 136.29,39.17 136.41,39.29 136.41,39.92 136.67,40.19 139.89,40.19 140.04,40.04 140.04,39.86 v1(139.91,39.73)
  BOTTOM w0.14: JDIMM2.70 142.04,41.2 141.29,40.45 140.47,40.45 139.91,39.89 v1(139.91,39.73)
DDR_A_D28: length 73.3
  TOP w0.089: v1(90.4,51.92) 90.4,51.92 90.9,52.42 JCPU1.M10
  TOP w0.14: v1(139.37,36.68) 139.37,36.56 139.9,36.03 140.7,36.03 141.2,36.53 141.2,36.94 141.55,37.3 JDIMM1.57
  IN1 w0.089: v1(90.4,51.92) 90.68,51.92 91.08,52.32 91.56,52.32 93,50.89 93,50.75 93.24,50.52 96.57,50.52 96.8,50.75 96.8,51.25 97.17,51.62 98.33,51.62 98.48,51.76 100.72,51.76 101.9,50.57 101.9,48.8 103.23,47.48 103.23,46.37 104.49,45.1
  IN1 w0.147: v1(139.37,36.68) 139.37,36.68 138.8,36.1 136.4,36.1 135.28,34.98 134.76,34.98 133.4,33.62 126.38,33.62 126.2,33.8 123.25,33.8 122.57,34.48 120.09,34.48 119.75,34.82 118.85,34.82 118.36,34.33 118.36,34.31 117.77,33.72 115.7,33.72 115.39,34.03 113.66,34.03 113.31,34.38 113.31,36.28 104.49,45.1
  BOTTOM w0.14: v1(139.37,36.68) 139.37,36.51 139.77,36.11 141.34,36.11 142.23,37 JDIMM2.56
DDR_A_D29: length 71.2
  TOP w0.089: v3(91.4,51.92) 91.9,52.42 JCPU1.M9
  TOP w0.14: JDIMM1.59 141.59,37.9 140.64,36.95 v1(140.64,36.68)
  IN1 w0.089: v3(91.4,51.92) 91.57,51.75 91.57,51.32 91.99,50.89 91.99,50.76 92.43,50.33 96.63,50.33 96.98,50.68 96.98,51.06 97.36,51.44 98.41,51.44 98.55,51.58 100.59,51.58 101.73,50.44 101.73,48.73 103.03,47.42 103.03,46 104.47,44.56
  IN1 w0.147: v1(140.64,36.68) 141.06,36.27 141.06,35.86 140.93,35.73 136.56,35.73 135.43,34.6 134.91,34.6 133.55,33.24 126.23,33.24 126.04,33.42 121.73,33.42 121.25,33.91 118.64,33.91 118.39,33.65 118.39,33.63 118.1,33.35 115.54,33.35 115.24,33.65 113.5,33.65 112.94,34.22 112.94,36.1 104.47,44.56
  BOTTOM w0.14: v1(140.64,36.68) 141.32,36.68 142.23,37.6 JDIMM2.58
DDR_A_D30: length 73.7
  TOP w0.089: JCPU1.N9 91.9,53.42 v1(91.4,52.92)
  TOP w0.14: v1(138.39,39.73) 137.93,39.28 136.64,39.28 136.17,39.75 136.17,40.26 135.83,40.6 JDIMM1.68
  IN1 w0.089: v1(91.4,52.92) 91.11,52.92 90.98,53.05 90.98,53.31 91.11,53.43 91.87,53.43 92,53.31 92,52.45 92.13,52.33 93.68,52.33 93.8,52.45 93.8,53.21 93.93,53.34 100.57,53.34 102.89,51.02 102.89,49.44 104.49,47.83
  IN1 w0.147: v1(138.39,39.73) 138.27,39.73 137.57,39.03 137.57,38.64 137.35,38.42 135.98,38.42 134.59,37.03 131.55,37.03 130.97,36.45 127.01,36.45 126.87,36.3 126.87,35.9 126.72,35.75 126.42,35.75 126.28,35.9 126.28,36.3 126.13,36.45 125.84,36.45 125.69,36.3 125.69,35.9 125.54,35.75 125.25,35.75 125.1,35.9 125.1,36.3 124.95,36.45 124.66,36.45 124.51,36.3 124.51,35.86 124.38,35.73 124.05,35.73 123.93,35.86 123.93,36.32 123.8,36.45 121.02,36.45 120.56,36.91 120.08,36.91 119.95,37.03 119.95,37.45 119.83,37.58 119.18,37.58 119.06,37.45 119.06,37.02 118.93,36.89 115.43,36.89 104.49,47.83
  BOTTOM w0.14: v1(138.39,39.73) 137.69,39.04 136.57,39.04 136.24,39.37 136.24,39.94 135.89,40.3 JDIMM2.67
DDR_A_D31: length 69.1
  TOP w0.089: v1(93.4,52.92) 93.87,52.45 JCPU1.M7
  TOP w0.14: JDIMM1.70 135.88,41.2 136.96,40.12 136.96,39.82 v1(136.86,39.73)
  IN1 w0.089: v1(93.4,52.92) 93.48,52.84 93.48,52.63 93.35,52.5 92.94,52.5 92.81,52.63 92.81,53.38 92.95,53.52 100.64,53.52 103.07,51.09 103.07,49.83 104.49,48.41 104.49,48.37
  IN1 w0.147: 104.49,48.37 114.8,38.06 115.28,38.06 115.41,37.93 115.41,37.45 115.59,37.28 117.85,37.28 117.98,37.4 117.98,37.85 118.1,37.97 120.37,37.97 121.52,36.83 123.68,36.83 123.8,36.95 123.8,37.3 123.93,37.43 124.26,37.43 124.39,37.3 124.39,36.95 124.52,36.83 124.85,36.83 124.98,36.95 124.98,37.3 125.11,37.43 125.44,37.43 125.57,37.3 125.57,36.95 125.7,36.83 126.03,36.83 126.16,36.95 126.16,37.3 126.29,37.43 126.62,37.43 126.75,37.3 126.75,36.95 126.88,36.83 127.21,36.83 127.34,36.95 127.34,37.3 127.46,37.43 127.82,37.43 127.95,37.3 127.95,36.95 128.08,36.83 128.4,36.83 128.52,36.95 128.52,37.3 128.65,37.43 129.01,37.43 129.13,37.3 129.13,36.95 129.26,36.83 129.63,36.83 129.75,36.95 129.75,37.28 129.88,37.4 130.22,37.4 130.35,37.28 130.35,36.96 130.48,36.83 130.78,36.83 130.91,36.96 130.91,37.28 131.04,37.4 134.42,37.4 135.81,38.79 135.81,38.8 137.09,38.8 137.19,38.9 137.19,39.57 137.04,39.73 v1(136.86,39.73)
  BOTTOM w0.14: v1(136.86,39.73) 136.86,40.56 136.52,40.9 JDIMM2.69
DDR_A_D32: length 70.9
  TOP w0.089: v3(94.41,66.94) 94.9,67.43 JCPU1.AG6
  TOP w0.14: v1(138.42,62.93) 138.42,62.81 137.21,61.6 JDIMM1.130
  IN1 w0.089: v3(94.41,66.94) 94.41,66.9 94.53,66.78 95.81,66.78 95.93,66.9 95.93,68.02 96.28,68.36 96.51,68.36 96.8,68.66 96.8,70.14 97.18,70.51 97.57,70.51 97.8,70.74 97.8,71.14 98.18,71.51 99.54,71.51 101.65,73.62 102.56,73.62 103.32,74.38 103.39,74.38
  IN1 w0.147: 103.39,74.38 103.67,74.38 103.8,74.51 103.8,74.64 103.92,74.77 104.27,74.77 104.39,74.64 104.39,74.19 104.52,74.06 104.9,74.06 105.03,74.19 105.03,74.47 105.15,74.6 109.77,74.6 110.07,74.9 110.86,74.9 110.97,75.01 110.97,75.2 111.06,75.29 113.32,75.29 113.45,75.16 113.45,74.72 113.57,74.6 113.83,74.6 113.96,74.72 113.96,74.79 114.07,74.91 114.31,74.91 114.42,74.79 114.42,74.72 114.54,74.6 116.31,74.6 116.44,74.73 116.44,74.93 116.8,75.29 118.82,75.29 118.97,75.14 118.97,74.72 119.1,74.6 119.43,74.6 119.56,74.72 119.56,75.16 119.69,75.29 120.01,75.29 120.14,75.16 120.14,74.72 120.27,74.6 120.57,74.6 120.7,74.72 120.7,75.16 120.83,75.29 121.19,75.29 121.32,75.16 121.32,74.72 121.45,74.6 121.9,74.6 129.61,66.89 130.94,66.89 131.06,66.76 131.06,66.65 131.19,66.52 131.53,66.52 131.66,66.65 131.66,66.76 131.79,66.89 132.29,66.89 132.42,66.76 132.42,66.62 132.21,66.4 132.21,66.03 132.82,65.42 132.92,65.42 133.04,65.54 133.04,65.65 133.17,65.77 133.42,65.77 133.55,65.65 133.55,65.54 133.68,65.42 133.78,65.42 135.81,63.39 138.62,63.39 138.74,63.26 138.74,63.06 138.62,62.93 v1(138.42,62.93)
  BOTTOM w0.14: JDIMM2.129 136.1,61.3 136.47,61.67 137.36,61.67 138.42,62.73 v1(138.42,62.93)
DDR_A_D33: length 68.1
  TOP w0.089: JCPU1.AG5 95.93,67.45 v3(96.4,67.92)
  TOP w0.14: JDIMM1.132 136.62,62.2 137.15,62.73 v1(137.15,62.93)
  IN1 w0.089: v3(96.4,67.92) 96.32,67.92 96.19,67.79 96.19,67.45 96.29,67.35 96.94,67.35 97,67.41 97,70.08 97.24,70.32 97.63,70.32 98,70.69 98,71.08 98.24,71.32 99.6,71.32 100.46,72.17 101.45,72.17 101.57,72.3 101.57,72.45 101.32,72.71 101.32,72.94 101.51,73.13 102.42,73.13
  IN1 w0.147: 102.42,73.13 102.43,73.13 102.54,73.25 103.08,73.25 103.21,73.37 103.21,73.92 103.34,74.05 103.64,74.05 103.77,73.92 103.77,73.85 103.94,73.69 105.24,73.69 105.39,73.83 105.39,74.07 105.53,74.22 105.83,74.22 105.98,74.07 105.98,73.83 106.12,73.69 106.42,73.69 106.56,73.83 106.56,74.07 106.71,74.22 107.01,74.22 107.15,74.07 107.15,73.83 107.3,73.69 107.6,73.69 107.74,73.83 107.74,74.07 107.89,74.22 108.19,74.22 108.33,74.07 108.33,73.81 108.46,73.68 108.79,73.68 108.92,73.81 108.92,74.07 109.07,74.22 109.36,74.22 109.51,74.07 109.51,73.81 109.64,73.68 109.97,73.68 110.1,73.81 110.1,74.4 110.23,74.52 110.54,74.52 110.67,74.4 110.67,74.35 110.79,74.22 111.18,74.22 111.3,74.35 111.3,74.79 111.43,74.91 111.77,74.91 111.89,74.79 111.89,74.35 112.02,74.22 112.36,74.22 112.48,74.35 112.48,74.79 112.61,74.91 112.94,74.91 113.07,74.79 113.07,74.37 113.22,74.22 116.67,74.22 116.82,74.37 116.82,74.77 116.95,74.9 117.28,74.9 117.41,74.77 117.41,74.37 117.55,74.22 117.85,74.22 118,74.37 118,74.79 118.12,74.91 118.46,74.91 118.59,74.79 118.59,74.37 118.73,74.22 121.74,74.22 129.45,66.51 130.66,66.51 131.1,66.07 131.28,66.07 131.36,66.14 131.55,66.14 131.78,65.91 131.78,65.73 131.68,65.63 131.68,65.48 131.89,65.26 132.07,65.26 132.15,65.35 132.36,65.35 132.57,65.14 132.57,64.93 132.51,64.87 132.51,64.65 132.81,64.35 133.02,64.35 133.13,64.47 133.13,64.91 133.26,65.04 133.63,65.04 133.75,64.91 133.75,64.58 133.88,64.45 134.19,64.45 135.71,62.93 v1(137.15,62.93)
  BOTTOM w0.14: JDIMM2.131 136.12,61.9 v1(137.15,62.93)
DDR_A_D34: length 67
  TOP w0.089: JCPU1.AK6 94.9,70.55 94.55,70.9 94.55,70.93 v3(94.54,70.94)
  TOP w0.14: JDIMM1.141 142.02,64.9 141.93,64.99 141.15,64.99 140.91,64.75 v1(140.91,64.51)
  IN1 w0.089: v3(94.54,70.94) 94.86,70.94 95.24,71.32 95.6,71.32 95.98,71.7 95.98,72.08 96.22,72.32 96.62,72.32 97,72.7 97,73.09 97.24,73.33 97.63,73.33 98,73.7 98,74.09 98.24,74.33 98.65,74.33 98.98,74.66 98.98,75.06 100.45,76.53 104.49,76.53
  IN1 w0.147: 104.49,76.53 108.96,76.53 109.65,77.22 122.01,77.22 130.41,68.82 133.11,68.82 135.98,65.95 137.48,65.95 137.93,65.51 138.49,65.51 138.63,65.37 138.63,65.21 138.77,65.07 139.07,65.07 139.22,65.21 139.22,65.37 139.35,65.51 139.68,65.51 139.82,65.37 139.82,65.01 139.94,64.88 140.28,64.88 140.41,65.01 140.41,65.37 140.54,65.51 142.54,65.51 142.67,65.38 142.67,64.68 142.54,64.55 142.23,64.55 142.1,64.68 142.1,64.86 141.97,64.99 141.1,64.99 140.91,64.8 v1(140.91,64.51)
  BOTTOM w0.14: JDIMM2.140 142.23,64.6 141.86,64.97 141.26,64.97 140.91,64.62 v1(140.91,64.51)
DDR_A_D35: length 70
  TOP w0.089: v1(95.4,69.92) 95.9,70.42 JCPU1.AK5
  TOP w0.14: JDIMM1.142 135.81,65.2 137.76,67.15 139.29,67.15 139.55,66.89 139.55,66.61 v1(139.56,66.59)
  IN1 w0.089: 104.49,76.9 100.31,76.9 98.8,75.4 98.8,74.73 98.59,74.52 98.13,74.52 97.81,74.2 97.81,73.76 97.57,73.52 97.1,73.52 96.81,73.23 96.81,72.76 96.56,72.51 96.08,72.51 95.8,72.23 95.8,71.77 95.53,71.5 95.16,71.5 95.13,71.46 94.51,71.46 94.39,71.34 94.37,71.34 94.14,71.11 94.14,71.09 94.12,71.07 94.12,70.73 94.41,70.44 95.4,70.44 95.53,70.32 95.53,70.04 v1(95.4,69.92)
  IN1 w0.147: v1(139.56,66.59) 139.76,66.59 139.89,66.46 139.89,66.05 139.76,65.93 138.04,65.93 137.64,66.33 136.14,66.33 133.27,69.19 130.57,69.19 122.16,77.59 109.49,77.59 108.8,76.9 104.49,76.9
  BOTTOM w0.14: JDIMM2.143 135.83,65.5 137.37,67.04 139.4,67.04 139.6,66.84 139.6,66.63 v1(139.56,66.59)
DDR_A_D36: length 69.6
  TOP w0.089: v1(95.4,67.92) 95.9,68.42 JCPU1.AH5
  TOP w0.14: v1(139.82,62.93) 139.82,62.71 141.23,61.3 JDIMM1.129
  IN1 w0.089: v1(95.4,67.92) 95.47,67.98 95.64,67.98 95.76,67.87 95.76,67.08 95.63,66.95 94.93,66.95 94.8,67.08 94.8,68.2 94.93,68.33 95.88,68.33 96,68.46 96,69.09 96.62,69.71 96.62,70.32 97,70.7 97,71.08 97.24,71.31 97.7,71.31 98,71.62 98,72.08 98.24,72.32 100.1,72.32 101.66,73.88 102.56,73.88 103.66,74.97 104.49,74.97
  IN1 w0.147: 104.49,74.97 109.6,74.97 110.3,75.66 113.73,75.66 113.8,75.59 113.8,75.37 113.89,75.28 114.46,75.28 114.74,75.01 115.99,75.01 116.65,75.66 121.36,75.66 129.77,67.26 132.47,67.26 135.97,63.76 139.37,63.76 139.66,64.06 140.08,64.06 140.57,63.57 140.57,63.46 140.5,63.39 139.79,63.39 139.65,63.25 139.65,63.1 v1(139.82,62.93)
  BOTTOM w0.14: JDIMM2.130 141.79,61.6 141.36,62.03 140.57,62.03 139.82,62.79 v1(139.82,62.93)
DDR_A_D37: length 68.5
  TOP w0.089: v1(94.4,67.92) 94.9,68.42 JCPU1.AH6
  TOP w0.14: JDIMM1.131 142.12,61.9 v1(141.09,62.93)
  IN1 w0.089: v1(94.4,67.92) 94.4,68.42 94.5,68.51 95.69,68.51 95.81,68.64 95.81,69.15 96.45,69.79 96.45,70.4 96.81,70.76 96.81,71.15 97.17,71.5 97.64,71.5 97.81,71.68 97.81,72.15 98.17,72.5 99.59,72.5 101.3,74.22 102.66,74.22 103.79,75.35 104.49,75.35
  IN1 w0.147: v1(141.09,62.93) 141.09,62.27 141.21,62.14 142.21,62.14 142.34,62.27 142.34,63.92 142.21,64.04 141.84,64.04 141.72,63.92 141.72,63.6 141.59,63.48 141.21,63.48 141.08,63.6 141.08,63.92 140.96,64.04 140.68,64.04 140.29,64.43 139.5,64.43 139.21,64.14 136.13,64.14 132.63,67.64 129.92,67.64 121.52,76.04 116.49,76.04 115.84,75.39 114.89,75.39 114.23,76.04 110.14,76.04 109.45,75.35 104.49,75.35
  BOTTOM w0.14: v1(141.09,62.93) 141.82,62.2 JDIMM2.132
DDR_A_D38: length 67.9
  TOP w0.089: v3(95.4,68.92) 95.9,69.42 JCPU1.AJ5
  TOP w0.14: v1(138.04,66.59) 137.75,66.59 135.76,64.6 JDIMM1.140
  IN1 w0.089: v3(95.4,68.92) 95.51,68.92 95.63,69.05 95.63,69.39 95.51,69.52 95.2,69.52 95.13,69.46 95.13,69.24 95.03,69.14 94.77,69.14 94.56,69.34 94.32,69.34 94.2,69.47 94.2,69.71 94.32,69.84 94.73,69.84 94.85,69.96 94.85,70.14 94.73,70.26 94.34,70.26 93.94,70.67 93.94,71.36 94.26,71.69 94.82,71.69 94.92,71.78 94.92,72.08 95.17,72.33 95.65,72.33 96,72.68 96,73.08 96.24,73.32 96.63,73.32 97,73.69 97,74.18 97.15,74.33 97.65,74.33 98,74.68 98,75.1 100.18,77.28 104.49,77.28
  IN1 w0.147: v1(138.04,66.59) 137.93,66.7 136.29,66.7 133.43,69.57 130.72,69.57 129.3,70.99 129.3,71.2 129.36,71.27 129.36,71.47 129.15,71.68 128.95,71.68 128.88,71.62 128.67,71.62 128.41,71.88 128.41,72.09 128.47,72.16 128.47,72.37 128.26,72.58 128.05,72.58 127.99,72.51 127.78,72.51 127.57,72.72 127.57,72.93 127.64,72.99 127.64,73.2 127.43,73.41 127.22,73.41 127.15,73.34 126.95,73.34 122.32,77.97 109.34,77.97 108.65,77.28 104.49,77.28
  BOTTOM w0.14: v1(138.04,66.59) 137.71,66.59 136.02,64.9 JDIMM2.141
DDR_A_D39: length 67.7
  TOP w0.089: JCPU1.AJ6 94.9,69.42 v1(94.4,68.92)
  TOP w0.14: JDIMM1.143 141.79,65.5 141.09,66.2 v1(141.09,66.59)
  IN1 w0.089: 104.49,77.66 100.3,77.66 97.81,75.16 97.81,74.76 97.57,74.52 97.08,74.52 96.81,74.25 96.81,73.77 96.55,73.51 96.18,73.51 95.81,73.15 95.81,72.76 95.56,72.51 95.1,72.51 94.73,72.14 94.45,72.14 93.75,71.44 93.75,70.56 94.02,70.29 94.02,69.3 v1(94.4,68.92)
  IN1 w0.147: 104.49,77.66 108.49,77.66 109.18,78.35 122.47,78.35 126.98,73.84 127.53,73.84 131.43,69.94 133.58,69.94 136.45,67.08 142.17,67.08 142.3,66.95 142.3,66.52 142.09,66.31 141.34,66.31 141.09,66.56 v1(141.09,66.59)
  BOTTOM w0.14: JDIMM2.142 142.28,65.2 141.09,66.39 v1(141.09,66.59)
DDR_A_D40: length 70.8
  TOP w0.089: v1(92.4,69.92) 92.87,69.45 JCPU1.AJ8
  TOP w0.14: v1(137.28,68.79) 137.27,68.73 137.27,68.53 135.74,67 JDIMM1.148
  IN1 w0.089: 99.41,78.35 97.8,76.75 97.41,76.75 94.8,74.14 94.8,73.75 94.56,73.51 94.18,73.51 93.82,73.16 93.82,72.78 92.82,71.77 92.82,69.85 92.7,69.72 92.53,69.72 92.4,69.85 v1(92.4,69.92)
  IN1 w0.147: 99.41,78.35 100.29,79.24 107.73,79.24 109.53,81.03 109.73,81.03 109.85,81.16 109.85,81.36 109.98,81.49 110.32,81.49 110.45,81.36 110.45,81.16 110.58,81.03 110.9,81.03 111.01,81.14 111.01,81.61 111.14,81.74 111.47,81.74 111.6,81.61 111.6,81.14 111.75,81 112.04,81 112.19,81.14 112.19,81.61 112.31,81.74 112.64,81.74 112.77,81.61 112.77,80.55 112.9,80.42 113.27,80.42 113.42,80.57 113.42,81.61 113.55,81.74 113.88,81.74 114.01,81.61 114.01,80.55 114.14,80.42 114.47,80.42 114.6,80.55 114.6,81.28 114.73,81.41 115.06,81.41 115.19,81.28 115.19,80.57 115.34,80.42 122.63,80.42 127.56,75.5 128.16,75.5 132.14,71.52 134.24,71.52 136.98,68.79 v1(137.28,68.79)
  BOTTOM w0.14: v1(137.28,68.79) 137.28,68.26 136.32,67.3 JDIMM2.149
DDR_A_D41: length 72.1
  TOP w0.089: JCPU1.AK8 92.9,70.41 93.32,69.99 v3(93.41,69.99)
  TOP w0.14: JDIMM1.147 142.15,66.7 141.26,67.59 140.63,67.59 139.82,68.4 v1(139.82,68.79)
  IN1 w0.089: 104.49,78.48 100.55,78.48 97.58,75.51 97.18,75.51 96.81,75.15 96.81,74.76 95.55,73.5 95.16,73.5 94.82,73.15 94.82,72.77 94.56,72.51 94.32,72.51 93.39,71.59 93.39,70 v3(93.41,69.99)
  IN1 w0.147: v1(139.82,68.79) 139.89,68.79 140.02,68.66 140.02,68.08 139.89,67.95 139.55,67.95 139.42,68.08 139.42,68.2 139.3,68.33 138.95,68.33 138.83,68.2 138.83,68.08 138.7,67.95 136.74,67.95 133.93,70.77 131.83,70.77 127.91,74.69 127.3,74.69 122.82,79.17 117.73,79.17 117.54,79.37 117.54,79.55 117.41,79.67 117.12,79.67 117,79.55 117,79.32 116.85,79.17 116.56,79.17 116.41,79.32 116.41,79.53 116.26,79.67 115.97,79.67 115.82,79.53 115.82,79.32 115.67,79.17 115.38,79.17 115.23,79.32 115.23,79.53 115.08,79.67 114.79,79.67 114.64,79.53 114.64,79.32 114.49,79.17 114.2,79.17 114.05,79.32 114.05,79.53 113.9,79.67 113.61,79.67 113.46,79.53 113.46,79.3 113.33,79.17 113,79.17 112.87,79.3 112.87,79.53 112.72,79.67 112.43,79.67 112.28,79.53 112.28,79.32 112.13,79.17 111.84,79.17 111.69,79.32 111.69,79.53 111.54,79.67 111.25,79.67 111.1,79.53 111.1,79.32 110.96,79.17 110.66,79.17 110.51,79.32 110.51,79.53 110.37,79.67 110.07,79.67 109.92,79.53 109.92,79.32 109.78,79.17 109.56,79.17 109.35,79.39 109.05,79.39 108.15,78.48 104.49,78.48
  BOTTOM w0.14: v1(139.82,68.79) 139.82,68.47 140.52,67.77 140.83,67.77 142.2,66.4 JDIMM2.146
DDR_A_D42: length 71.9
  TOP w0.089: v1(91.4,68.92) 91.9,69.42 JCPU1.AJ9
  TOP w0.14: v1(137.44,71.73) 137.41,71.71 137.41,71.46 135.95,70 JDIMM1.158
  IN1 w0.089: 96.62,78.55 96.27,78.2 95.76,78.2 95.48,77.92 95.17,77.92 93.8,76.55 93.8,75.75 93.57,75.52 92.89,75.52 92.8,75.44 92.8,74.75 92.57,74.52 92.11,74.52 91.8,74.22 91.8,73.75 91.36,73.31 91.24,73.31 91,73.08 91,71.65 91.21,71.44 91.67,71.44 91.87,71.23 91.87,70.8 91.57,70.5 91.57,69.08 v1(91.4,68.92)
  IN1 w0.14: 100.76,81.19 99.26,81.19
  IN1 w0.147: 100.76,81.19 106.95,81.19 109.53,83.77 112.16,83.77 112.18,83.79 117.49,83.79 117.62,83.67 117.62,82.91 117.74,82.78 118.93,82.78 119.05,82.65 119.05,82.48 119.18,82.35 119.52,82.35 119.64,82.48 119.64,82.63 119.77,82.75 120.11,82.75 120.23,82.63 120.23,82.48 120.36,82.35 120.7,82.35 120.82,82.48 120.82,82.61 120.95,82.74 121.28,82.74 121.41,82.61 121.41,82.48 121.54,82.35 121.87,82.35 122,82.48 122,82.56 122.15,82.71 123.08,82.71 126.3,79.49 126.98,79.49 132.55,73.93 133.8,73.93 134.27,73.45 135.04,73.45 136.23,72.27 137.39,72.27 137.51,72.14 137.51,71.81 v1(137.44,71.73) ; 99.26,81.19 96.62,78.55
  BOTTOM w0.14: v1(137.44,71.73) 137.41,71.71 137.41,71.46 135.65,69.7 JDIMM2.157
DDR_A_D43: length 73.1
  TOP w0.089: JCPU1.AK9 91.57,70.78 91.57,70.78 v1(91.41,70.93)
  TOP w0.14: JDIMM1.160 135.98,70.6 136.93,71.55 136.93,71.95 137.17,72.19 138.3,72.19 138.68,71.81 v1(138.71,71.72)
  IN1 w0.089: v1(91.41,70.93) 91.08,70.93 90.82,71.19 90.82,73.15 91,73.33 91,74.08 91.44,74.52 91.8,74.52 91.97,74.69 91.97,75.05 92.24,75.32 92.37,75.32 93,75.95 93,76.08 95.09,78.17 95.48,78.17 95.73,78.42 95.86,78.42 95.99,78.55
  IN1 w0.147: 95.99,78.55 99,81.57 106.8,81.57 109.37,84.14 112,84.14 112.07,84.21 117.86,84.21 117.99,84.08 117.99,83.33 118.12,83.2 123.12,83.2 125.66,80.66 126.6,80.66 126.98,80.28 126.98,80.05 131.97,75.07 133.2,75.07 134.44,73.83 135.2,73.83 136.38,72.64 138.78,72.64 138.91,72.51 138.91,71.84 138.78,71.72 v1(138.71,71.72)
  BOTTOM w0.14: v1(138.71,71.72) 138.71,71.77 138.29,72.19 137.2,72.19 136.94,71.93 136.94,71.53 135.72,70.3 JDIMM2.159
DDR_A_D44: length 72.9
  TOP w0.089: v3(92.4,68.92) 92.87,68.45 JCPU1.AH8
  TOP w0.14: JDIMM1.146 136.36,66.4 138.55,68.59 v1(138.55,68.79)
  IN1 w0.089: v3(92.4,68.92) 93,69.52 93,71.63 94,72.63 94,73.08 94.24,73.32 94.62,73.32 94.98,73.68 94.98,74.06 97.46,76.54 97.94,76.54 99.22,77.83
  IN1 w0.147: 99.22,77.83 99.42,77.83 100.45,78.86 107.99,78.86 109.18,80.05 109.31,80.05 109.46,80.2 109.46,80.43 109.58,80.56 109.92,80.56 110.04,80.43 110.04,80.2 110.19,80.05 110.49,80.05 110.63,80.2 110.63,80.47 110.78,80.62 111.08,80.62 111.22,80.47 111.22,80.2 111.37,80.05 111.67,80.05 111.81,80.2 111.81,80.47 111.96,80.62 112.25,80.62 112.4,80.47 112.4,80.2 112.55,80.05 117.91,80.05 118.05,79.9 118.05,79.68 118.18,79.55 118.52,79.55 118.64,79.68 118.64,79.9 118.79,80.05 119.09,80.05 119.23,79.9 119.23,79.68 119.36,79.55 119.7,79.55 119.82,79.68 119.82,79.9 119.97,80.05 120.28,80.05 120.43,79.9 120.43,79.68 120.56,79.55 120.89,79.55 121.02,79.68 121.02,79.92 121.15,80.05 121.47,80.05 121.6,79.92 121.6,79.68 121.73,79.55 121.99,79.55 122.12,79.68 122.12,79.84 122.25,79.97 122.56,79.97 122.69,79.84 122.69,79.62 122.76,79.55 122.97,79.55 127.4,75.12 128.01,75.12 131.98,71.15 134.08,71.15 136.9,68.33 138.42,68.33 138.55,68.46 v1(138.55,68.79)
  BOTTOM w0.14: v1(138.55,68.79) 138.55,68.42 137.97,67.84 137.45,67.84 136.31,66.7 JDIMM2.147
DDR_A_D45: length 71.6
  TOP w0.089: v1(92.4,67.92) 91.9,68.42 JCPU1.AH9
  TOP w0.14: JDIMM1.149 142.21,67.3 141.09,68.42 v1(141.09,68.79)
  IN1 w0.089: v1(92.4,67.92) 92.92,68.44 92.92,69.01 93.23,69.31 93.3,69.31 93.81,69.82 93.81,70.25 93.57,70.49 93.57,71.51 94.38,72.32 94.62,72.32 95,72.7 95,73.08 95.24,73.32 95.62,73.32 97,74.7 97,75.08 97.24,75.32 97.64,75.32 100.43,78.11 104.49,78.11
  IN1 w0.147: v1(141.09,68.79) 142.95,68.79 143.08,68.66 143.08,67.71 142.95,67.58 136.59,67.58 133.77,70.4 131.67,70.4 127.76,74.31 127.15,74.31 122.66,78.8 109,78.8 108.3,78.11 104.49,78.11
  BOTTOM w0.14: JDIMM2.148 142.31,67 141.09,68.22 v1(141.09,68.79)
DDR_A_D46: length 71.3
  TOP w0.089: JCPU1.AL9 91.86,71.45 v3(91.4,71.91)
  TOP w0.14: JDIMM1.157 141.96,69.7 139.98,71.68 v1(139.98,71.72)
  IN1 w0.089: 97.15,78.55 96.63,78.02 95.92,78.02 95.52,77.62 95.21,77.62 93.98,76.4 93.98,75.68 93.64,75.34 93.26,75.34 93,75.08 93,73.95 92.56,73.51 92.18,73.51 91.8,73.14 91.8,72.31 v3(91.4,71.91)
  IN1 w0.147: 97.15,78.55 99.42,80.81 107.11,80.81 109.59,83.29 115.91,83.29 116.06,83.15 116.06,82.61 116.19,82.48 116.52,82.48 116.65,82.61 116.65,83.15 116.8,83.29 117.09,83.29 117.24,83.15 117.24,82.11 117.37,81.98 117.74,81.98 117.89,82.13 117.89,82.21 118.02,82.33 118.35,82.33 118.48,82.21 118.48,82.13 118.63,81.98 123.28,81.98 126.19,79.07 126.87,79.07 132.39,73.55 133.64,73.55 134.11,73.08 134.88,73.08 136.7,71.26 139.89,71.26 140.02,71.39 140.02,71.68 v1(139.98,71.72)
  BOTTOM w0.14: JDIMM2.158 141.68,70 141.35,70.33 141.35,70.77 140.85,71.27 140.42,71.27 139.98,71.7 v1(139.98,71.72)
DDR_A_D47: length 68.8
  TOP w0.089: v3(92.4,70.92) 92.9,71.42 JCPU1.AL8
  TOP w0.14: v1(141.25,71.72) 141.25,71.34 142.28,70.3 JDIMM1.159
  IN1 w0.089: v3(92.4,70.92) 92.4,71.31 92,71.71 92,73.08 92.24,73.32 92.62,73.32 93.29,73.99 93.29,74.24 93.8,74.75 93.8,74.98 94.34,75.52 94.57,75.52 94.84,75.79 94.84,77.01 95.27,77.43 95.59,77.43 96,77.85 96.76,77.85 97.47,78.55 97.94,78.55
  IN1 w0.147: v1(141.25,71.72) 141.3,71.72 141.43,71.59 141.43,71.01 141.3,70.89 136.54,70.89 134.73,72.7 133.96,72.7 133.48,73.18 132.22,73.18 126.78,78.61 126.11,78.61 123.12,81.6 116.53,81.6 115.22,82.92 109.75,82.92 107.24,80.41 99.81,80.41 97.94,78.55
  BOTTOM w0.14: v1(141.25,71.72) 141.25,71.39 141.38,71.26 141.64,71.26 141.72,71.18 141.72,70.73 141.84,70.6 JDIMM2.160
DDR_A_D48: length 77.7
  TOP w0.089: v3(90.4,74.92) 90.4,74.91 89.94,74.45 JCPU1.AP11
  TOP w0.14: JDIMM1.164 136.06,71.8 137.37,73.11 137.97,73.11 138.53,73.68 v1(138.53,73.92)
  IN1 w0.089: v3(90.4,74.92) 91.44,75.96 92.26,75.96 94.46,78.16 94.46,78.55
  IN1 w0.147: 94.46,78.55 98.31,82.39 106.45,82.39 109.03,84.97 111.66,84.97 111.72,85.03 122.46,85.03 122.59,84.91 122.59,84.11 122.67,84.03 123.47,84.03 123.83,83.66 124.04,83.66 124.67,84.29 124.85,84.29 125.08,84.05 125.08,83.87 124.46,83.24 124.46,83.04 124.66,82.83 124.87,82.83 125.6,83.56 125.78,83.56 126.02,83.32 126.02,83.14 125.27,82.4 125.27,82.22 125.87,81.63 126.04,81.63 126.79,82.37 126.97,82.37 127.24,82.11 127.24,81.9 127.01,81.67 127.01,81.48 127.24,81.25 127.42,81.25 127.65,81.48 127.86,81.48 128.13,81.21 128.13,81.01 128.11,80.98 128.11,80.77 128.31,80.57 128.52,80.57 128.54,80.59 128.75,80.59 128.95,80.39 128.95,80.11 128.91,80.07 128.91,79.89 129.15,79.65 129.33,79.65 129.37,79.69 129.65,79.69 129.92,79.42 129.92,79.22 129.88,79.18 129.88,79 130.12,78.76 130.3,78.76 130.33,78.8 130.54,78.8 130.81,78.53 130.81,78.25 130.48,77.91 130.48,77.73 130.72,77.5 130.89,77.5 131.28,77.88 131.46,77.88 131.73,77.61 131.73,77.43 131.34,77.05 131.34,76.87 132.31,75.9 133.55,75.9 134.78,74.66 135.54,74.66 136.73,73.47 138.6,73.47 138.73,73.6 138.73,73.8 138.6,73.92 v1(138.53,73.92)
  BOTTOM w0.14: JDIMM2.163 135.81,71.5 137.21,72.9 137.76,72.9 138.53,73.68 v1(138.53,73.92)
DDR_A_D49: length 76.7
  TOP w0.089: JCPU1.AN11 89.89,73.45 v5(89.41,72.96)
  TOP w0.14: v1(137.14,73.92) 137.13,73.92 137.16,73.89 137.16,73.52 136.93,73.29 136.66,73.29 136.27,72.9 136.27,72.53 136.14,72.4 JDIMM1.166
  IN1 w0.089: v5(89.41,72.96) 89.41,72.82 89.53,72.69 89.87,72.69 90,72.82 90,75.08 90.36,75.45 90.5,75.45 91.29,76.24 92.29,76.24 93.9,77.85 93.9,78.55
  IN1 w0.147: 93.9,78.55 98.12,82.77 106.3,82.77 108.87,85.35 111.5,85.35 111.57,85.41 111.67,85.41 111.8,85.54 111.8,85.83 111.93,85.96 112.26,85.96 112.39,85.83 112.39,85.54 112.52,85.41 112.85,85.41 112.98,85.54 112.98,85.83 113.1,85.96 113.44,85.96 113.57,85.83 113.57,85.54 113.69,85.41 114.03,85.41 114.16,85.54 114.16,85.83 114.28,85.96 114.62,85.96 114.75,85.83 114.75,85.54 114.87,85.41 115.21,85.41 115.33,85.54 115.33,85.83 115.46,85.96 115.8,85.96 115.92,85.83 115.92,85.54 116.05,85.41 116.39,85.41 116.51,85.54 116.51,85.83 116.64,85.96 116.98,85.96 117.1,85.83 117.1,85.54 117.23,85.41 117.56,85.41 117.69,85.54 117.69,85.83 117.82,85.96 118.15,85.96 118.28,85.83 118.28,85.54 118.41,85.41 118.74,85.41 118.87,85.54 118.87,85.83 119,85.96 119.33,85.96 119.46,85.83 119.46,85.54 119.59,85.41 119.92,85.41 120.05,85.54 120.05,85.83 120.18,85.96 120.51,85.96 120.64,85.83 120.64,85.54 120.77,85.41 121.1,85.41 121.23,85.54 121.23,85.82 121.35,85.95 121.7,85.95 121.83,85.82 121.83,85.54 121.96,85.41 122.61,85.41 123,85.02 123,84.53 123.13,84.4 123.78,84.4 123.86,84.48 123.86,84.6 123.93,84.67 125.21,84.67 126.4,83.48 126.4,82.91 126.56,82.75 127.12,82.75 132.15,77.72 132.15,77.33 131.87,77.05 131.87,76.87 132.18,76.56 132.36,76.56 132.78,76.99 132.98,76.99 133.22,76.75 133.22,76.57 133.17,76.52 133.17,76.4 133.3,76.27 133.7,76.27 133.7,76.27 133.71,76.27 134.94,75.03 135.7,75.03 136.8,73.92 v1(137.14,73.92)
  BOTTOM w0.14: JDIMM2.165 135.89,72.1 137.16,73.37 137.16,73.89 137.13,73.92 v1(137.14,73.92)
DDR_A_D50: length 80.2
  TOP w0.089: v3(88.41,71.92) 88.88,71.45 JCPU1.AL12
  TOP w0.14: v1(139.82,77.04) 139.82,77.04 140.26,76.6 140.54,76.6 141.04,76.1 141.04,75.78 141.39,75.43 141.56,75.43 141.89,75.1 JDIMM1.175
  IN1 w0.089: v3(88.41,71.92) 88.81,72.32 88.81,73.11 88.5,73.42 88.38,73.42 88.04,73.76 88.04,77.13 88.78,77.87
  IN1 w0.147: v1(139.82,77.04) 139.82,77.05 139.23,77.63 136.17,77.63 133.46,80.34 132.97,80.34 131.81,81.5 131.81,82.26 129.73,84.34 128.79,84.34 125.71,87.43 123.86,87.43 122.56,88.73 112.91,88.73 112.76,88.58 112.76,88.39 112.63,88.26 112.3,88.26 112.17,88.39 112.17,88.49 112.04,88.62 111.71,88.62 111.58,88.49 111.58,88.39 111.45,88.26 109.7,88.26 106.38,91.59 102.44,91.59 88.78,77.93 88.78,77.87
  BOTTOM w0.14: JDIMM2.174 142.2,74.8 141.81,75.2 141.57,75.2 139.82,76.94 v1(139.82,77.04)
DDR_A_D51: length 78.1
  TOP w0.089: JCPU1.AM12 88.9,72.45 v1(88.41,72.94)
  TOP w0.14: v1(141.09,77.05) 141.09,76.58 141.22,76.45 141.38,76.45 141.59,76.24 141.59,75.92 141.81,75.7 JDIMM1.177
  IN1 w0.089: v1(88.41,72.94) 88.41,73.07 87.83,73.65 87.83,77.21
  IN1 w0.14: 88.25,77.63 87.83,77.21
  IN1 w0.147: 88.25,77.63 88.25,77.93 102.29,91.97 106.53,91.97 109.39,89.11 109.67,89.11 109.82,88.96 109.82,88.79 109.97,88.64 110.26,88.64 110.41,88.79 110.41,88.96 110.56,89.11 122.71,89.11 124.01,87.81 125.86,87.81 128.95,84.72 129.89,84.72 132.19,82.42 132.19,81.65 133.12,80.72 133.62,80.72 136.27,78.07 140.3,78.07 141.09,77.27 v1(141.09,77.05)
  BOTTOM w0.14: JDIMM2.176 142.16,75.4 141.09,76.47 v1(141.09,77.05)
DDR_A_D52: length 78.8
  TOP w0.089: v1(89.4,71.94) 89.9,72.44 JCPU1.AM11
  TOP w0.14: JDIMM1.163 142.18,71.5 139.8,73.87 v1(139.8,73.92)
  IN1 w0.089: v1(89.4,71.94) 90.52,73.06 90.52,73.29 90.82,73.59 90.82,74.91 91.67,75.76 92.31,75.76 95.1,78.54 95.1,78.55
  IN1 w0.14: 98.95,82.02 98.56,82.02 95.73,79.19
  IN1 w0.147: 95.1,78.55 95.73,79.19 ; v1(139.8,73.92) 139.8,73.89 140.2,73.49 140.2,73.31 139.83,72.93 139.65,72.93 139.49,73.09 136.57,73.09 135.38,74.28 134.63,74.28 133.39,75.52 132.16,75.52 129.98,77.7 129.98,77.85 130.11,77.98 130.11,78.24 129.06,79.29 128.85,79.29 128.72,79.16 128.51,79.16 128.31,79.37 128.31,79.58 128.43,79.71 128.43,79.91 127.79,80.56 127.34,80.56 126.67,81.23 125.73,81.23 123.31,83.65 122.34,83.65 122.21,83.78 122.21,84.53 122.08,84.66 121.66,84.66 121.54,84.53 121.54,83.78 121.41,83.65 121.08,83.65 120.95,83.78 120.95,84.51 120.8,84.66 120.51,84.66 120.36,84.51 120.36,83.78 120.23,83.65 119.9,83.65 119.77,83.78 119.77,84.51 119.62,84.66 119.33,84.66 119.18,84.51 119.18,83.78 119.05,83.65 118.72,83.65 118.59,83.78 118.59,84.51 118.44,84.66 111.88,84.66 111.81,84.6 109.19,84.6 106.61,82.02 98.95,82.02
  BOTTOM w0.14: v1(139.8,73.92) 139.8,73.65 140.77,72.68 140.92,72.68 141.8,71.8 JDIMM2.164
DDR_A_D53: length 78.1
  TOP w0.089: JCPU1.AL11 89.88,71.45 89.35,70.93 v3(89.4,70.93)
  TOP w0.14: JDIMM1.165 142.19,72.1 141.07,73.21 v1(141.07,73.92)
  IN1 w0.089: v3(89.4,70.93) 89,71.33 89,73.11 89.34,73.44 89.47,73.44 89.82,73.79 89.82,75.9 90.28,76.37 90.43,76.37 91,76.94 91,77.08 91.91,77.99 92.75,77.99
  IN1 w0.147: 92.75,77.99 92.81,77.99 97.97,83.15 106.1,83.15 109.29,86.33 122.22,86.33 123.51,85.04 125.36,85.04 133.03,77.38 133.7,77.38 133.96,77.11 133.96,76.9 133.87,76.81 133.87,76.63 134.11,76.4 134.29,76.4 134.4,76.5 134.57,76.5 134.79,76.29 134.79,76.11 134.69,76 134.69,75.82 135.05,75.45 135.23,75.45 135.38,75.6 135.66,75.6 136.88,74.38 139.02,74.38 139.17,74.53 139.17,74.85 139.32,74.99 139.61,74.99 139.76,74.85 139.76,74.53 139.91,74.38 140.26,74.38 140.4,74.52 140.4,74.84 140.52,74.97 141.59,74.97 141.72,74.84 141.72,73.88 141.59,73.75 141.2,73.75 141.07,73.88 v1(141.07,73.92)
  BOTTOM w0.14: v1(141.07,73.92) 141.07,73.11 141.78,72.4 JDIMM2.166
DDR_A_D54: length 77.1
  TOP w0.089: JCPU1.AP12 88.9,74.39 v3(88.44,73.93)
  TOP w0.14: v1(137.28,77.04) 137.28,76.94 136.61,76.28 136.61,75.67 135.75,74.8 JDIMM1.174
  IN1 w0.089: 89.13,77.69 88.35,76.91 88.35,75.2 88.44,75.11 v3(88.44,73.93)
  IN1 w0.147: 89.13,77.69 89.13,77.75 102.6,91.21 106.22,91.21 109.55,87.89 113.1,87.89 113.23,88.02 113.23,88.19 113.39,88.35 113.66,88.35 113.82,88.19 113.82,88.01 113.95,87.89 114.3,87.89 114.43,88.01 114.43,88.21 114.57,88.35 114.87,88.35 115.02,88.21 115.02,88.01 115.14,87.89 115.48,87.89 115.61,88.01 115.61,88.23 115.73,88.35 116.07,88.35 116.19,88.23 116.19,88.01 116.32,87.89 116.74,87.89 116.86,88.01 116.86,88.21 117.01,88.35 117.31,88.35 117.45,88.21 117.45,88.01 117.58,87.89 117.92,87.89 118.04,88.01 118.04,88.23 118.17,88.35 118.51,88.35 118.63,88.23 118.63,88.01 118.76,87.89 119.1,87.89 119.22,88.01 119.22,88.21 119.37,88.35 119.66,88.35 119.81,88.21 119.81,88.03 119.96,87.89 120.25,87.89 120.4,88.03 120.4,88.21 120.55,88.35 120.84,88.35 120.99,88.21 120.99,88.03 121.14,87.89 121.43,87.89 121.58,88.03 121.58,88.21 121.73,88.35 122.02,88.35 122.17,88.21 122.17,88.03 122.32,87.89 122.87,87.89 123.7,87.05 125.55,87.05 128.64,83.97 129.57,83.97 131.44,82.11 131.44,81.34 132.81,79.97 133.31,79.97 136.06,77.22 137.1,77.22 v1(137.28,77.04)
  BOTTOM w0.14: JDIMM2.175 136.02,75.1 137.28,76.36 v1(137.28,77.04)
DDR_A_D55: length 79.9
  TOP w0.089: JCPU1.AN12 88.91,73.45 v1(89.4,73.94)
  TOP w0.14: JDIMM1.176 135.82,75.4 136.24,75.82 136.24,76.45 136.83,77.04 136.83,77.23 137.13,77.53 138.21,77.53 138.55,77.2 v1(138.55,77.04)
  IN1 w0.089: v1(89.4,73.94) 89.4,73.94 88.66,74.68 88.66,75.19 88.53,75.32 88.53,76.72 89.26,77.45
  IN1 w0.147: v1(138.55,77.04) 138.55,76.78 138.68,76.66 138.89,76.66 139.01,76.53 139.01,76.25 138.89,76.12 138.11,76.12 137.98,76.25 137.98,76.46 137.86,76.59 137.52,76.59 137.4,76.46 137.4,76.33 137.27,76.2 136.74,76.2 136.61,76.33 136.61,76.71 136.49,76.84 135.9,76.84 133.15,79.59 132.57,79.59 130.95,81.22 130.95,81.37 131.06,81.48 131.06,81.73 130.84,81.95 130.66,81.95 130.53,81.81 130.35,81.81 130.11,82.05 130.11,82.23 130.36,82.49 130.36,82.65 129.42,83.59 128.48,83.59 125.39,86.68 123.55,86.68 122.71,87.51 109.39,87.51 106.06,90.84 102.75,90.84 98.82,86.91 98.82,86.9 89.37,77.45 89.26,77.45
  BOTTOM w0.14: v1(138.55,77.04) 138.55,77.35 138.23,77.67 137.27,77.67 136.65,77.05 136.65,76.68 135.67,75.7 JDIMM2.177
DDR_A_D56: length 90.4
  TOP w0.089: JCPU1.AJ14 86.87,69.45 v3(86.4,69.92)
  TOP w0.14: v1(141.17,79.01) 141.43,79.01 141.68,78.75 141.68,77.95 142.13,77.5 JDIMM1.183
  IN1 w0.089: 85.81,77.63 85.81,73.94 86.24,73.52 86.52,73.52 86.8,73.24 86.8,72.78 86.48,72.45 86.08,72.45 85.81,72.19 85.81,70.51 v3(86.4,69.92)
  IN1 w0.147: v1(141.17,79.01) 141.77,79.01 141.9,79.13 141.9,80.02 141.77,80.14 137.64,80.14 137.14,80.65 135.92,80.65 134.9,81.67 134.9,84.31 132.97,86.24 131.62,86.24 129.32,88.54 127.87,88.54 127.76,88.65 127.76,90.88 127.56,91.07 127.16,91.07 127.04,90.95 127.04,90.53 126.91,90.41 126.51,90.41 126.38,90.53 126.38,90.95 126.25,91.07 121.88,91.07 121.35,91.6 110.13,91.6 108.18,93.55 100.82,93.55 97.45,90.18 97.45,89.37 85.81,77.73 85.81,77.63
  BOTTOM w0.14: v1(141.17,79.01) 141.17,78.2 142.17,77.2 JDIMM2.182
DDR_A_D57: length 90.8
  TOP w0.089: v1(86.4,68.92) 86.87,68.45 JCPU1.AH14
  TOP w0.14: JDIMM1.182 135.77,77.2 136.01,77.44 136.01,77.57 137.08,78.64 137.08,78.94 v1(137.02,79.01)
  IN1 w0.089: v1(86.4,68.92) 86.87,69.38 86.87,70.14 86.59,70.42 86.21,70.42 85.99,70.64 85.99,71.09 86.24,71.34 86.7,71.34 87.01,71.65 87.01,72.1 87.24,72.34 87.57,72.34 87.81,72.57 87.81,73.13 87.22,73.72 87.22,74 86.81,74.42 86.81,77.66
  IN1 w0.147: 86.81,77.66 98.22,89.07 98.22,89.88 101.13,92.79 107.87,92.79 109.39,91.28 109.39,90.47 109.53,90.32 109.83,90.32 109.98,90.47 109.98,90.7 110.12,90.85 110.42,90.85 110.56,90.7 110.56,90.47 110.71,90.32 111.09,90.32 111.24,90.47 111.24,90.7 111.38,90.85 111.68,90.85 111.82,90.7 111.82,90.47 111.97,90.32 112.27,90.32 112.41,90.47 112.41,90.7 112.56,90.85 112.86,90.85 113,90.7 113,90.47 113.15,90.32 113.45,90.32 113.59,90.47 113.59,90.7 113.74,90.85 114.03,90.85 114.18,90.7 114.18,90.47 114.33,90.32 114.62,90.32 114.77,90.47 114.77,90.72 114.9,90.85 115.23,90.85 115.36,90.72 115.36,90.47 115.51,90.32 115.88,90.32 116.03,90.47 116.03,90.7 116.18,90.85 116.47,90.85 116.62,90.7 116.62,90.47 116.77,90.32 121.6,90.32 121.75,90.17 121.75,90.06 121.88,89.93 122.21,89.93 122.34,90.06 122.34,90.19 122.47,90.32 122.85,90.32 122.97,90.19 122.97,90 123.1,89.88 123.46,89.88 123.58,90 123.58,90.19 123.71,90.32 124,90.32 125.68,88.63 126.71,88.63 128.36,86.99 129.01,86.99 129.07,86.92 129.28,86.92 129.49,87.13 129.67,87.13 129.9,86.89 129.9,86.71 129.58,86.39 129.58,86.21 129.93,85.87 130.11,85.87 130.43,86.19 130.61,86.19 130.85,85.95 130.85,85.77 130.54,85.47 130.54,85.24 131.25,84.53 131.43,84.53 131.84,84.94 133.21,84.94 134.15,84 134.15,81.36 136.5,79.01 v1(137.02,79.01)
  BOTTOM w0.14: JDIMM2.183 135.95,77.5 136.23,77.78 136.23,78.51 136.73,79.01 v1(137.02,79.01)
DDR_A_D58: length 90.5
  TOP w0.089: v1(85.41,71.84) 85.44,71.84 85.83,71.45 JCPU1.AL15
  TOP w0.14: v1(138.08,82.34) 138.08,81.77 137.59,81.28 137.46,81.28 136.38,80.2 JDIMM1.192
  IN1 w0.089: v1(85.41,71.84) 85.44,71.84 85.04,72.24 85.04,72.76 84,73.8 84,77.34
  IN1 w0.147: v1(138.08,82.34) 138.24,82.34 138.36,82.23 138.36,81.93 138.3,81.86 136.38,81.86 136.08,82.16 136.08,82.68 136.59,83.2 136.59,84.29 128.61,92.27 122.35,92.27 121.84,92.78 119.77,92.78 119.62,92.93 119.62,93.26 119.49,93.38 119.16,93.38 119.03,93.26 119.03,92.93 118.88,92.78 118.51,92.78 118.36,92.93 118.36,93.38 118.21,93.53 117.92,93.53 117.77,93.38 117.77,92.93 117.62,92.78 117.33,92.78 117.18,92.93 117.18,93.38 117.03,93.53 116.74,93.53 116.59,93.38 116.59,92.93 116.44,92.78 116.15,92.78 116,92.93 116,93.38 115.85,93.53 115.56,93.53 115.41,93.38 115.41,92.93 115.26,92.78 114.89,92.78 114.76,92.91 114.76,93.4 114.63,93.53 110.75,93.53 109.55,94.73 100.1,94.73 96.21,90.83 96.21,89.81 84.4,78 84.4,77.74 84,77.34
  BOTTOM w0.14: v1(138.08,82.34) 137.96,82.22 137.96,81.95 137.29,81.27 137.16,81.27 135.79,79.9 JDIMM2.191
DDR_A_D59: length 89.8
  TOP w0.089: v3(85.41,70.93) 85.47,70.93 85.9,70.5 JCPU1.AK15
  TOP w0.14: v1(136.56,82.33) 136.56,82.32 136.59,82.3 136.59,80.97 136.42,80.8 JDIMM1.194
  IN1 w0.089: 83.77,77.64 83.77,77.25 83.83,77.2 83.83,73.73 84.86,72.69 84.86,71.59 85.47,70.99 85.47,70.98 v3(85.41,70.93)
  IN1 w0.147: 83.77,77.64 84,77.87 84,78.12 95.83,89.96 95.83,90.98 99.95,95.1 109.71,95.1 110.9,93.91 119.99,93.91 120.14,93.76 120.14,93.28 120.27,93.16 120.6,93.16 120.73,93.28 120.73,93.76 120.88,93.91 121.17,93.91 121.32,93.76 121.32,93.28 121.45,93.16 121.78,93.16 121.91,93.28 121.91,93.76 122.06,93.91 122.35,93.91 122.5,93.76 122.5,92.78 122.63,92.65 122.96,92.65 123.09,92.78 123.09,93.78 123.21,93.91 123.55,93.91 123.68,93.78 123.68,92.78 123.8,92.65 124.18,92.65 124.33,92.8 124.33,93.78 124.45,93.91 124.79,93.91 124.92,93.78 124.92,92.8 125.06,92.65 128.76,92.65 137.08,84.33 137.08,82.74 136.68,82.33 v1(136.56,82.33)
  BOTTOM w0.14: v1(136.56,82.33) 136.56,81.19 135.87,80.5 JDIMM2.193
DDR_A_D60: length 90.4
  TOP w0.089: v3(86.4,71.92) 86.87,71.45 JCPU1.AL14
  TOP w0.14: v1(139.64,79.01) 139.71,79.01 140.62,78.09 141.02,78.09 142.21,76.9 JDIMM1.181
  IN1 w0.089: 86.33,77.72 86.33,77.56 86.01,77.23 86.01,74.78 86.35,74.43 86.53,74.43 87,73.97 87,72.61 86.4,72.02 v3(86.4,71.92)
  IN1 w0.147: v1(139.64,79.01) 139.76,79.12 139.76,79.64 139.63,79.77 139.28,79.77 139.16,79.64 139.16,79.59 139.03,79.46 138.69,79.46 138.56,79.59 138.56,79.64 138.44,79.77 138.1,79.77 137.98,79.64 137.98,79.59 137.85,79.46 137.48,79.46 137.35,79.59 137.35,79.91 137.22,80.04 136.88,80.04 136.75,79.91 136.75,79.81 136.64,79.7 136.35,79.7 134.52,81.52 134.52,84.16 132.82,85.86 131.47,85.86 129.17,88.16 127.71,88.16 127.32,88.56 127.32,88.75 127.19,88.88 127,88.88 126.87,89 126.87,89.28 127,89.41 127.26,89.41 127.38,89.54 127.38,89.9 127.26,90.03 126.19,90.03 126.06,90.16 126.06,90.34 125.93,90.46 125.6,90.46 125.47,90.34 125.47,90.03 125.34,89.9 124.95,89.9 124.82,90.03 124.82,90.56 124.68,90.7 121.19,90.7 121.04,90.84 121.04,91.1 120.92,91.22 120.58,91.22 120.45,91.1 120.45,90.82 120.33,90.7 119.99,90.7 119.86,90.82 119.86,91.1 119.74,91.22 119.4,91.22 119.27,91.1 119.27,90.82 119.15,90.7 118.81,90.7 118.69,90.82 118.69,91.1 118.56,91.22 118.19,91.22 118.06,91.1 118.06,90.82 117.93,90.7 117.6,90.7 117.47,90.82 117.47,91.04 117.29,91.22 109.97,91.22 108.02,93.17 100.98,93.17 97.83,90.02 97.83,89.22 86.33,77.72
  BOTTOM w0.14: JDIMM2.180 142.18,76.6 140.44,78.34 140.34,78.34 139.67,79.01 v1(139.64,79.01)
DDR_A_D61: length 91.2
  TOP w0.089: v1(86.4,70.92) 86.87,70.45 JCPU1.AK14
  TOP w0.14: v1(138.29,79.01) 138.29,78.88 137.7,78.3 137.27,78.3 136.38,77.41 136.38,77.29 135.69,76.6 JDIMM1.180
  IN1 w0.089: 87.61,77.87 86.99,77.25 86.99,74.49 87.43,74.05 87.43,73.77 87.99,73.21 87.99,72.33 87.98,72.32 87.98,71.69 87.61,71.32 87.24,71.32 86.84,70.92 v1(86.4,70.92)
  IN1 w0.147: v1(138.29,79.01) 138.33,78.97 138.33,78.6 138.24,78.52 136.46,78.52 133.77,81.21 133.77,82.55 133.47,82.86 132.39,82.86 129.75,85.5 129.49,85.5 129.27,85.28 129.03,85.28 128.66,85.65 128.66,85.83 129.03,86.19 129.03,86.37 128.79,86.61 128.61,86.61 128.26,86.26 128.05,86.26 127.77,86.53 127.77,86.74 127.83,86.8 127.83,86.98 127.6,87.22 127.42,87.22 127.34,87.14 127.16,87.14 126.93,87.38 126.93,87.56 127,87.63 127,87.81 126.76,88.05 126.58,88.05 126.52,87.99 126.32,87.99 126.05,88.26 125.35,88.26 125.23,88.37 125.23,88.55 125.11,88.68 124.79,88.68 124.66,88.55 124.66,88.38 124.53,88.26 124.2,88.26 123.89,88.56 123.89,88.77 124.26,89.14 124.26,89.32 124.03,89.56 123.85,89.56 123.48,89.19 123.27,89.19 122.9,89.56 121.63,89.56 121.48,89.71 121.48,89.8 121.34,89.94 121.04,89.94 120.89,89.8 120.89,89.71 120.75,89.56 120.45,89.56 120.3,89.71 120.3,89.8 120.16,89.94 119.86,89.94 119.72,89.8 119.72,89.71 119.57,89.56 119.27,89.56 119.13,89.71 119.13,89.8 118.98,89.94 118.68,89.94 118.54,89.8 118.54,89.71 118.39,89.56 118.09,89.56 117.95,89.71 117.95,89.8 117.8,89.94 117.51,89.94 117.36,89.8 117.36,89.71 117.21,89.56 116.92,89.56 116.77,89.71 116.77,89.8 116.62,89.94 116.33,89.94 116.18,89.8 116.18,89.71 116.03,89.56 115.74,89.56 115.59,89.71 115.59,89.8 115.44,89.94 115.15,89.94 115,89.8 115,89.71 114.85,89.56 114.48,89.56 114.33,89.71 114.33,89.8 114.18,89.94 113.89,89.94 113.74,89.8 113.74,89.71 113.59,89.56 113.3,89.56 113.15,89.71 113.15,89.8 113,89.94 112.71,89.94 112.56,89.8 112.56,89.71 112.42,89.56 112.12,89.56 111.97,89.71 111.97,89.8 111.83,89.94 111.53,89.94 111.38,89.8 111.38,89.71 111.24,89.56 110.94,89.56 110.79,89.71 110.79,89.8 110.65,89.94 110.35,89.94 110.21,89.8 110.21,89.71 110.06,89.56 109.76,89.56 109.62,89.71 109.62,89.8 109.47,89.94 109.19,89.94 109.01,90.13 109.01,91.12 107.71,92.42 102.1,92.42 87.61,77.93 87.61,77.87
  BOTTOM w0.14: v1(138.29,79.01) 138.29,78.59 137.84,78.14 137.12,78.14 135.87,76.9 JDIMM2.181
DDR_A_D62: length 92
  TOP w0.089: v1(85.41,69.92) 85.4,69.92 85.87,69.45 JCPU1.AJ15
  TOP w0.14: JDIMM1.191 142.06,79.9 141.35,80.61 141.35,81.87 141.13,82.09 v1(141.13,82.34)
  IN1 w0.089: 83.38,78.55 82.66,77.83 82.66,76.47 82.83,76.3 82.83,71.84 83.28,71.39 83.53,71.39 85.01,69.92 v1(85.41,69.92)
  IN1 w0.147: 83.38,78.55 83.38,78.57 92.56,87.75 92.56,88.77 99.64,95.85 110.02,95.85 111.22,94.66 126.79,94.66 126.92,94.53 126.92,93.53 127.04,93.4 127.5,93.4 127.63,93.53 127.63,94.11 127.78,94.26 128.07,94.26 128.22,94.11 128.22,93.55 128.37,93.4 129.07,93.4 139.47,83.01 140.47,83.01 v1(141.13,82.34)
  BOTTOM w0.14: JDIMM2.192 141.94,80.2 141.49,80.65 141.49,80.96 140.84,81.6 140.84,82.05 v1(141.13,82.34)
DDR_A_D63: length 94.7
  TOP w0.089: JCPU1.AH15 85.9,68.46 85.47,68.89 v3(85.41,68.89)
  TOP w0.14: v1(139.61,82.34) 139.6,82.34 139.58,82.36 139.61,82.34 139.61,82.39 140.03,82.8 141.32,82.8 141.83,82.3 141.83,80.71 142.04,80.5 JDIMM1.193
  IN1 w0.089: v3(85.41,68.89) 85.41,68.9 85.81,69.3 85.81,70.08 85.5,70.39 85.38,70.39 84.68,71.09 84.68,72.22 83.49,73.42 83.29,73.42 83.01,73.69 83.01,77.36 83.19,77.53
  IN1 w0.147: 83.19,77.53 83.19,77.85 92.93,87.59 92.93,88.62 99.79,95.48 109.87,95.48 111.06,94.28 125.18,94.28 125.29,94.18 125.29,93.15 125.42,93.03 125.75,93.03 125.88,93.15 125.88,94.16 126.01,94.28 126.41,94.28 126.54,94.16 126.54,93.15 126.67,93.03 128.92,93.03 139.6,82.34 v1(139.61,82.34)
  BOTTOM w0.14: JDIMM2.194 142.17,80.8 141.88,81.09 141.88,82.28 141.36,82.8 140.04,82.8 139.61,82.37 139.61,82.34 139.58,82.35 139.59,82.34 v1(139.61,82.34)
DDR_A_DQS0: length 78.3
  TOP w0.102: JCPU1.D4 96.9,44.44 v3(96.4,43.95)
  TOP w0.14: JDIMM1.12 135.96,23.8 136.02,23.75 136.02,23.56 136.08,23.49 136.27,23.49 137.62,22.15 138.82,22.15 138.89,22.23 138.89,22.55 138.8,22.64 v1(138.62,22.64)
  IN1 w0.089: v3(96.4,43.95) 96.14,43.68 96.14,43.5 96.24,43.4 96.4,43.4 96.53,43.52 96.85,43.52 97.02,43.35 97.02,41.16 96.54,40.68 96.54,39.72 96.5,39.69
  IN1 w0.147: v1(138.62,22.64) 138.66,22.64 138.71,22.59 138.71,22.26 138.62,22.18 136.45,22.18 134.79,20.52 123.85,20.52 123.81,20.56 122.1,20.56 121.87,20.79 111.97,20.79 109.02,23.74 107.17,23.74 106.03,24.88 97.5,24.88 94.42,27.96 94.42,35.73 94.64,35.95 94.64,37.82 96.5,39.69
  BOTTOM w0.14: v1(138.62,22.64) 138.7,22.71 138.7,23.11 139.07,23.48 140.37,23.48 140.79,23.06 140.98,23.06 141.41,23.49 141.94,23.49 142.25,23.8 JDIMM2.12
