# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_CPU_SVIDALRT#: length 20.8
  TOP w0.089: v5(71.39,69.95) 71.88,69.45 JCPU1.AJ29
  TOP w0.102: v1(62.08,81.73) 62.08,82.07 62.53,82.52 RC64.1
  BOTTOM w0.102: v1(62.08,81.73) 62.08,80.32 61.1,79.34 61.1,77.03 v2(61.85,76.27) 65.48,72.64 65.48,71.84 66.8,70.52 69.89,70.52 69.92,70.49 70.8,70.49 71.34,69.95 v5(71.39,69.95)
H_CPUPWRGD: length 52
  TOP w0.102: v1(65.96,88.58) 65.96,90.01 65.84,90.14 64.49,90.14 v2(63.85,90.78) 63.54,91.08 v1(63.14,91.08) ; UH4.AY11 36.9,109.29 v1(36.64,109.02)
  IN3 w0.102: v1(36.64,109.02) 36.76,108.9 40.64,108.9 41.41,108.13 41.41,104.38 42.61,103.19
  IN3 w0.127: 42.61,103.19 43.11,102.68 43.11,102.08 43.28,101.92 46.58,101.92 49.69,98.81 50.7,98.81 51.27,98.24 51.27,95.35 52.72,93.9 53.81,93.9 v1(55.55,92.16)
  BOTTOM w0.102: v1(55.55,92.16) 55.55,92.25 55.98,92.69 60.13,92.69 61.73,91.08 v1(63.14,91.08) ; v1(65.96,88.58) 66.47,88.08 RC8.1 68.57,87.49 68.57,85.84 68.06,85.34 RC46.1 68.06,83.96 68.43,83.59 RC27.1
H_CPUPWRGD_R: length 13.5
  TOP w0.089: v5(67.33,74.88) 67.33,74.88 67.33,74.88 67.76,74.45 JCPU1.AP33
  BOTTOM w0.102: RC27.2 68.43,81.6 68.3,81.47 68.07,81.47 67.94,81.34 67.94,81.15 68.07,81.02 68.83,81.02 68.96,80.89 68.96,80.64 68.83,80.51 68.07,80.51 67.94,80.39 67.94,80.13 68.07,80.01 68.88,80.01 69.01,79.88 69.01,79.62 68.88,79.5 68.07,79.5 67.94,79.37 67.94,79.12 68.07,78.99 68.74,78.99 68.87,78.86 68.87,78.61 68.74,78.48 68.07,78.48 67.94,78.35 67.94,77.84 67.46,77.36 v2(67.46,77.15) 67.46,75.02 v5(67.33,74.88)
H_CPUPWRGD_XDP: length 12.8
  BOTTOM w0.102: RC8.2 69.53,88.08 69.66,88.2 69.66,90.53 69.78,90.65 70.01,90.65 70.12,90.55 v2(70.12,89.79) 70.12,89.21 70.23,89.09 70.4,89.09 70.52,89.21 70.52,90.55 70.62,90.65 70.83,90.65 70.93,90.55 70.93,89.25 71.05,89.13 71.22,89.13 71.33,89.25 71.33,90.55 71.44,90.65 72.73,90.65 73.15,91.08 JXDP1.10
H_PM_SYNC: length 70.9
  TOP w0.089: v1(66.34,72.93) 66.82,72.45 JCPU1.AM34
  TOP w0.102: UH4.AP14 34.28,111.32 34.54,111.06 34.54,111.02 v1(34.61,110.96) ; v1(52.65,95.43) 52.94,95.14 55.78,95.14 57.38,93.54 59.61,93.54 63.54,89.61 63.54,85.47 63.96,85.05 63.96,82.84 64.2,82.6 v1(65.12,82.6)
  IN3 w0.102: v1(34.61,110.96) 38.78,110.96 38.81,110.99 39.93,110.99 41.49,109.42 41.49,108.85 42.68,107.66 42.68,105.86 43.06,105.47
  IN3 w0.127: v1(52.65,95.43) 52.61,95.47 52.61,95.54 51.76,96.39 51.76,98.41 50.77,99.4 49.85,99.4 46.08,103.18 44.98,103.18 44.4,103.75 44.4,104.97 44.13,105.23 43.31,105.23 43.06,105.47
  BOTTOM w0.102: v1(65.12,82.6) 65.12,82.19 65,82.07 64.28,82.07 64.16,81.95 64.16,81.78 64.28,81.66 65.36,81.66 65.48,81.54 65.48,81.37 65.36,81.26 64.25,81.26 64.13,81.14 64.13,80.97 64.25,80.85 65.35,80.85 65.47,80.73 65.47,80.56 65.35,80.44 64.34,80.44 64.22,80.32 64.22,80.16 64.34,80.04 65.36,80.04 65.48,79.92 65.48,79.75 65.36,79.63 64.37,79.63 64.25,79.51 64.25,79.34 64.37,79.22 65.64,79.22 65.78,79.08 65.78,78.08 66,77.86 66,76.25 65.52,75.77 65.52,74.5 66.31,73.7 66.31,72.96 v1(66.34,72.93) ; v1(34.61,110.96) 34.61,110.99 34.23,111.37 T63.1
H_PROCHOT#: length 439.5
  TOP w0.102: v1(154.21,118.68) 154.32,118.68 154.62,118.38 154.62,101.91 154.52,101.8 154.52,94.68 155.46,93.74 155.46,89.1 160.02,84.54 v1(162.33,84.54) ; v1(65.75,83.43) 65.75,82.55 65.33,82.13 64.1,82.13 63.1,81.14 61.09,81.14 60.36,81.86 58.34,81.86 57.85,81.37 v1(57.85,81) ; v1(173.75,43.55) 173.75,46.85 169.23,51.37 v1(169.23,52.98) ; v1(179.02,147.26) 178.89,147.13 Q47.1 176.93,147.13 176.6,147.47 R1180.2
  TOP w0.254: v1(20.56,76.62) 20.64,76.62 21.22,76.04 PR729.1 PR732.2 PC732.1
  IN1 w0.109: v1(162.33,84.54) 165.03,84.54 168.3,81.28 168.3,61.57 169.46,60.41 169.46,53.22 v1(169.23,52.98) ; v1(178.26,130.95) 178.2,130.9 178.2,130.38 176.21,128.38 170.25,128.38 169.47,127.6 163.66,127.6 154.75,118.68 v1(154.21,118.68) 154.21,118.33 149.54,113.65 118.57,113.65 116.37,111.46 113.28,111.46 112.87,111.05 102.74,111.05 102.73,111.05 101.38,111.05 100.42,110.1 97.24,110.1 96.71,109.57 94.61,109.57 86.28,101.24 83.73,101.24 81.86,99.38 79.11,99.38 78.64,99.85 75.57,99.85 75.07,99.35 74.33,99.35 71.91,96.93 69.57,96.93 65.54,92.9 65.54,90.03 64.7,89.19 64.7,86.97 65.75,85.93 v1(65.75,83.43)
  IN4 w0.109: v1(173.75,43.55) 174.86,42.43 174.86,36.41 173.79,35.33 173.79,30.26 175.61,28.44 188.17,28.44 190.91,31.17 202.73,31.17 214.68,19.23 223.37,19.23 228.52,14.07 240.37,14.07 v1(241.87,15.57) ; v1(57.85,81) 57.85,82.84 54.75,85.93 54.75,92.18 54.76,92.19 54.76,93.26 53.08,94.94 51.82,94.94 51.31,95.45 47.78,95.45 46.95,96.28 45.05,96.28 44.65,95.89 44.65,94.74 44.01,94.1 41.28,94.1 41.02,94.37 41.02,95.34 39.78,96.58 39.03,96.58 38.65,96.96 34.78,96.96 34.64,96.83 34.07,96.83 33.06,95.81 30.57,95.81 30.35,95.59 27.86,95.59 26.92,94.65 26.29,94.65 26.17,94.54 25.17,94.54 23.05,92.41 v1(21.59,92.41)
  BOTTOM w0.102: PR935.2 242,15.71 v1(241.87,15.57) ; v1(65.75,83.43) 65.5,83.68 CC92.1 65.05,83.86 65.32,84.13 RC16.2 66.29,83.83 66.29,83.34 66.39,83.24 RC22.1 ; 21.79,89.31 22.1,89.61 22.1,91.91 v1(21.59,92.41) ; 21.79,89.31 21.79,89.32 20.65,88.18 19.39,88.18 18.76,87.54 17.41,87.54 16.61,86.74 16.61,80.46 20.45,76.62 v1(20.56,76.62) ; 21.79,89.31 v2(21.74,89.26) ; v1(179.02,147.26) 177.73,145.97 176.78,145.97 176.1,145.29 176.1,139.97 173.38,137.25 173.38,135.62 173.54,135.46 173.54,130.88 174.44,129.99 177.29,129.99 v1(178.26,130.95)
H_PROCHOT#_R: length 12.2
  TOP w0.089: v1(68.34,71.88) 68.77,71.45 JCPU1.AL32
  BOTTOM w0.102: 66.67,73.68 67.59,72.77 67.59,72.56 68.26,71.88 v1(68.34,71.88) ; 66.67,73.68 65.71,74.65 65.71,75.69 66.19,76.17 66.19,81.68 RC22.2 ; 66.67,73.68 v2(66.67,73.69)
H_SNB_IVB#: length 100.1
  TOP w0.102: JCPU1.C26 74.9,43.41 74.31,42.81 v1(74.31,40.08) ; RH150.1 v1(38.2,101.83)
  IN3 w0.127: v1(52.69,45.34) 52.96,45.34 53.47,45.85 53.47,48.48 53.12,48.82 53.12,50.33 54.96,52.18 54.96,67.56 55.71,68.3 55.71,78.94 53.34,81.32 53.34,90.69 52.93,91.1 52.93,92.14 51.27,93.8 48.66,93.8 48.27,94.2 48.27,97.33 45.39,100.21 41.11,100.21 40.73,100.6 40.36,100.6 39.91,101.04 38.99,101.04 v1(38.2,101.83)
  BOTTOM w0.102: v1(74.31,40.08) v2(70.57,40.08) 65.56,40.08 63.6,38.13 60.25,38.13 57.59,40.78 56.98,40.78 52.69,45.07 v1(52.69,45.34)
H_THERMTRIP#: length 157
  TOP w0.102: v1(110.74,135.14) 110.74,134.94 109.75,133.95 109.75,132.4 109.54,132.18 109.54,131.55 108.71,130.72 108.1,130.72 106.69,129.31 106.69,128.3 100.49,122.11 100.49,121.13 96.63,117.27 96.63,114.36 98.88,112.12 98.88,110.17 95.26,106.55 86.16,106.55 85.72,106.99 83.29,106.99 81.86,105.56 81.86,104.36 79.12,101.61 79.12,98.22 76.8,95.9 75.94,95.9 75.32,95.28 71.89,95.28 70.33,93.71 70.33,88.19 v1(70.43,88.09) ; Q28.3 v1(149.82,166.12) ; v1(112.6,150.36) 112.6,150.44 111.62,151.42 111.62,166.22 v1(112.41,167.01)
  IN2 w0.127: v1(132.14,166.43) 132.14,166.45 129.96,168.63 114.03,168.63 v1(112.41,167.01)
  BOTTOM w0.102: v1(149.82,166.12) 149.35,165.65 142.72,165.65 141.93,164.86 133.72,164.86 v1(132.14,166.43) ; RC24.1 69.44,84.3 69.17,84.57 RC14.2 69.17,85.2 69.65,85.67 69.65,87.3 v1(70.43,88.09) ; v1(110.74,135.14) 110.59,135.29 110.59,137.3 112.62,139.33 112.62,142.05 112.03,142.65 v2(112.03,147.3) 112.03,148.26 112.51,148.74 112.51,150.27 v1(112.6,150.36)
H_THERMTRIP#_R: length 9.5
  TOP w0.089: v1(68.35,73.97) 68.36,73.97 68.88,73.45 JCPU1.AN32
  BOTTOM w0.102: RC24.2 69.44,78.6 v2(69.26,78.42) 67.88,77.04 67.88,74.8 68.35,74.33 v1(68.35,73.97)
HDD1_DET#: length 217.3
  TOP w0.102: v1(202.6,63.32) 203.1,62.83 203.1,55.59 202.47,54.97 200.42,54.97 JSATA1.12
  IN2 w0.127: v1(32.89,99.49) 33.48,100.08 37,100.08 37.1,100.18 42.24,100.18 42.72,99.7 47.63,99.7 48.53,100.6 58.66,100.6 59.6,99.66 63.37,99.66 66.91,96.12 74.02,96.12 75.63,97.73 82.44,97.73 82.81,98.1 108.97,98.1 109.53,97.54 128.94,97.54 131.77,100.37 148.98,100.37 150.53,98.82 172.51,98.82 173.98,97.35 173.98,94.28 177.88,90.37 181.68,90.37 183.22,88.84 183.22,85.24 185.75,82.72 185.75,69.71 189.85,65.61 198.4,65.61 200.68,63.32 v1(202.6,63.32)
  BOTTOM w0.102: RH290.2 RH30.1 29.58,99.9 v2(31.53,99.9) 32.03,99.9 32.07,99.94 32.45,99.94 v1(32.89,99.49)
HDD2_DET#: length 138.4
  TOP w0.102: v1(21.49,93.04) v2(23.37,93.04) 24.2,93.04 25.13,93.97 QH1.3 ; JSATA2.12 83.05,30.53 v1(82.78,30.26)
  IN1 w0.109: v1(21.49,93.04) 21.22,92.77 14.48,92.77 14.1,92.39 14.1,76.8 9.5,72.2 9.5,66.05 14.2,61.35 24.89,61.35 28.64,57.61 28.64,49.4 31.58,46.46 31.58,42.46 33.35,40.69 36.8,40.69 38.28,39.22 v1(38.29,39.22)
  IN4 w0.109: v1(38.29,39.22) 39.84,39.22 40.13,38.93 43.22,38.93 44.23,37.91 59.28,37.91 66.83,30.37 71.94,30.37 72.6,31.03 82.02,31.03 v1(82.78,30.26)
HDD_DET#_R: length 63.2
  TOP w0.102: RH13.1 72.11,97.94 71.46,97.3 67.78,97.3 67.25,96.76 v1(65.11,96.76) ; UH4.V14 26.36,111.32 v1(26.69,110.99)
  IN2 w0.127: v1(65.11,96.76) 65.11,96.92 62.83,99.2 59.41,99.2 58.47,100.14 48.72,100.14 47.58,99 38.92,99 38.54,99.38 33.79,99.38 33.23,98.82 30.57,98.82 30.21,99.19 29.13,99.19 v1(28.68,98.73)
  BOTTOM w0.102: v1(26.69,110.99) 27.21,110.47 27.21,108.85 28.12,107.94 28.12,106.27 27.81,105.96 27.61,105.96 27.34,105.69 27.34,105.12 27.01,104.79 27.01,103.23 28.08,102.16 v2(28.36,102.16) 28.36,101.19 RH290.1 28.29,101.12 27.85,100.69 27.85,99.56 v1(28.68,98.73)
HDD_EN_5V: length 7.6
  TOP w0.102: v2(188.36,58.03) Q27.3
  TOP w0.254: R499.2 185.77,58.14 R1630.1 184.9,59.01 Q300.3 186.52,59.57 C393.1 187.2,59.55 187.44,59.31 Q27.3
HDD_FALL_INT: length 242.5
  TOP w0.305: v1(127.06,107.98) 127.06,107.5 R503.2 125.8,106.24 125.8,104.75 125.83,104.71 U88.11
  IN2 w0.305: v1(173.43,123.55) 173.37,123.48 173.32,123.48 168.69,128.11 164.73,128.11 164.31,127.69 157.22,127.69 151.83,133.08 138.03,133.08 137.56,132.61 132.89,132.61 132.23,131.95 130.44,131.95 129.96,131.47 114.78,131.47 114.53,131.22 107.17,131.22 106.94,131.45 106.89,131.5 105.56,131.5 105.24,131.81 105.24,131.81 104.61,132.45 84.76,132.45 84.11,133.1 82.59,133.1 82.5,133.19 82.5,133.19 82,133.69 81.4,133.69 79.79,132.08 77.34,132.08 76.1,133.33 74.52,133.33 73.3,134.54 70.88,134.54 70.47,134.95 70.47,135.42 68.04,137.86 65.01,137.86 64.48,138.39 61.72,138.39 61.16,137.83 55.15,137.83 55.02,137.71 47.8,137.71 44.79,134.7 36.57,134.7 35.76,135.51 29.11,135.51 27.41,137.21 27.41,137.53 27.27,137.67 25.8,137.67 25.45,138.02 25.45,138.56 25.42,138.58 25.42,138.59 25.11,138.9 24.67,138.9 24.53,138.76 22.48,138.76 22.45,138.72 22.43,138.72 21.54,137.83 21.54,137.23 20.05,135.75 19.02,135.75 18.58,135.31 18.5,135.31 18.12,134.93 18.12,134.48 18.16,134.44 18.16,133.86 18.1,133.8 18.1,132.75 17.16,131.81 17.16,130.66 v1(16.83,130.33)
  BOTTOM w0.305: v1(16.83,130.33) 17.12,130.04 RH334.1 ; v1(173.43,123.55) 173.39,123.55 172.92,124.02 167.38,124.02 164.93,126.47 v2(154.13,126.47) 152.21,124.55 152.21,119.55 148.47,115.81 140.59,115.81 139.67,116.73 133.69,116.73 131.16,114.2 131.16,113.73 127.06,109.63 v1(127.06,107.98)
HDMI_CEC: length 4.2
  BOTTOM w0.102: JHDMI1.13 34.52,167.73 34.52,167.04 34.14,166.66 v2(34.14,165.65) 33.88,165.39 R1165.1
HDMI_HPD_SINK: length 24.2
  TOP w0.102: R1164.1 R1128.1 v2(41.25,163.42) 40.51,163.42 37.13,160.05 37.13,158.95 36.97,158.79 36.97,155.94 39.5,153.42 40.66,153.42 40.8,153.28 43.22,153.28 43.69,152.81 43.69,152.25 44.68,151.26 44.68,150.47 44.57,150.37 U9.17
HDMI_HPD_SINK_R: length 4.4
  TOP w0.102: R1164.2 40.23,166.51 39.71,167.03 38.9,167.03 38.26,167.67 37.58,167.67 JHDMI1.19
HDMI_SCL_SINK: length 36.5
  TOP w0.127: v1(42.3,141.39) 42.15,141.54 42.15,141.94 42.17,141.96 U9.48 ; R461.2 36.81,166.15 36.04,166.92 v1(36.04,167.13)
  IN4 w0.109: v1(36.04,167.13) 36.04,166.94 35.91,166.82 34.63,166.82 34.52,166.93 34.52,167.85 JHDMI1.15
  BOTTOM w0.127: v1(42.3,141.39) 41.93,141.76 41.93,142.85 v2(41.43,143.36) 39.34,145.44 39.34,150.42 38.77,150.99 38.77,156.09 39.47,156.79 39.47,165.13 37.15,167.45 36.16,167.45 36.04,167.34 v1(36.04,167.13)
HDMI_SDA_SINK: length 36.6
  TOP w0.127: R460.2 38,166.15 37.25,166.9 36.89,166.9 36.88,166.9 v3(36.79,166.9) ; U9.47 41.77,141.96 41.87,141.87 41.87,141.59 v1(41.67,141.39)
  IN4 w0.127: JHDMI1.16 36.03,169.86 36.7,169.86 37.57,169 37.57,167.83 36.79,167.06 v3(36.79,166.9)
  BOTTOM w0.127: v3(36.79,166.9) 37.29,166.9 39.22,164.97 39.22,156.89 38.52,156.19 38.52,150.89 39.09,150.31 39.09,145.21 41.67,142.63 v1(41.67,141.39)
HOST_DEB_RX: length 9
  TOP w0.102: v2(211.4,119.65) 211.26,119.51 211.26,118.03 211.73,117.57 R855.1 211.52,117.35 211.52,116.13 211.77,115.88 212.09,115.88 213.19,114.77 213.19,113.31 212.82,112.94 JDEG2.9
HOST_DEB_TX: length 5.8
  TOP w0.102: JDEG2.8 209.69,112.44 209.95,112.7 209.95,115.79 209.61,116.13 v3(209.6,116.13) 209.23,115.76 R853.1
HOST_DEBUG_RX: length 148
  TOP w0.102: R849.2 R855.2 212.68,117.04 v1(211.95,116.31) ; v1(169.9,148.12) 170.34,148.57 170.88,148.57 170.94,148.63 U54.B46 ; v1(173.98,135.16) 173.97,135.16 173.37,134.56 173.37,125.33 174.24,124.45 174.24,121.2 173.86,120.82 173.86,116.79 180.08,110.57 180.08,106.54 178.57,105.03 178.57,102.33 177.72,101.47 177.72,97.35 180.26,94.81 180.26,93.49 179.75,92.98 178.93,92.98 178.46,92.5 178.46,91.03 179.77,89.72 179.77,89.12 180.57,88.32 v1(180.59,88.32)
  IN1 w0.109: v1(173.98,135.16) 173.98,135.17 174.13,135.17 174.53,135.57 174.99,135.57 175.23,135.81 175.23,141.79 174.99,142.02 174.99,142.88 172.86,145.02 172.86,145.57 170.75,147.68 170.34,147.68 v1(169.9,148.12)
  IN4 w0.109: v1(208.81,132.13) 210.33,130.61 210.33,120.97 211.95,119.35 v1(211.95,116.31)
  BOTTOM w0.102: v1(208.81,132.13) 208.63,131.94 201.76,131.94 201.68,132.02 198.08,132.02 197.27,132.83 190.52,132.83 189.54,133.81 187.88,133.81 186.78,134.91 184.94,134.91 183.79,133.77 180.97,133.77 180.29,134.46 174.68,134.46 v1(173.98,135.16) ; JMINI2.17 192.69,89.63 191.79,88.72 189.46,88.72 189.13,88.39 v2(189.13,86.93) 189.13,86.13 188.13,85.13 182.54,85.13 182.46,85.21 181.65,85.21 180.88,85.98 180.88,86.79 180.17,87.5 180.17,87.9 v1(180.59,88.32)
HOST_DEBUG_TX: length 110.9
  TOP w0.102: v1(209.52,119.09) 208.79,119.83 R848.2 ; R853.2 207.78,115.31 v1(207.58,115.11) ; U54.B44 170.83,147.63 170.56,147.36 v1(170.56,147.22) ; v1(174.76,136.02) 175.31,135.47 175.31,134.2 174.05,132.94 174.05,125.98 175.13,124.9 175.13,116.17 180.72,110.58 180.72,106.6 179.03,104.92 179.03,102.14 178.41,101.51 v2(178.41,98.26) 178.41,97.82 v1(178.99,97.23)
  IN1 w0.109: v1(170.56,147.22) 170.88,147.22 172.63,145.47 172.63,144.92 174.76,142.79 174.76,141.73 175,141.49 175,136.23 174.79,136.02 v1(174.76,136.02)
  IN3 w0.127: v1(178.99,97.23) 179.27,97.23 179.49,97.45 186.51,97.45 186.71,97.65 188.25,97.65 193.43,102.83 194.36,102.83 194.97,102.22 v1(194.99,102.25) 196.34,102.25 197.38,103.29 197.38,106.44 198.01,107.07 202.48,107.07 203.69,108.29 204.6,108.29 206.96,110.66 v1(207.02,110.66)
  BOTTOM w0.102: JMINI2.16 196.29,99.53 195.87,99.95 195.87,100.84 196.44,101.41 C595.1 195.86,101.7 195.31,102.25 v1(194.99,102.25) ; v1(207.02,110.66) 206.53,111.15 206.53,114.06 v1(207.58,115.11) 207.78,115.31 207.78,117.65 209.22,119.09 v1(209.52,119.09)
HSYNC: length 5.3
  TOP w0.102: UH4.M47 23.23,127.68 23.54,127.98 23.54,128.8 23,129.34 23,129.93 v2(22.5,130.44) 21.69,131.24 RH123.2
HSYNC_BUF: length 10.5
  TOP w0.102: R43.1 66.07,164.69 v2(63.13,161.75) 61.89,160.51 v1(61.89,158.14)
  BOTTOM w0.102: U19.37 62.17,157.09 62.33,157.25 62.33,157.7 v1(61.89,158.14)
HSYNC_DOCK: length 62.4
  IN3 w0.127: v1(58.15,154.74) 59.5,154.74 64.08,150.15 66.84,150.15 70.9,146.1 72.29,146.1 74.79,143.6 76.88,143.6 78.17,142.31 78.17,140.08 80.87,137.38 84.16,137.38 85.74,135.8 85.74,134.05 87.32,132.46 90.93,132.46 97.48,125.91 97.48,123.1 v3(97.72,122.86)
  BOTTOM w0.102: JDOCK1.65 98.74,121.85 v3(97.72,122.86) ; v1(58.15,154.74) 58.4,154.99 U19.28
HSYNC_L: length 11.1
  TOP w0.102: v3(65.68,170.22) 65.68,170.21 65.6,170.12 C19.1 65.6,168.92 65.12,168.44 R52.2 65.58,167.92 65.71,168.05 L4.2
  IN1 w0.109: JCRT1.13 60.31,171.7 60.31,171.7 61.8,170.22 v3(65.68,170.22)
HW_GPS_DISABLE2#: length 224.1
  IN2 w0.127: v1(98.22,164.07) 101.48,164.07 105.87,159.69 112.2,159.69 112.61,159.28 116.86,159.28 122.29,153.86 124.92,153.86 129.67,158.61 133.11,158.61 134.42,159.92 136.31,159.92 136.76,160.38 145.15,160.38 145.55,160.78 147.69,160.78 148.08,160.39 150.07,160.39 151.1,159.36 153.82,159.36 158.11,163.65 172.24,163.65 172.97,162.92 174.31,162.92 176.36,160.86 182.12,160.86 183.25,161.99 185.77,161.99 186.35,161.42 191.93,161.42 193.17,160.19 194.98,160.19 196.06,161.27 196.77,161.27 200.86,157.18 205.83,157.18 210.37,152.63 210.37,149.02 210.75,148.64 210.75,104.94 211.68,104.01 213.06,104.01 217.47,99.6 217.47,98.02 227.19,88.3 228.1,88.3 232.38,84.02 232.38,83.81 v1(232.43,83.76)
  BOTTOM w0.102: v1(98.22,164.07) 98.85,163.45 JMINI1.51 ; v1(232.43,83.76) 230.9,83.76 v2(230.8,83.66) 229.82,82.68 229.55,82.68 227.78,80.9 227.78,78.99 228.16,78.6 R798.2 228.68,77.31 229.58,77.31 230.06,76.82 231.32,76.82 231.94,76.2 U46.B34
ICOUT: length 5.4
  TOP w0.254: PU901.26 v2(175.88,36.06) 175.61,36.32 PC908.1 PR918.2
IMVP_PWRGD: length 368.4
  TOP w0.254: v1(32.03,72.02) 31.51,72.54 PR736.2 ; v1(27.79,87.12) 27.6,86.93 v2(27.6,86.56) 27.6,86.25 27.02,85.67 PR707.2
  IN1 w0.127: v1(242.87,60.69) 242.81,60.63 242.81,60.59 242.52,60.3 241.77,60.3 241.44,60.63 241.44,67.79 243.06,69.41 243.06,69.44 243.04,69.45 243.04,69.45 243.04,69.43 v1(243.05,69.43)
  IN1 w0.254: v1(23.23,74.97) 23.51,75.25 23.51,75.84 24.41,76.75 27.91,76.75 28.38,76.28 28.38,73.6 29.53,72.45 31.6,72.45 v1(32.03,72.02)
  IN2 w0.127: v1(23.23,74.97) 22.79,74.97 22.1,74.28 22.1,73.76 20.93,72.58 20.93,67.87 30.2,58.6 30.2,52.01 35.85,46.36 35.85,36.96 34.01,35.12 34.01,21.43 34.98,20.46 35.18,20.26 35.41,20.04 35.41,12.89 37.06,11.24 94.33,11.24 96.58,13.49 96.58,20.99 97.59,22 105.13,22 105.69,21.44 106.91,21.44 111.2,17.15 111.8,17.15 112.69,18.03 112.82,18.16 112.83,18.16 113.02,18.35 118.34,18.35 118.57,18.12 119.44,18.12 119.98,17.58 124.27,17.58 125.33,16.52 131.95,16.52 133.21,15.26 133.84,15.26 150.22,15.26 152.58,17.62 154.94,17.62 156.5,19.18 158.93,19.18 159.24,19.5 161.82,19.5 165.5,23.18 v1(165.86,23.18)
  IN3 w0.127: v1(242.87,60.69) 242.81,60.63 242.81,60.59 241.36,59.14 234.86,59.14 233.93,60.07 232.35,60.07 231.46,60.97 231.46,60.99 231.2,61.24 223.91,61.24 223.9,61.23 223.05,61.23 221.37,62.9 208.62,62.9 202.39,56.67 200.56,56.67 199.68,55.79 198.14,55.79 197.38,55.03 193.5,55.03 192.86,54.39 192.86,54.38 190.36,51.88 187.58,51.88 186.98,51.28 181.58,51.28 180.5,50.2 179.15,50.2 178.32,49.38 174.08,49.38 165.83,41.13 165.83,35.8 164.8,34.78 164.8,24.2 165.82,23.18 v1(165.86,23.18)
  IN3 w0.254: v1(23.23,74.97) 23.23,75.69 25.16,77.62 25.16,80.56 26.69,82.1 26.69,85.5 27.24,86.04 27.24,86.58 v1(27.79,87.12)
  BOTTOM w0.127: U46.A62 243.04,69.45 243.04,69.43 v1(243.05,69.43)
  BOTTOM w0.254: PR734.2 31.54,72.53 32.03,72.05 v1(32.03,72.02)
IMVP_VR_ON: length 339.1
  IN1 w0.109: v1(245.73,66.08) 242.48,66.08 241.72,65.32 241.72,61.09 242.06,60.74 v1(242.19,60.74)
  IN2 w0.127: v1(19.75,74.64) 19.35,74.64 18.46,73.75 18.46,70.01 29.97,58.51 29.97,51.91 35.56,46.32 35.56,36.99 33.78,35.21 33.78,21.62 33.4,21.24 33.4,14.39 36.8,10.99 94.45,10.99 96.81,13.34 96.81,20.9 97.68,21.77 105.04,21.77 105.6,21.21 106.81,21.21 111.1,16.92 111.9,16.92 112.91,17.93 112.93,17.93 113.1,18.11 118.26,18.11 118.48,17.89 118.94,17.89 120.18,16.65 122.34,16.65 122.85,16.14 124.88,16.14 124.89,16.15 130.16,16.15 130.74,15.56 132.59,15.56 132.64,15.51 133.12,15.03 150.32,15.03 152.67,17.39 155.03,17.39 156.57,18.92 158.99,18.92 159.02,18.95 159.31,19.24 162.29,19.24 165.35,22.3 165.67,22.3 v1(165.84,22.14)
  IN3 w0.127: v1(242.19,60.74) 240.82,59.37 234.95,59.37 234.02,60.3 232.46,60.3 231.68,61.07 231.68,61.09 231.3,61.47 223.14,61.47 221.47,63.13 208.52,63.13 202.37,56.99 198.5,56.99 196.77,55.26 193.39,55.26 192.63,54.5 192.63,54.48 191.76,53.61 186.69,53.61 185.65,52.57 182.29,52.57 180.23,50.5 179.12,50.5 178.25,49.63 174.01,49.63 165.6,41.22 165.6,35.9 164.57,34.87 164.57,23.4 v1(165.84,22.14)
  BOTTOM w0.102: v1(19.75,74.64) 20.03,74.64 20.2,74.82 20.8,74.82 20.98,74.99 PR730.1 21.22,74.34 v2(21.52,74.03) ; R771.2 245.69,66.27 245.73,66.23 v1(245.73,66.08)
INIT3_3V#: length 1.6
  TOP w0.102: v1(24.7,110.97) 24.74,110.97 25.06,111.3 UH4.T14
  BOTTOM w0.102: T106.1 24.18,110.45 v1(24.7,110.97)
INTRUDER#: length 16.9
  TOP w0.102: v2(12.32,116.98) 11.89,117.41 RH11.2 10.88,117.05 v1(10.88,116.47) ; v1(21.69,114.38) 21.69,114.58 UH4.K22
  IN4 w0.102: 18.77,114.83 17.63,113.69 16.36,113.69
  IN4 w0.109: v1(10.88,116.47) 10.88,116.54 11.3,116.95 11.75,116.95 12.05,116.65 12.05,116.31 11.99,116.24 11.99,115.49 12.32,115.15 12.32,114.88 13.52,113.69 16.36,113.69 ; v1(21.69,114.38) 21.24,114.83 18.77,114.83
IRQ_SERIRQ: length 307.8
  TOP w0.102: U54.A28 168.47,140.96 168.52,140.91 168.52,140.9 168.58,140.84 v1(168.57,140.84) ; v1(167.63,136.18) 167.63,128.12 166.41,126.9 166.41,125.69 166.66,125.44 166.66,107.76 v1(166.88,107.54) 167.37,107.05 167.37,106.65 166.96,106.24 U37.27 U39.27 166.96,100.48 v1(166.79,100.31) ; UH4.V5 26.38,106.75 v1(26.68,107.05) ; v1(223.96,67.93) 223.96,69.05 224.23,69.32 224.81,69.32 225.03,69.1 231.09,69.1 231.69,69.7 v1(233.05,69.7)
  IN1 w0.109: v1(167.63,136.18) 167.75,136.3 167.75,137.35 168.77,138.37 168.77,140.64 v1(168.57,140.84)
  IN2 w0.102: v1(26.68,107.05) 27.27,106.46 27.27,106.26 27.63,105.89 27.96,105.89 28.52,105.33 33.75,105.33 34.45,106.04 34.79,106.04 35.4,105.43 39.91,105.43 41.04,106.56 41.04,107.93 41.76,108.65 42.77,108.65
  IN2 w0.127: v1(166.79,100.31) 165.71,101.38 161.25,101.38 160.91,101.73 151.29,101.73 149.94,103.07 128.37,103.07 127.72,102.43 99.81,102.43 90.77,111.47 81.91,111.47 81.69,111.25 79.31,111.25 78.31,112.26 74.5,112.26 71.08,108.84 64.12,108.84 61.56,111.4 51.09,111.4 50.44,110.75 46.95,110.75 44.85,108.65 42.77,108.65 ; v1(223.96,67.93) 223.28,68.62 222.18,68.62 221.91,68.9 217.28,68.9 213.7,65.32 204.65,65.32 202.53,67.44 191.05,67.44 189.46,69.03 189.46,85.57 188.04,86.98 187.56,86.98 186.69,87.86 186.69,88.33 182.57,92.46 181.92,92.46 180.8,93.58 180.8,94.25 177.89,97.16 177.89,98.52 175.55,100.86 175.55,103.34 174.34,104.55 169.87,104.55 v1(166.88,107.54)
  BOTTOM w0.102: v1(26.68,107.05) 26.27,106.64 v2(26.27,104.1) 26.27,102.9 26.57,102.61 26.57,101.62 26.71,101.48 26.71,96.82 RH28.1 ; v1(233.05,69.7) U46.B21
ISEN1: length 20.1
  TOP w0.203: PU702.13 26.07,75.8 25.79,75.53 25.79,75.27 v1(25.51,74.99)
  TOP w0.254: PR742.1 28.62,71.35 v1(28.18,71.35) ; PR719.1 26.63,67.62 27.51,67.62 27.65,67.76 v1(28.19,67.76) ; PC742.1 24.99,73.18 24.99,73.81 v2(25.45,74.27) 25.45,74.93 v1(25.51,74.99)
  IN1 w0.254: v1(28.19,67.76) 28.19,69.03 27.65,69.57 27.65,70.93 28.07,71.35 v1(28.18,71.35) 28.19,71.36 28.19,72.31 27.29,73.22 27.29,75.51 26.73,76.07 26.11,76.07 25.51,75.48 v1(25.51,74.99)
  BOTTOM w0.254: v1(28.19,67.76) 28.85,67.09 PR758.1
ISEN1G: length 13.8
  TOP w0.203: 22.79,81.48 23.14,81.48 23.63,80.99 23.63,80.56 24,80.19 PU702.2
  TOP w0.254: 22.79,81.48 PC719.1 v2(23.19,82.11) 23.51,82.11 v1(23.84,81.78)
  IN1 w0.254: v1(20.29,85.92) 21.82,85.92 22.45,85.28 22.45,83.25 23.84,81.86 v1(23.84,81.78)
  BOTTOM w0.254: PR771.1 19.58,85.2 v1(20.29,85.92) 20.77,85.44 PR769.2
ISEN2: length 26.1
  TOP w0.203: 25.04,75.46 25.3,75.46 25.67,75.83 PU702.12
  TOP w0.254: v1(27.48,68.28) 27.32,68.11 26.06,68.11 25.55,67.6 PR723.1 ; PR759.1 30.33,66.64 30.69,66.28 v1(30.73,66.28) ; v1(22.83,73.72) 22.83,73.6 22.2,72.96 PR740.2 ; 25.04,75.46 24.78,75.2 24.78,74.18 24.32,73.72 v1(24.1,73.72) 24.1,73.06 PC739.1
  IN1 w0.254: v1(24.1,73.72) 24.5,73.33 24.5,68.05 25,67.54 26.16,67.54 26.9,68.28 v1(27.48,68.28)
  IN4 w0.254: v1(22.83,73.72) v1(24.1,73.72)
  BOTTOM w0.254: v1(27.48,68.28) 27.48,68.29 28.73,69.53 v2(28.94,69.53) 28.97,69.56 PR741.1 30.22,68.78 30.87,68.14 30.87,66.42 v1(30.73,66.28)
ISEN2G: length 21.6
  TOP w0.254: PC720.1 23.01,81.09 23.3,80.8 v2(23.3,80.34) 23.3,80.07 v1(23.59,79.79) PU702.3 ; PR720.2 v1(20.45,72.93)
  IN1 w0.254: v1(21.25,84.79) 21.25,83.21 23.59,80.87 v1(23.59,79.79)
  IN2 w0.254: v1(23.59,79.79) 23.42,79.96 22.58,79.96 21.45,78.83 21.45,73.89 20.49,72.93 v1(20.45,72.93)
  BOTTOM w0.254: v1(21.25,84.79) 21.66,85.2 PR766.2 22.9,85.2 23.13,85.44 PR774.1
ISEN3: length 29.2
  TOP w0.203: PU702.11 25.27,75.99 25.08,75.81 24.64,75.81 v1(24.42,75.59)
  TOP w0.254: PC738.1 23.53,73.25 23.53,73.88 23.71,74.05 23.71,74.73 23.73,74.76 23.73,74.77 24.42,75.45 v1(24.42,75.59) ; v1(28.15,70.59) 28.71,70.03 PR747.1 ; v1(30.33,67.89) 29.98,67.89 29.06,66.97 PR762.1
  IN1 w0.254: v1(25.42,68.44) 24.88,68.99 24.88,73.46 24.78,73.56 24.78,75.24 v1(24.42,75.59) ; v1(30.33,67.89) 30.33,68.94 28.68,70.59 v1(28.15,70.59)
  IN4 w0.254: v1(28.15,70.59) 28.15,69.76 26.39,68 25.87,68 v1(25.42,68.44)
  BOTTOM w0.254: PC733.1 22.25,74.16 22.71,74.61 22.71,75.25 22.99,75.53 v2(23.71,75.53) 24.36,75.53 v1(24.42,75.59) ; PR716.1 25.84,67.6 25.42,68.02 v1(25.42,68.44)
JETWAY_14M: length 9.4
  TOP w0.102: v3(22.15,128.77) 22.24,128.67 UH4.K49 ; RH315.2 21.33,135.23 v1(21.59,135.23)
  IN4 w0.109: v1(21.59,135.23) 21.51,135.23 21.12,134.84 21.12,132.75 22.12,131.75 22.12,130.39 22.58,129.93 22.58,129.08 22.27,128.77 v3(22.15,128.77)
JETWAY_CLK14M: length 216.6
  TOP w0.102: v1(47.65,136.28) 47.46,136.47 46.81,136.47 46.15,137.14 42.39,137.14 41.85,137.67 36.56,137.67 35.21,139.03 29.34,139.03 29.04,139.32 24.4,139.32 23.77,138.7 22.43,138.7 20.67,136.94 RH315.1 ; v1(166.14,100.29) 166.6,99.84 170.48,99.84 170.92,100.27 173.65,100.27 174.11,99.8 U39.13 U37.13 174.11,95.55 RE6.1
  IN4 w0.109: v1(129.63,119.13) 129.82,118.94 130.62,118.94 133.02,116.53 140.04,116.53 140.97,115.6 153.55,115.6 154.54,116.59 163.21,116.59 165.95,119.33 v1(166.15,119.33)
  BOTTOM w0.102: v1(129.63,119.13) 126.64,116.14 126.64,115.3 117.83,106.49 102.91,106.49 100.57,104.15 84.66,104.15 82.78,106.03 81.63,106.03 79.97,107.7 79.97,108.26 78.41,109.82 78.41,111.45 69.53,120.33 69.53,122.52 68.08,123.96 68.08,133.49 65.49,136.08 64.74,136.08 63.6,137.22 61.64,137.22 60.73,136.31 56.25,136.31 55.83,135.89 53.35,135.89 53.19,136.06 53.19,136.63 52.4,137.41 v2(50.57,137.41) 48.41,137.41 47.65,136.65 v1(47.65,136.28) ; v1(166.14,100.29) 166.01,100.29 162.37,103.94 162.37,107.42 166.15,111.2 v1(166.15,119.33)
JTAG_CLK: length 104.2
  TOP w0.102: JDEG2.4 209.8,110.44 210.36,111 210.36,117.04 209.61,117.79 v1(209.47,117.79) R860.2 ; U54.B56 168.72,151.1 v1(168.62,150.99)
  IN4 w0.109: v1(168.62,150.99) 168.62,151.02 169.71,152.11 177.58,152.11 178.19,152.73 181.02,152.73 182.17,151.58 187.01,151.58 189.18,153.75 192.36,153.75 194.25,155.65 196.81,155.65 198.17,157.01 198.17,157.98 200.95,160.76 v1(203.22,160.76)
  BOTTOM w0.102: v1(209.47,117.79) 210.67,118.99 210.67,135.92 213.07,138.32 213.07,157.39 211.87,158.59 207.41,158.59 206.08,159.92 v2(206.08,161.21) 205.97,161.33 203.8,161.33 v1(203.22,160.76)
JTAG_RST#: length 13.8
  TOP w0.102: U54.B57 168.17,151.67 168.17,150.76 167.74,150.33 v1(167.69,150.33) ; R824.2 R836.1 C735.1 169,157.32 JTAG1.1 167.05,157.32 v1(166.9,157.47)
  BOTTOM w0.102: v1(166.9,157.47) 167.45,156.92 167.45,155.51 168.17,154.79 v2(168.17,151.4) 168.17,150.64 167.87,150.33 v1(167.69,150.33)
JTAG_TDI: length 103.1
  TOP w0.102: U54.A51 169.47,152.9 170.01,153.44 v1(170.01,153.58) ; R858.2 209.08,118.45 v1(209.47,118.45) 209.9,118.45 210.56,117.79 210.56,110 210.01,109.44 JDEG2.2
  IN4 w0.109: v1(203.9,160.8) 203.47,161.22 201.11,161.22 197.96,158.07 197.96,157.1 196.72,155.86 194.17,155.86 192.27,153.97 188.95,153.97 186.88,151.9 182.3,151.9 181.15,153.04 174.88,153.04 174.75,153.18 170.42,153.18 v1(170.01,153.58)
  BOTTOM w0.102: v1(209.47,118.45) 209.66,118.45 210.46,119.25 210.46,136.01 212.86,138.41 212.86,157.3 211.79,158.38 207.01,158.38 v2(204.63,160.76) 204.6,160.8 v1(203.9,160.8)
JTAG_TDO: length 111.9
  TOP w0.102: v1(168.59,150.27) 169.09,150.76 169.09,151.27 169.22,151.41 U54.B55 ; R861.2 213.34,106.84 213.08,107.1 213.08,110.77 212.91,110.94 JDEG2.5 211.22,110.94 210.97,111.19 210.97,120.62 213.27,122.92 213.27,159.01 v1(213.02,159.27)
  IN4 w0.109: v1(202.61,160.06) 202.13,160.55 201.03,160.55 198.38,157.9 198.38,156.92 196.9,155.44 194.34,155.44 192.45,153.54 189.27,153.54 187.09,151.37 182.08,151.37 180.94,152.51 178.28,152.51 177.66,151.9 170.22,151.9 v1(168.59,150.27)
  BOTTOM w0.102: v1(202.61,160.06) 202.61,161.14 203.99,162.51 206.11,162.51 208.58,160.03 212.25,160.03 v1(213.02,159.27) ; v1(168.59,150.27) 168.11,149.78 v2(167.75,149.78)
JTAG_TMS: length 109.9
  TOP w0.102: v1(212.84,158.55) 213.07,158.32 213.07,123 210.77,120.7 210.77,110.57 211.4,109.94 JDEG2.3 212.7,109.94 212.85,109.79 212.85,106.3 213.44,105.71 R859.2 ; U54.A53 168.47,153.03 168.72,153.28 168.72,153.68 v2(168.92,153.89) 169.29,154.25 v1(169.38,154.25)
  IN4 w0.109: v1(203.95,161.79) 201.38,161.79 197.75,158.16 197.75,157.19 196.63,156.07 194.08,156.07 192.19,154.18 188.86,154.18 186.79,152.11 182.38,152.11 181.24,153.25 174.97,153.25 173.51,154.71 170.27,154.71 169.81,154.25 v1(169.38,154.25)
  BOTTOM w0.102: v1(212.84,158.55) 212.4,158.99 207.96,158.99 207.62,159.33 207.62,160.71 206.07,162.26 204.42,162.26 v1(203.95,161.79)
KB_DET#: length 106.9
  TOP w0.102: UH4.D6 19.43,106.81 19.1,106.48 v1(19.1,106.46) ; v1(90.4,109.21) 90.4,109.16 90.84,109.61 90.84,110.38 89.97,111.25 JKB1.19 JKB1.20 ; v1(64.45,95.8) 64.48,95.8 64.62,95.66 67.13,95.66 68.34,96.86 76.5,96.86 78.23,98.59 78.23,101.74 78.02,101.95 78.02,103.64 80.81,106.43 v3(80.81,107.49)
  IN2 w0.102: 20.38,103.19 20.38,103.72 19.1,105 v1(19.1,106.46)
  IN2 w0.127: v1(90.4,109.21) 90.35,109.16 90.35,108.66 89.57,107.89 88.5,107.89 87.45,106.83 83.88,106.83 82.65,105.6 81.56,105.6 80.78,106.38 80.78,107.47 v3(80.81,107.49) ; v1(64.45,95.8) 64.4,95.85 64.4,96.74 62.4,98.74 59.22,98.74 58.28,99.68 52.48,99.68 50.39,97.6 49.8,97.6 49.25,98.15 38.83,98.15 37.85,97.17 36.28,97.17 36.1,97.35 34.31,97.35 34.26,97.3 32.78,97.3 32.42,96.94 28.56,96.94 27.67,97.83 25.96,97.83 25.32,98.46 25.32,98.93 23.89,100.36 21.86,100.36 20.38,101.84 20.38,103.19
  BOTTOM w0.102: RH170.1 14.51,103.19 17.35,106.02 18.65,106.02 v1(19.1,106.46)
LAN_ACTLED_YEL#: length 73.4
  TOP w0.102: R1171.1 77.25,164.46 v1(77.25,163.78) ; U32.17 119.8,145.48 119.62,145.66 119.62,146.24 v1(120.1,146.72)
  IN4 w0.109: v1(119.54,159.75) 109.64,159.75 108.56,158.67 98.84,158.67 97.32,157.15 97.32,154.31 94.91,151.89 82.21,151.89 81.13,152.97 80.63,152.97 77.91,155.69 77.91,162.14 77.25,162.8 v1(77.25,163.78)
  BOTTOM w0.102: v1(119.54,159.75) 119.72,159.58 120.37,159.58 v2(120.73,159.21) 120.88,159.07 120.88,157.67 120.1,156.9 v1(120.1,146.72)
LAN_DISABLE#_R: length 207.2
  TOP w0.102: U31.3 120.61,162.25 119.72,163.13 R555.2 R549.2 R557.1 119.01,165.16 119.33,164.85 119.33,164.26 v1(119.48,164.11)
  IN1 w0.109: v1(241.23,78.42) 241.23,78.38 240.86,78.01 240.42,78.01 239.58,78.84 238.96,78.84 238.59,78.47 238.59,75.88 v1(238.16,75.45)
  IN2 w0.127: v1(119.48,164.11) 119.67,163.92 135.72,163.92 137.21,162.43 144.04,162.43 145.22,161.25 148.21,161.25 148.37,161.42 149.97,161.42 151.12,160.27 152.58,160.27 153.08,159.77 153.76,159.77 157.87,163.88 172.38,163.88 173.12,163.14 174.41,163.14 176.46,161.09 181.8,161.09 183.15,162.43 193.25,162.43 193.7,161.99 194.82,161.99 195.31,161.49 196.87,161.49 200.96,157.4 205.92,157.4 210.6,152.73 210.6,149.11 210.98,148.73 210.98,105.07 211.81,104.24 213.15,104.24 217.7,99.69 217.7,98.11 227.29,88.53 228.2,88.53 232.42,84.31 233.87,84.31 235.81,82.37 235.81,82.37 236.15,82.03 236.15,80.87 236.37,80.66 239.85,80.66 241.23,79.27 v1(241.23,78.42)
  BOTTOM w0.102: v2(241.04,79.34) 241.23,79.15 v1(241.23,78.42) ; U46.B47 238.83,76.12 v1(238.16,75.45)
LAN_SMBCLK: length 231.2
  TOP w0.102: R551.1 130.56,157.1 131.23,157.1 v2(131.74,157.61) 131.74,159.72 131.65,159.8 v1(131.65,161.3) ; RH305.1 14.55,103.19 16.14,104.78 16.14,105.92 v1(16.13,105.93) 16.25,106.05 16.25,106.19 17.66,107.59 17.95,107.59 18.29,107.93 UH4.C8
  IN1 w0.109: v1(131.65,161.3) 131.62,161.28 130.73,161.28 130.22,161.79 130.22,169.49 128.62,171.1 128.48,171.09 108.36,171.09 99.95,162.69 99.95,160.14 96.79,156.97 96.79,154.16 92.64,150.02 81.63,150.02 80.64,151.01 77.83,151.01 74.17,154.67 71.2,154.67 70.74,154.2 68.83,154.2 66.43,156.6 60.87,156.6 59.04,158.43 52.82,158.43 52.3,158.95 46.85,158.95 45.95,158.05 45.95,155.7 46.28,155.37 46.28,152.43 44.3,150.45 40.4,150.45 38.09,152.76 20.5,152.76 19.89,153.36 18.57,153.36 15.17,149.97 15.17,145.46 14.1,144.39 13.27,144.39 11.63,142.75 11.63,140.98 9.96,139.32 8.62,139.32 7.89,138.6 5.84,138.6 4.74,137.49 4.19,137.49 3.47,136.77 3.47,133.49 4.22,132.74 4.22,108.91 3.55,108.24 3.55,104.86 3.53,104.84 3.53,104.84 4.8,103.57 7.09,103.57 7.34,103.82 10.44,103.82 10.76,104.14 14.04,104.14 14.92,105.02 15.64,105.02 16.13,105.5 16.13,105.92 v1(16.13,105.93)
LAN_SMBCLK_R: length 4.1
  TOP w0.102: U31.28 127.95,159.85 128.32,159.47 v2(128.31,159.47) 128.8,158.98 128.8,157.91 R551.2
LAN_SMBDATA: length 229.3
  TOP w0.102: R552.1 130.48,160.85 131.52,161.89 v2(131.74,161.89) 132.22,161.89 v1(132.32,161.79) ; v1(20.96,109.44) 20.95,109.45 20.95,109.54 20.7,109.79 UH4.G12
  IN1 w0.109: v1(14.96,105.48) 13.88,104.39 10.67,104.39 10.35,104.08 7.2,104.08 7,103.88 4.85,103.88 3.78,104.94 3.78,108.14 4.46,108.81 4.46,132.92 3.72,133.66 3.72,136.66 4.29,137.24 4.84,137.24 5.95,138.34 8,138.34 8.72,139.07 10.07,139.07 11.88,140.88 11.88,142.64 13.37,144.13 14.21,144.13 15.43,145.35 15.43,149.89 18.67,153.12 19.79,153.12 20.4,152.52 37.94,152.52 38.01,152.45 38.03,152.45 40.29,150.19 44.4,150.19 46.52,152.31 46.52,155.47 46.18,155.8 46.18,157.93 46.95,158.7 52.06,158.7 52.58,158.18 58.94,158.18 60.76,156.36 60.78,156.37 66.33,156.37 68.73,153.97 70.84,153.97 71.3,154.43 74.07,154.43 77.73,150.77 80.54,150.77 81.55,149.76 92.75,149.76 97.04,154.05 97.04,156.86 100.34,160.17 100.34,162.72 108.47,170.84 128.37,170.84 129.87,169.34 129.87,161.44 130.48,160.83 131.88,160.83 132.32,161.28 v1(132.32,161.79)
  IN4 w0.102: 18.2,108.22 18.35,108.37 18.77,108.37 19.21,108.81 19.21,108.81 19.25,108.84 20.09,108.84 20.28,109.03 20.62,109.03 20.95,109.36 20.95,109.44 v1(20.96,109.44)
  IN4 w0.109: v1(14.96,105.48) 14.96,105.71 16.71,107.46 17.44,107.46 18.2,108.22
  BOTTOM w0.127: v1(14.96,105.48) 14.96,105.48 14.98,105.45 14.76,105.22 RH306.1
LAN_SMBDATA_R: length 4.5
  TOP w0.102: U31.31 127.56,161.05 127.62,160.99 129.28,160.99 R552.2 129.91,160.35 v2(131.27,160.35)
LAN_TEST_EN: length 2.7
  TOP w0.102: R561.1 128.6,160.65 U31.30
LAN_TX0+: length 9
  TOP w0.089: L30.1 119.63,150.72 119.63,151.71 121.18,153.26 v2(121.18,155.77) 121.18,156.33 121.88,157.03 121.88,157.29 121.85,157.32 U31.13
LAN_TX0+R: length 6
  TOP w0.089: L30.2 118.98,148.78 119.65,148.11 119.65,147.84 v2(119.87,147.62) 120.07,147.41 121.45,147.41 122.38,146.48 122.38,145.8 122.3,145.72 U32.12
LAN_TX0-: length 9
  TOP w0.089: U31.14 122.25,157.28 122.22,157.25 122.22,156.88 121.52,156.19 121.52,153.12 v2(120.62,152.22) 119.98,151.57 119.98,150.58 L31.1
LAN_TX0-R: length 5.9
  TOP w0.089: U32.11 122.8,145.72 122.72,145.8 122.72,146.62 121.59,147.75 v2(121.51,147.75) 120.22,147.75 119.99,147.98 119.99,148.27 L31.2
LAN_TX1+: length 8.4
  TOP w0.089: L33.1 122.64,150.68 122.64,152.68 v2(123.05,153.09) 123.48,153.52 123.48,157.26 123.45,157.29 U31.17
LAN_TX1+R: length 4.3
  TOP w0.089: U32.10 123.3,145.72 123.36,145.79 v2(123.36,146.28) 123.36,146.34 123.38,146.35 123.38,146.99 122.62,147.75 122.62,148.18 L33.2
LAN_TX1-: length 8.4
  TOP w0.089: U31.18 123.85,157.29 123.82,157.26 123.82,153.38 122.99,152.54 v2(122.99,151.26) 122.99,150.61 L32.1
LAN_TX1-R: length 4.3
  TOP w0.089: L32.2 122.96,148.19 122.96,147.89 v2(123.2,147.65) 123.72,147.13 123.72,146.21 123.71,146.19 123.71,145.81 123.8,145.72 U32.9
LAN_TX2+: length 8.5
  TOP w0.089: L34.1 125.66,150.65 125.66,152.18 124.69,153.16 v2(124.69,154.46) 124.69,157.11 124.65,157.14 U31.20
LAN_TX2+R: length 4.4
  TOP w0.089: L34.2 125.7,148.14 125.7,147.77 124.88,146.94 v2(124.88,146.32) 124.88,145.8 124.8,145.72 U32.7
LAN_TX2-: length 8.5
  TOP w0.089: U31.21 125.05,157.14 125.03,157.12 125.03,153.3 126.01,152.32 v2(126.01,151.36) 126.01,150.64 L35.1
LAN_TX2-R: length 4.3
  TOP w0.089: L35.2 126.05,148.23 126.05,147.62 v2(125.91,147.48) 125.22,146.8 125.22,145.8 125.3,145.72 U32.6
LAN_TX3+: length 9.2
  TOP w0.089: L36.1 128.69,150.63 128.69,150.98 v2(126.62,153.05) 126.01,153.66 126.01,156.88 125.88,157.01 125.88,157.29 125.85,157.32 U31.23
LAN_TX3+R: length 4.7
  TOP w0.089: U32.3 126.8,145.72 126.88,145.8 126.88,146.21 v2(127.18,146.51) 128.67,148.01 128.67,148.22 L36.2
LAN_TX3-: length 9.2
  TOP w0.089: L37.1 129.03,150.67 129.03,151.12 v2(128.85,151.3) 126.35,153.8 126.35,157.03 126.22,157.15 126.22,157.26 126.25,157.29 U31.24
LAN_TX3-R: length 4.8
  TOP w0.089: U32.2 127.3,145.72 127.22,145.8 127.22,146.07 v2(128.72,147.57) 129.02,147.87 129.02,148.15 L37.2
LANCLK_REQ#: length 184.8
  TOP w0.102: v1(119.73,167.95) 119.81,167.87 R1187.1 ; v1(106.64,98.57) 105.12,100.09 v1(105.12,110.6) ; UH4.M1 23.23,104.21 v1(23.05,104.03)
  IN2 w0.102: v1(23.05,104.03) 22.93,104.03 22.64,103.73 22.64,103.25 22.58,103.19
  IN2 w0.127: v1(106.64,98.57) 106.51,98.69 83.08,98.69 82.35,97.96 75.54,97.96 73.93,96.34 67.01,96.34 63.47,99.89 59.7,99.89 58.76,100.83 47.05,100.83 46.29,100.06 42.74,100.06 42.4,100.41 37,100.41 36.91,100.31 33.3,100.31 32.92,99.94 32.07,99.94 31.78,99.64 28.38,99.64 27.4,100.62 24.92,100.62 24.18,101.36 23.37,101.36 22.88,101.84 22.88,102.31 22.58,102.62 22.58,103.19
  BOTTOM w0.102: v1(119.73,167.95) v2(119.3,167.51) 119.01,167.22 119.01,161.39 118.4,160.78 118.4,159.33 119.87,157.86 119.87,155.88 119.87,155.87 119.87,155.86 119.87,155.85 119.87,153.68 119.16,152.97 119.16,150.41 118.88,150.13 118.88,145.16 119.15,144.89 119.15,137.59 127.96,128.78 127.96,121.45 125.72,119.2 125.72,118.15 118.22,110.65 105.17,110.65 v1(105.12,110.6)
LANCLK_REQ#_R: length 3.8
  TOP w0.102: U31.48 121.85,164.18 120.84,165.19 ; v2(120.84,165.2) 120.84,165.19 ; 120.84,165.19 120.75,165.28 R547.2 R1187.2
LAT_ON_SW#: length 4.8
  TOP w0.102: v1(165.73,150.85) 165.59,150.99 165.59,151.11 165.22,151.47 U54.B63
  BOTTOM w0.102: v1(165.73,150.85) v2(165.73,151.94) 165.73,152.44 165.38,152.79 165.38,153.84 R870.2
LCD_A0+_PCH: length 71.9
  TOP w0.102: v1(34.21,128.9) 33.83,128.51 33.83,128.24 33.79,128.2 33.79,128.02 33.97,127.84 33.97,127.62 33.63,127.28 UH4.AN47 ; U11.16 67.56,132.92 67.5,132.99 67.5,133.05 67.44,133.1 66.83,133.1 66.71,132.99 66.71,132.64 66.8,132.55 66.9,132.55 v3(66.99,132.64)
  IN1 w0.117: v1(34.21,128.9) 34.35,129.04 35.19,129.04 35.3,129.15 37.82,129.15 38.86,130.18 39.09,130.18 39.43,130.52 39.83,130.52 40.24,130.11 40.6,130.11 40.86,129.84 45.84,129.84 46.3,129.38 48.19,129.38 48.43,129.62 48.43,130.03 48.5,130.11 61.75,130.11 61.99,130.34 61.99,130.48 62.11,130.61 62.6,130.61 62.72,130.48 62.72,130.34 62.96,130.11 64.12,130.11 64.47,130.46 64.47,130.99 64.59,131.12 65.14,131.12 65.27,130.99 65.27,130.29 65.17,130.19 64.9,130.19 64.61,129.9 64.61,129.33 64.9,129.04 65.19,129.04 65.31,128.91 65.31,127.77 65.19,127.65 64.37,127.65 64.09,127.36 64.09,126.78 64.37,126.49 65.06,126.49 65.19,126.37 65.19,126.05 65.06,125.92 64.38,125.92 64.09,125.63 64.09,125.11 64.38,124.82 64.92,124.82 65.05,124.69 65.05,123.83 65.34,123.54 66.04,123.54 66.34,123.83 66.34,124.24 66.46,124.37 66.89,124.37 67.19,124.66 67.19,125.3 66.89,125.59 66.42,125.59 66.29,125.72 66.29,126.08 66.42,126.21 68.19,126.21 68.48,126.5 68.48,127.07 68.19,127.36 66.45,127.36 66.34,127.48 66.34,127.83 66.45,127.94 67.66,127.94 67.95,128.24 67.95,128.8 67.66,129.1 66.45,129.1 66.34,129.21 66.34,129.56 66.45,129.68 67.66,129.68 67.95,129.97 67.95,130.67 67.66,130.96 66.39,130.96 66.27,131.09 66.27,131.48 66.39,131.61 66.71,131.61 66.93,131.83 66.93,132.58 v3(66.99,132.64)
LCD_A0-_PCH: length 71.9
  TOP w0.102: v1(34.2,129.67) 34.2,129.46 34.19,129.44 34.19,129.38 34.09,129.28 34.03,129.28 33.81,129.06 33.81,128.87 33.56,128.63 33.56,128.35 33.53,128.31 33.53,127.82 UH4.AN48 ; v3(66.27,132.64) 66.27,132.65 66.44,132.83 66.44,133.1 66.72,133.37 67.48,133.37 67.53,133.42 U11.15
  IN1 w0.117: v3(66.27,132.64) 66.48,132.43 66.56,132.43 66.64,132.35 66.64,131.94 66.59,131.89 66.28,131.89 65.98,131.6 65.98,130.97 66.28,130.68 67.54,130.68 67.67,130.55 67.67,130.09 67.54,129.97 66.33,129.97 66.05,129.68 66.05,129.1 66.33,128.81 67.54,128.81 67.67,128.69 67.67,128.36 67.54,128.23 66.33,128.23 66.05,127.94 66.05,127.36 66.33,127.07 68.07,127.07 68.2,126.95 68.2,126.62 68.07,126.49 66.3,126.49 66.01,126.2 66.01,125.6 66.3,125.31 66.78,125.31 66.9,125.18 66.9,124.78 66.78,124.65 66.34,124.65 66.05,124.36 66.05,123.95 65.92,123.83 65.46,123.83 65.33,123.95 65.33,124.81 65.04,125.1 64.5,125.1 64.37,125.23 64.37,125.51 64.5,125.64 65.18,125.64 65.47,125.93 65.47,126.48 65.18,126.78 64.49,126.78 64.37,126.89 64.37,127.24 64.49,127.36 65.31,127.36 65.6,127.65 65.6,129.03 65.31,129.33 65.02,129.33 64.9,129.45 64.9,129.78 65.02,129.91 65.29,129.91 65.56,130.18 65.56,131.11 65.26,131.4 64.47,131.4 64.18,131.11 64.18,130.57 64,130.39 63.08,130.39 63.01,130.46 63.01,130.6 62.71,130.89 62,130.89 61.7,130.6 61.7,130.46 61.64,130.39 48.38,130.39 48.14,130.15 48.14,129.74 48.07,129.67 46.42,129.67 45.96,130.13 40.98,130.13 40.71,130.39 40.36,130.39 39.95,130.8 39.31,130.8 38.97,130.47 38.74,130.47 37.7,129.43 35.16,129.43 35.03,129.3 34.33,129.3 34.2,129.43 v1(34.2,129.67)
LCD_A1+_PCH: length 70.2
  TOP w0.102: v1(32.78,129.82) 32.78,129.81 33.39,129.2 33.39,129.03 33.14,128.78 UH4.AM49 ; U11.20 69.72,130.45 69.62,130.35 69.62,129.55 69.52,129.45 69.35,129.29 68.71,129.29 68.54,129.12 v3(68.54,129.12)
  IN1 w0.102: 40.46,129.54 40.45,129.55 40.43,129.55 40.37,129.62 40.14,129.62 38.98,129.62 38.2,128.83 35.63,128.83 35.27,128.46 33.94,128.46 33.7,128.7 33.7,129.1 33.71,129.33 33.64,129.39 33.64,129.4 33.63,129.41
  IN1 w0.117: 40.46,129.54 40.65,129.35 45.63,129.35 46.29,128.69 46.29,128.05 46.42,127.93 46.75,127.93 46.88,128.05 46.88,128.59 47.18,128.89 47.78,128.89 48.07,128.6 48.07,127.62 48.2,127.49 48.62,127.49 48.89,127.22 48.89,126.54 48.6,126.24 47.61,126.24 47.48,126.11 47.48,125.78 47.61,125.66 48.6,125.66 48.89,125.36 48.89,120.11 49.77,119.24 49.77,118.77 52.63,115.91 60.34,115.91 64.17,119.74 64.17,120.83 64.45,121.12 65.14,121.12 65.27,121.24 65.27,121.57 65.14,121.7 64.38,121.7 64.09,121.99 64.09,122.72 64.38,123.02 66.25,123.02 67.69,124.46 67.69,125.3 68.01,125.62 68.84,125.62 68.98,125.76 68.98,129.41 68.81,129.58 68.61,129.58 68.61,129.57 68.35,129.57 68.21,129.43 68.21,129.3 68.39,129.12 v3(68.54,129.12) ; 33.63,129.41 33.49,129.55 32.92,129.55 32.78,129.69 v1(32.78,129.82)
LCD_A1-_PCH: length 70.2
  TOP w0.102: v1(32.79,129.16) 32.79,128.07 33.14,127.72 UH4.AM47 ; U11.19 69.22,130.45 69.35,130.32 69.35,129.66 69.33,129.64 69.24,129.55 68.55,129.55 68.46,129.64 68.46,129.93 68.54,130.01 v3(68.54,130.01)
  IN1 w0.102: v1(32.79,129.16) 32.8,129.16 32.91,129.27 32.91,129.27 ; 40.26,129.34 40.25,129.35 39.09,129.35 38.31,128.56 35.75,128.56 35.38,128.19 33.83,128.19 33.44,128.59 33.44,129.12 33.43,129.13 33.44,129.14 33.44,129.2 33.43,129.21
  IN1 w0.117: 32.91,129.27 33.37,129.27 33.43,129.21 ; 40.26,129.34 40.54,129.06 45.51,129.06 46.01,128.57 46.01,127.94 46.3,127.64 46.87,127.64 47.17,127.94 47.17,128.47 47.29,128.6 47.67,128.6 47.79,128.48 47.79,127.5 48.08,127.2 48.5,127.2 48.61,127.1 48.61,126.66 48.48,126.53 47.49,126.53 47.2,126.23 47.2,125.67 47.49,125.37 48.48,125.37 48.61,125.24 48.61,120 49.49,119.12 49.49,118.65 52.51,115.63 60.45,115.63 64.45,119.63 64.45,120.72 64.57,120.83 65.26,120.83 65.55,121.13 65.55,121.69 65.26,121.99 64.5,121.99 64.37,122.11 64.37,122.6 64.5,122.73 66.37,122.73 67.97,124.34 67.97,125.18 68.12,125.33 68.95,125.33 69.27,125.64 69.27,129.53 68.92,129.87 68.68,129.87 68.54,130.01 v3(68.54,130.01)
LCD_A2+_PCH: length 76.6
  TOP w0.102: v3(32.12,129.35) 32.12,129.16 32.59,128.69 32.59,128.49 32.26,128.16 UH4.AK49 ; U11.24 71.72,130.28 71.6,130.16 71.6,129.78 71.42,129.6 71.42,128.87 71.69,128.6 72.07,128.6 72.23,128.77 72.23,128.88 v1(72.1,129.01)
  IN1 w0.102: v3(32.12,129.35) 32.12,129.25 33.37,127.99 35.46,127.99 35.75,128.28 38.33,128.28 39.06,129.01 40.03,129.01 41.07,127.96 42.52,127.96 42.53,127.97 42.62,127.97 42.63,127.98 42.64,127.98
  IN1 w0.117: v1(72.1,129.01) 71.86,128.77 71.13,128.77 70.98,128.91 70.98,131.88 70.69,132.17 69.13,132.17 68.84,131.88 68.84,131.25 69.13,130.96 69.62,130.96 69.76,130.81 69.76,127.53 70.05,127.25 70.86,127.25 70.98,127.13 70.98,126.78 70.86,126.66 70.05,126.66 69.76,126.38 69.76,125.43 69.54,125.2 69.54,124.8 69.66,124.67 69.66,124.51 69.41,124.26 69.24,124.26 69.12,124.38 68.72,124.38 68.31,123.97 68.31,123.57 68.43,123.45 68.43,123.28 68.18,123.03 68.02,123.03 67.89,123.15 67.49,123.15 66.05,121.71 66.05,120.94 65.97,120.86 65.97,119.4 65.89,119.32 64.85,119.32 60.66,115.13 52.29,115.13 48.97,118.45 48.97,118.92 48.11,119.78 48.11,124.05 46.7,125.46 46.7,126.22 46.41,126.51 45.65,126.51 45.34,126.82 45.34,126.99 45.59,127.25 45.59,127.66 45.19,128.06 44.78,128.06 44.52,127.81 44.41,127.81 44.24,127.98 42.64,127.98
LCD_A2-_PCH: length 76.6
  TOP w0.102: UH4.AK47 32.15,127.65 31.84,127.96 31.84,128.44 31.98,128.57 v1(31.98,128.73) ; U11.23 71.22,130.28 71.34,130.16 71.34,129.89 71.16,129.71 71.16,128.76 71.58,128.33 71.93,128.33 72.1,128.17 v3(72.1,128.17)
  IN1 w0.102: 42.64,127.69 40.96,127.69 39.92,128.74 39.17,128.74 38.44,128.01 35.87,128.01 35.57,127.72 33.26,127.72 32.26,128.73 v1(31.98,128.73)
  IN1 w0.117: v3(72.1,128.17) 72.1,128.17 72.1,128.24 71.86,128.48 71.01,128.48 70.69,128.8 70.69,131.76 70.57,131.89 69.25,131.89 69.12,131.76 69.12,131.37 69.25,131.24 69.73,131.24 70.05,130.93 70.05,127.65 70.17,127.53 70.98,127.53 71.26,127.25 71.26,126.66 70.98,126.38 70.17,126.38 70.05,126.26 70.05,125.31 69.82,125.08 69.82,124.91 69.94,124.79 69.94,124.39 69.53,123.98 69.13,123.98 69,124.1 68.84,124.1 68.59,123.85 68.59,123.69 68.71,123.56 68.71,123.16 68.3,122.75 67.9,122.75 67.78,122.87 67.61,122.87 66.34,121.59 66.34,120.82 66.26,120.74 66.26,119.28 66.01,119.03 64.96,119.03 60.78,114.85 52.17,114.85 48.69,118.33 48.69,118.81 47.83,119.66 47.83,123.93 46.42,125.34 46.42,126.1 46.29,126.23 45.53,126.23 45.05,126.71 45.05,127.11 45.31,127.36 45.31,127.54 45.07,127.78 44.89,127.78 44.64,127.52 44.3,127.52 44.12,127.69 42.64,127.69
LCD_ACLK+_PCH: length 67.9
  TOP w0.102: v3(31.67,123.64) 31.67,123.66 32.06,124.05 UH4.AK40 ; v1(75.82,131.78) 75.82,131.7 75.72,131.6 75.52,131.6 75.36,131.76 75.36,132.05 75.09,132.32 74.81,132.32 74.71,132.42 U11.29
  IN1 w0.102: v3(31.67,123.64) 31.93,123.64 31.97,123.68 31.97,124 32.45,124.48 32.7,124.48 33.81,125.58 33.81,125.67 35.86,127.72 38.44,127.72 39.09,128.37 39.99,128.37 41.15,127.22 42.63,127.22 42.69,127.16
  IN1 w0.117: v1(75.82,131.78) 75.82,131.75 75.59,131.53 74.95,131.53 73.32,129.9 73.32,128.63 72.28,127.58 72.17,127.58 71.76,127.17 71.76,125.51 67.39,121.14 67.39,119.6 66.32,118.53 65.17,118.53 60.89,114.25 51.34,114.25 49.44,116.15 49.44,116.62 46.47,119.59 46.47,123.37 45.01,124.83 45.01,125.38 44.48,125.91 43.93,125.91 42.69,127.16
LCD_ACLK-_PCH: length 67.9
  TOP w0.102: v1(31.67,123) 31.74,123 UH4.AK39 ; v3(75.82,131.15) 75.64,131.33 75.41,131.33 75.09,131.65 75.09,131.94 74.97,132.06 74.82,132.06 74.68,131.92 U11.28
  IN1 w0.102: 42.5,126.94 42.5,126.95 41.04,126.95 39.88,128.1 39.2,128.1 38.55,127.46 35.98,127.46 34.08,125.56 34.08,125.47 32.82,124.21 32.56,124.21 32.24,123.89 32.24,123.57 v1(31.67,123)
  IN1 w0.117: 42.5,126.94 43.81,125.63 44.36,125.63 44.73,125.26 44.73,124.71 46.19,123.25 46.19,119.47 49.16,116.5 49.16,116.03 51.22,113.97 61.01,113.97 65.28,118.25 66.44,118.25 67.68,119.48 67.68,121.02 72.05,125.39 72.05,127.06 72.29,127.3 72.4,127.3 73.61,128.51 73.61,129.78 75.07,131.24 75.73,131.24 v3(75.82,131.15)
LCD_B0+_PCH: length 66.1
  TOP w0.102: v3(52.82,132.79) 52.98,132.63 52.98,132.44 52.68,132.14 52.68,130.35 52.89,130.14 53.5,130.14 53.72,130.35 53.72,131.16 53.83,131.27 54.14,131.27 54.27,131.14 54.27,130.47 54.51,130.23 55.4,130.23 55.69,130.51 55.69,131.63 55.75,131.69 56.06,131.69 56.25,131.88 56.25,132.42 55.96,132.7 55.13,132.7 54.75,132.32 54.02,132.32 53.9,132.45 53.9,133.87 53.67,134.1 53.35,134.1 53.22,134.23 53.22,134.4 53.35,134.53 53.68,134.53 53.9,134.75 53.9,135.43 54.02,135.56 54.47,135.56 54.6,135.43 54.6,134.65 54.82,134.43 55.09,134.43 55.14,134.37 55.14,134.24 55.19,134.19 U13.16 ; v1(31.61,125.65) 31.79,125.65 31.84,125.6 31.84,125.17 31.71,125.05 31.28,125.05 31.16,125.17 UH4.AH43
  IN1 w0.102: v1(31.61,125.65) 31.31,125.65 30.94,126.02 30.94,126.26 30.72,126.48 30.11,126.48 29.98,126.61 29.98,126.82 30.11,126.95 31.95,126.95 32.34,127.35 32.34,128.04 32.06,128.32 31.16,128.32 30.85,128 29.68,128 29.45,128.23 29.45,128.59
  IN1 w0.117: v3(52.82,132.79) 52.6,133.01 51.92,133.01 51.39,133.54 51.39,134.1 51.68,134.4 51.96,134.4 52.09,134.52 52.09,134.89 51.96,135.01 48.53,135.01 47.89,134.37 47.76,134.37 47.7,134.31 47.7,134.08 47.41,133.79 46.82,133.79 46.53,134.08 46.53,134.24 46.4,134.37 46.01,134.37 45.88,134.24 45.88,134.06 45.61,133.79 37.07,133.79 36.99,133.7 36.99,133.46 36.54,133.02 35.84,133.02 35.54,133.31 35.54,133.49 35.41,133.62 35.15,133.62 35.03,133.49 35.03,132.48 34.73,132.18 34,132.18 33.7,132.48 33.7,133.5 33.58,133.63 33.22,133.63 33.1,133.5 33.1,132.75 32.39,132.04 30.67,132.04 29.61,130.97 29.61,130.21 29.73,130.09 30,130.09 30.29,129.79 30.29,129.23 30,128.93 29.58,128.93 29.45,128.81 29.45,128.59
LCD_B0-_PCH: length 66.2
  TOP w0.102: v3(52.82,133.43) 53.25,132.99 53.25,132.33 52.94,132.03 52.94,130.46 53,130.4 53.39,130.4 53.45,130.46 53.45,131.27 53.72,131.53 54.25,131.53 54.53,131.25 54.53,130.58 54.62,130.49 55.29,130.49 55.42,130.62 55.42,131.74 55.64,131.95 55.95,131.95 55.98,131.99 55.98,132.31 55.85,132.44 55.24,132.44 54.86,132.06 53.91,132.06 53.63,132.34 53.63,133.76 53.56,133.83 53.24,133.83 52.96,134.12 52.96,134.52 53.24,134.8 53.57,134.8 53.63,134.86 53.63,135.54 53.91,135.83 54.58,135.83 54.86,135.54 54.86,134.76 54.93,134.69 U13.15 ; v1(30.67,125.71) 30.6,125.71 30.47,125.83 30.47,126.18 30.6,126.31 31.03,126.31 31.16,126.18 UH4.AH45
  IN1 w0.102: v1(30.67,125.71) 30.67,126.15 30.61,126.21 30,126.21 29.71,126.5 29.71,126.93 30,127.22 31.83,127.22 32.08,127.46 32.08,127.93 31.95,128.05 31.28,128.05 30.96,127.73 29.57,127.73 29.18,128.12 29.18,128.47 29.17,128.47 29.17,128.56 29.16,128.57 29.16,128.59
  IN1 w0.117: v3(52.82,133.43) 52.68,133.29 52.04,133.29 51.67,133.65 51.67,133.99 51.8,134.11 52.08,134.11 52.38,134.41 52.38,135.01 52.08,135.3 48.42,135.3 47.77,134.66 47.65,134.66 47.42,134.43 47.42,134.2 47.29,134.07 46.94,134.07 46.81,134.2 46.81,134.36 46.52,134.66 45.89,134.66 45.6,134.36 45.6,134.18 45.49,134.07 36.95,134.07 36.7,133.82 36.7,133.58 36.43,133.3 35.95,133.3 35.83,133.43 35.83,133.61 35.53,133.9 35.03,133.9 34.74,133.61 34.74,132.59 34.61,132.47 34.12,132.47 33.99,132.59 33.99,133.62 33.7,133.91 33.11,133.91 32.81,133.62 32.81,132.87 32.27,132.32 30.56,132.32 29.32,131.09 29.32,130.1 29.62,129.8 29.88,129.8 30.01,129.68 30.01,129.34 29.88,129.22 29.46,129.22 29.16,128.92 29.16,128.59
