# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG14: length 1.7
  TOP w0.089: v5(74.4,73.94) 74.89,73.45 JCPU1.AN26
  BOTTOM w0.089: v5(74.4,73.94) 74.4,74.24 T11.1
CFG15: length 1.4
  TOP w0.089: JCPU1.AM27 73.9,72.45 v5(73.4,72.95)
  BOTTOM w0.089: T13.1 73.4,72.82 v5(73.4,72.95)
CFG16: length 1.3
  TOP w0.089: JCPU1.AK31 69.88,70.45 v1(69.37,70.97)
  BOTTOM w0.102: v1(69.37,70.97) 69.52,71.12 T71.1
CFG17: length 1.6
  TOP w0.089: v5(71.39,74.08) 71.9,73.57 JCPU1.AN29
  BOTTOM w0.089: v5(71.39,74.08) 71.39,74.57 T72.1
CHARGER_SMBCLK: length 158.7
  TOP w0.102: PU901.10 175.88,28.39 175.74,28.26 175.74,25.08 v1(176,24.83) ; v1(170.58,151.05) 171.01,150.63 U54.B50 ; v1(177.33,136.03) 177.33,135.93 177.66,135.6 177.91,135.6 178.18,135.33 178.18,133.82 178.93,133.07 178.93,129.72 178.52,129.32 178.52,114.88 182.48,110.92 182.48,104.42 181.2,103.14 181.2,100.56 v1(181.39,100.37)
  IN1 w0.109: v1(170.58,151.05) 170.6,151.05 170.81,150.84 172.31,150.84 173.52,149.63 173.52,148.96 175.96,146.52 175.96,145.92 176.68,145.2 176.68,143.19 177.13,142.74 177.13,140.57 177.85,139.85 177.85,136.82 177.33,136.3 v1(177.33,136.03) ; v1(181.39,100.37) 181.33,100.37 181.04,100.08 181.04,98.53 182.21,97.36 182.21,95.53 181.44,94.77 181.44,87.37 181.19,87.12 181.19,84.5 181.44,84.24 181.44,75.79 182.65,74.59 182.65,67.24 181.2,65.8 181.2,63.01 179.6,61.41 179.6,50.69 168.73,39.82 168.73,26.51 170.16,25.08 173.02,25.08 173.15,25.21 173.15,25.53 173.4,25.78 175.04,25.78 v1(176,24.83)
  BOTTOM w0.102: R828.2 175.57,152.03 v2(174.5,152.03) 171.66,152.03 170.72,151.09 170.62,151.09 v1(170.58,151.05)
CHARGER_SMBDAT: length 157
  TOP w0.102: v1(182.07,100.38) 182.05,100.38 181.46,100.97 181.46,103.04 182.74,104.32 182.74,111.02 178.78,114.99 178.78,129.21 179.18,129.62 179.18,133.64 v2(179.01,133.81) 178.43,134.39 178.43,135.52 177.98,135.98 v1(177.98,136.06) ; PU901.9 175.38,24.97 v1(175.23,24.83) ; U54.A47 174.24,150.38 175.65,151.79 R827.2 175.49,151.96 174.46,150.93 v1(173.82,150.93)
  IN1 w0.109: v1(175.23,24.83) 170.05,24.83 168.48,26.41 168.48,31.24 167.72,32 167.72,39.16 179.34,50.78 179.34,61.51 180.95,63.12 180.95,65.9 182.4,67.35 182.4,74.48 181.19,75.69 181.19,84.14 180.94,84.39 180.94,87.22 181.19,87.48 181.19,94.87 181.95,95.64 181.95,97.25 180.78,98.42 180.78,100.39 181.21,100.81 181.6,100.81 182.03,100.38 v1(182.07,100.38) ; v1(177.98,136.06) 178.1,136.18 178.1,139.95 177.38,140.68 177.38,142.85 176.93,143.29 176.93,145.33 176.21,146.05 176.21,146.74 173.82,149.12 v1(173.82,150.93)
CHG_LGATE: length 15.5
  IN4 w0.762: v1(179.87,32.45) 179.93,32.45 180.57,33.08 184.89,33.08 186.92,35.12 v1(193.27,35.12)
  BOTTOM w0.102: v2(180.78,32.54) 179.96,32.54 v1(179.87,32.45)
CHG_SNUB:
  vias: v2(193.84,32.66)
CHG_UGATE: length 15.1
  BOTTOM w0.762: 186.41,42.99 v2(185.58,42.99) 179.04,42.99 176.95,40.89 176.95,36.11
  vias: v1(176.93,34.68) v1(177.02,35.31)
CLK_80H: length 5.1
  TOP w0.102: RH314.2 19.66,129.71 20.86,128.51 20.86,128.03 21.18,127.71 21.18,127.34 UH4.H47
CLK_BCLK_ITP: length 21.1
  TOP w0.102: v6(31.68,110.17) 32.14,110.64 UH4.AK13
  BOTTOM w0.102: RH281.1 41.12,97.93 41.12,97.73 41.02,97.63 40.38,97.63 39.61,98.4 38.49,98.4 35.44,101.44 35.44,103.04 34.91,103.57 34.31,103.57 33.68,104.2 33.68,107.21 33.09,107.8 31.5,107.8 31.25,108.05 31.25,110.39 31.35,110.5 31.58,110.5 31.68,110.41 v6(31.68,110.17)
CLK_BCLK_ITP#: length 21.1
  TOP w0.102: v1(31.66,110.91) 32.07,111.32 UH4.AK14
  BOTTOM w0.102: v1(31.66,110.91) 31.47,110.91 31.04,110.48 31.04,107.87 31.38,107.53 32.98,107.53 33.41,107.1 v1(33.41,105.08) 33.41,104.09 34.2,103.3 34.8,103.3 35.18,102.93 35.18,101.33 38.38,98.13 39.5,98.13 40.27,97.36 40.65,97.36 RH280.1
CLK_BUF_BCLK: length 6.2
  TOP w0.102: UH4.BG30 UH4.BJ30 41.9,119.24 42.3,119.24 42.72,119.66 43.15,119.66 43.55,120.05 ; 43.55,120.05 44.05,120.56 44.05,121.43 44.72,122.09 RH91.1 ; 43.55,120.05 v2(43.56,120.05)
CLK_BUF_CKSSCD: length 12
  TOP w0.102: v5(31.65,106.31) 31.66,106.31 32.1,106.75 UH4.AK5
  IN4 w0.102: v5(31.65,106.31) 31.78,106.18 31.78,105.37 32.26,104.9 32.26,103.18
  IN4 w0.117: 32.26,103.18 32.26,102.65 32.58,102.33 32.58,101.4 31.34,100.16 31.34,99.36 31.99,98.71 32.53,98.71 32.61,98.64 32.61,98.45 v3(32.4,98.24)
  BOTTOM w0.102: v3(32.4,98.24) 32.4,98.23 32.64,97.99 32.64,97.38 RH79.1
CLK_BUF_CKSSCD#: length 12.7
  TOP w0.102: v7(31.67,106.96) 31.67,106.98 32.07,107.38 UH4.AK7
  IN4 w0.102: v7(31.67,106.96) 32.05,106.57 32.05,105.49 32.53,105.01 32.53,103.3 32.54,103.3 32.54,103.21 32.55,103.2 32.55,103.18
  IN4 w0.117: v1(33.03,98.24) 32.89,98.37 32.89,98.76 32.65,99 32.1,99 31.62,99.48 31.62,100.04 32.87,101.28 32.87,102.45 32.55,102.77 32.55,103.18
  BOTTOM w0.102: v1(33.03,98.24) 32.9,98.11 32.9,97.44 RH78.1
CLK_BUF_DMI: length 1.7
  TOP w0.102: UH4.BE18 39.27,112.81 38.92,112.46 v1(38.92,112.43)
  BOTTOM w0.102: v1(38.92,112.43) 39.09,112.6 39.09,112.93 RH75.1
CLK_BUF_DMI#: length 1.7
  TOP w0.102: UH4.BF18 39.91,112.78 v1(39.57,112.45)
  BOTTOM w0.102: RH74.1 39.36,112.95 39.36,112.66 v1(39.57,112.45)
CLK_BUF_DOT96: length 1.6
  TOP w0.102: UH4.E24 20.07,115.85 20.37,115.55 v1(20.37,115.35)
  BOTTOM w0.102: v1(20.37,115.35) 20.37,115.58 RH77.1
CLK_BUF_DOT96#: length 2
  TOP w0.102: UH4.G24 20.7,115.66 v1(21.01,115.36)
  BOTTOM w0.102: RH76.1 20.81,115.56 v1(21.01,115.36) 21.01,115.3 v2(21.37,114.94)
CLK_CPU_DMI: length 113.7
  TOP w0.102: UH4.AU22 35.38,114.96 v1(34.99,115.35) ; v3(74,33.71) 74.16,33.87 74.16,34.75 RC17.2
  IN1 w0.117: v3(74,33.71) 74,33.83 73.67,34.16 62.66,34.16 59.51,37.3 59.51,39.08 57.24,41.35 57.24,43.41 54.96,45.68 54.96,67.02 55.83,67.88 55.83,70.15 56.88,71.2 56.88,73.53 56.2,74.2 56.2,79.03 56.2,79.15 55.55,79.81 55.55,81.05 v1(54.96,81.64)
  IN3 w0.102: v1(34.99,115.35) 35.16,115.15 35.6,114.72 39.82,114.72 39.96,114.58 41.48,114.58 42.26,113.79 42.26,113.14 42.45,112.95 42.45,109.79 42.57,109.68
  IN3 w0.127: v1(54.96,81.64) 55.29,81.97 55.29,82.96 54.46,83.8 54.46,89.87 56.02,91.43 56.02,92.43 53.41,95.04 53.41,95.54 52.31,96.64 52.31,98.67 51.05,99.94 50.05,99.94 46.01,103.98 46.01,105.33 42.57,108.78 42.57,109.68
CLK_CPU_DMI#: length 113.7
  TOP w0.102: v1(74.64,33.71) 74.43,33.92 74.43,34.8 RC18.2 ; UH4.AV22 36.07,114.94 v1(35.66,115.35)
  IN1 w0.117: v1(74.64,33.71) 74.43,33.91 74.43,34.19 74.18,34.44 62.77,34.44 59.8,37.42 59.8,39.2 57.52,41.47 57.52,43.53 55.25,45.8 55.25,66.9 56.11,67.76 56.11,70.03 57.16,71.08 57.16,73.64 56.49,74.32 56.49,79.27 55.83,79.93 55.83,81.17 55.6,81.4 v3(55.6,81.64)
  IN3 w0.102: v1(35.66,115.35) 35.58,115.28 35.58,115.13 35.79,114.92 40.01,114.92 40.07,114.86 41.59,114.86 42.54,113.91 42.54,113.27 42.73,113.08 42.73,109.92 42.86,109.8 42.86,109.7 42.87,109.69 42.87,109.68
  IN3 w0.127: 42.87,109.68 42.87,108.91 46.32,105.46 46.32,104.1 50.18,100.24 51.18,100.24 52.62,98.8 52.62,96.77 53.72,95.67 53.72,95.16 56.32,92.56 56.32,91.3 54.76,89.74 54.76,83.92 55.6,83.08 v3(55.6,81.64)
CLK_CPU_ITP: length 40.3
  TOP w0.102: RH1.2 57.36,80.19 57.59,80.19 v3(57.76,80.35) 57.9,80.21 58.15,80.21 58.52,80.58 RH3.2
  IN1 w0.117: v1(54.01,91.62) 53.91,91.62 53.81,91.52 53.81,91.14 54.43,90.53 56.07,90.53 56.66,91.11 59.76,91.11 62.13,88.74 62.13,86.07 59.69,83.63 58.31,83.63 56.65,81.98 56.65,80.9 57.25,80.3 57.71,80.3 v3(57.76,80.35)
  BOTTOM w0.102: RH281.2 42.31,97.69 42.71,97.69 43.64,96.76 43.64,96.22 45.1,94.76 45.1,94.26 45.69,93.66 50.49,93.66 51.27,92.89 53.06,92.89 53.76,92.19 53.76,91.87 v1(54.01,91.62)
CLK_CPU_ITP#: length 40.4
  TOP w0.102: RH4.2 58.17,79.95 57.99,79.95 v1(57.76,79.72) 57.55,79.92 57.32,79.92 RH2.2
  IN1 w0.117: v3(53.38,91.62) 53.52,91.47 53.52,91.03 54.31,90.24 56.19,90.24 56.77,90.82 59.64,90.82 61.84,88.63 61.84,86.19 59.57,83.91 58.19,83.91 56.37,82.09 56.37,80.78 57.13,80.02 57.46,80.02 v1(57.76,79.72)
  BOTTOM w0.102: RH280.2 42.22,97.42 42.6,97.42 43.37,96.65 43.37,96.11 44.83,94.64 44.83,94.15 45.58,93.4 50.38,93.4 51.16,92.62 52.95,92.62 53.49,92.08 53.49,91.73 v3(53.38,91.62)
CLK_DDC2_CRT: length 21.5
  IN3 w0.127: v1(64.17,172.06) 64.88,172.77 JCRT1.15
  BOTTOM w0.102: U19.35 61.37,156.93 61.21,157.09 61.21,160.15 v2(66.48,165.41) 67.02,165.95 67.02,167.99 R48.2 67.08,169.13 66.14,169.13 65.25,170.02 65.25,170.41 64.17,171.49 v1(64.17,172.06)
CLK_DDC2_DOCK: length 67.6
  IN3 w0.127: v1(92.8,123.79) 92.8,123.65 92.26,123.11 90.42,123.11 86.87,126.67 81.77,126.67 80.88,127.56 80.88,128.52 74.98,134.43 74.98,135.23 75.53,135.77 75.53,137.63 74.86,138.29 74.86,138.53 74.55,138.85 73.73,138.85 73.2,139.38 72.08,139.38 71.43,140.03 70.64,140.03 70.23,140.45 70.23,140.45 70.12,140.56 69.51,140.56 68.62,139.68 63.94,139.68 58.63,144.98 58.63,145.72 55.07,149.29 55.07,149.78 v3(54.91,149.94)
  BOTTOM w0.102: U19.26 58.57,154.19 58.42,154.04 55.67,154.04 54.17,152.54 53.66,152.54 53.14,152.01 53.14,151.33 54.09,150.37 54.95,150.37 55.1,150.21 55.1,150.13 v3(54.91,149.94) ; v1(92.8,123.79) 93.24,124.23 JDOCK1.48
CLK_KBD: length 112.8
  TOP w0.102: U54.A38 173.68,145.88 174.57,144.98 174.57,144.32 v1(175,143.89) 175.58,143.32 R845.1 ; v1(174.43,120.45) 174.59,120.6 174.59,124.5 173.59,125.49 173.59,133.48 174.42,134.3 174.42,135.37 174.32,135.48 174.32,136.2 174.59,136.47 175.14,136.47 175.8,137.14 175.8,139.23 174.73,140.3 174.32,140.3 v1(174.09,140.53)
  IN2 w0.127: v1(116.88,130.26) 117.14,130.53 122.19,130.53 122.48,130.24 129.52,130.24 130.62,131.34 152.7,131.34 156.92,127.13 164.58,127.13 164.95,127.5 168.21,127.5 174.38,121.32 174.38,120.5 v1(174.43,120.45)
  BOTTOM w0.102: v1(174.09,140.53) 174.93,141.36 v2(174.93,141.92) 174.93,143.82 v1(175,143.89) ; v1(116.88,130.26) 116.85,130.26 116.56,130.56 104.08,130.56 101.74,128.22 JDOCK1.78
CLK_MSE: length 170.9
  TOP w0.102: U54.A39 173.53,146.38 v1(175.03,144.88) 175.1,144.88 175.64,144.34 R851.1
  IN2 w0.127: v1(175.03,144.88) 176.01,145.86 177.58,145.86 179.26,144.18 179.26,143.71 180.44,142.53 181.43,142.53 183.62,140.35 185.36,140.35 185.46,140.25 187.98,140.25 191.06,137.17 191.06,113.13 193.8,110.39 193.8,107.95 195.43,106.32 195.43,105.81 195.17,105.55 195.17,105.04 v1(194.94,104.81) ; v1(181.98,101.08) 180.96,102.1 180.96,103.52 179.32,105.16 179.32,106.14 178.67,106.79 178.67,110.6 177,112.27 168.22,112.27 167.68,111.74 166.11,111.74 165.32,112.52 157.27,112.52 157.01,112.26 130.81,112.26 128.86,114.21 117.49,114.21 113.77,117.93 107.69,117.93 107.17,117.41 105.92,117.41 104.67,118.66 104.67,119.36 102.65,121.37 v1(101.26,121.37)
  BOTTOM w0.102: v1(181.98,101.08) 182.43,101.54 184.06,101.54 187.34,104.81 v2(192.21,104.81) v1(194.94,104.81) ; JDOCK1.71 100.24,120.37 101.24,121.37 v1(101.26,121.37)
CLK_PCH_14M: length 11.7
  TOP w0.102: v5(21.77,126.32) 21.8,126.32 22.18,125.95 UH4.K45 ; RH183.1 22.71,135.33 22.81,135.23 v1(22.81,135.2)
  IN4 w0.109: v5(21.77,126.32) 22.27,126.83 22.27,127.28 23.96,128.97 23.96,130.15 23.76,130.35 23.76,132.23 23.4,132.59 23.4,134.05 23.25,134.2 23.25,134.9 22.95,135.2 v1(22.81,135.2)
CLK_PCI_5048: length 275
  TOP w0.127: v1(52.45,140.25) 51.47,139.27 46.63,139.27 45.52,138.15 43.22,138.15 42.68,138.69 36.98,138.69 35.63,140.04 30.06,140.04 29.08,141.02 22.51,141.02 CH23.2 20.83,140.28 19.28,140.28 18.53,139.54 18.53,137.52 18.64,137.4 RH160.2 ; v1(124.97,115.7) 124.97,112.54 134.24,103.26 139.48,103.26 143.71,99.04 v1(143.71,98.12)
  IN4 w0.127: v1(225.11,72.29) 224.15,71.34 218.26,71.34 215.9,73.7 215.9,78.49 214.45,79.93 207.39,79.93 205.84,81.48 197.16,81.48 192.69,85.96 192.69,87.89 192.39,88.19 191.64,88.19 190.75,87.29 185.72,87.29 184.02,85.6 176.04,85.6 170.74,90.89 163.07,90.89 158.47,95.49 157.11,95.49 155.61,96.99 151.55,96.99 151.01,97.52 144.31,97.52 v1(143.71,98.12)
  BOTTOM w0.102: v1(225.11,72.29) 225.39,72.57 227.57,72.57 228.03,72.11 R795.1 228.55,72.11 229.44,73 229.44,73.3 230.08,73.95
  BOTTOM w0.127: v1(124.97,115.7) 124.89,115.7 117.85,108.66 98.18,108.66 96.84,107.32 86.9,107.32 86.1,108.12 83.09,108.12 81.28,109.93 81.28,111.46 71.56,121.17 71.56,123.36 70.62,124.31 70.62,131.19 71.74,132.31 71.74,135.46 71.21,135.99 70.74,135.99 67.74,138.99 v2(66.32,138.99) 64.95,138.99 64.3,139.64 54.86,139.64 54.54,139.32 53.11,139.32 52.45,139.98 v1(52.45,140.25) ; U46.A28 230.08,73.95
CLK_PCI_DOCK: length 152.3
  TOP w0.127: v1(53.95,136.34) 53.95,137.81 54.48,138.34 54.48,140.63 54.09,141.02 53.85,141.02 53.32,141.55 51.87,141.55 51.74,141.42 51.74,140.88 51.87,140.75 52.91,140.75 53.03,140.63 53.03,139 52.78,138.75 46.86,138.75 45.76,137.64 42.82,137.64 42.28,138.18 36.77,138.18 35.42,139.53 29.57,139.53 29.27,139.83 27.99,139.83 27.86,139.95 27.86,140.39 27.74,140.51 27.46,140.51 27.33,140.39 27.33,139.94 27.2,139.81 26.94,139.81 26.81,139.94 26.81,140.39 26.68,140.51 26.43,140.51 26.3,140.39 26.3,139.94 26.18,139.81 25.92,139.81 25.79,139.94 25.79,140.39 25.67,140.51 25.41,140.51 25.29,140.39 25.29,139.94 25.16,139.81 24.91,139.81 24.78,139.94 24.78,140.26 24.65,140.39 22.76,140.39 22.37,140 CH21.2 21.89,139.31 20.79,139.31 20.66,139.18 20.66,138.95 20.79,138.82 21.35,138.82 21.47,138.7 21.47,138.44 21.35,138.32 20.83,138.32 20.7,138.19 20.7,137.69 19.85,136.84 RH103.2 ; v1(114.91,113.03) 114.91,107.67 v1(115.54,107.04)
  BOTTOM w0.127: v1(53.95,136.34) 53.95,136.44 54.93,137.41 60.87,137.41 61.44,137.99 v2(61.68,137.99) 63.66,137.99 64.96,136.69 65.61,136.69 68.91,133.39 68.91,130.62 69,130.53 69,123.77 70.04,122.73 70.04,120.54 78.93,111.65 78.93,110.05 82.42,106.56 83.09,106.56 84.99,104.66 96.92,104.66 99.3,107.04 v1(115.54,107.04) ; JDOCK1.121 113.74,117.83 114.06,117.51 114.3,117.51 114.69,117.12 114.69,115.6 113.94,114.85 113.89,114.85 R756.1 114.88,113.06 v1(114.91,113.03)
CLK_PCI_LOOPBACK: length 143.3
  TOP w0.102: UH4.H45 21.25,125.96 20.93,126.28 v1(20.7,126.28) ; CH20.2 20.01,138.23 v3(19.63,137.86)
  IN4 w0.109: v1(20.7,126.28) 20.7,125.84 20.57,125.72 18.26,125.72 17.83,126.15 17.83,126.77 17.94,126.88 19.25,126.88 19.37,127 19.37,127.19 19.25,127.31 17.94,127.31 17.83,127.42 17.83,127.64 17.94,127.75 19.25,127.75 19.38,127.88 19.38,128.06 19.25,128.19 17.94,128.19 17.83,128.3 17.83,128.47 17.96,128.6 19.58,128.6 19.7,128.72 19.7,128.89 19.58,129.01 18.09,129.01 17.96,129.13 17.96,129.32 18.07,129.43 19.47,129.43 19.59,129.56 19.59,131.23 19.47,131.36 18.12,131.36 17.99,131.49 17.99,131.7 18.12,131.83 19.12,131.83 19.25,131.95 19.25,132.13 19.12,132.26 18.28,132.26 18.15,132.39 18.15,132.61 18.28,132.74 19.04,132.74 19.16,132.87 19.16,135.27 19.29,135.4 20.04,135.4 20.16,135.52 20.16,135.75 20.04,135.88 18.45,135.88 18.33,136 18.33,136.23 18.45,136.36 22.93,136.36 23.06,136.49 23.06,136.74 22.93,136.87 18.52,136.87 18.39,137 18.39,137.24 18.52,137.36 22.14,137.36 22.27,137.49 22.27,137.94 22.14,138.06 20.18,138.06 20.06,138.19 20.06,138.47 20.18,138.6 24.5,138.6 24.63,138.72 24.63,138.98 24.5,139.1 20.17,139.1 20.04,139.23 20.04,139.56 20.17,139.69 23.54,139.69 23.67,139.81 23.67,140.13 23.54,140.26 20.45,140.26 20.32,140.39 20.32,140.59 20.45,140.72 23.81,140.72 23.94,140.84 23.94,141.07 23.81,141.2 20.39,141.2 20.27,141.33 20.27,141.57 20.39,141.69 23.81,141.69 23.94,141.82 23.94,142.1 23.81,142.23 20.79,142.23 20.66,142.35 20.66,142.6 20.79,142.72 23.59,142.72 23.71,142.85 23.71,143.13 23.59,143.26 20.9,143.26 20.78,143.38 20.78,143.64 20.9,143.76 22.6,143.76 22.72,143.89 22.72,144.12 22.6,144.25 20.28,144.25 20.15,144.12 20.15,142.3 19.61,141.76 19.61,140.4 19.48,140.27 18.75,140.27 18.63,140.15 18.63,139.93 18.75,139.8 19.06,139.8 19.18,139.68 19.18,139.46 19.06,139.33 17.51,139.33 17.38,139.21 17.38,138.94 17.51,138.81 19.42,138.81 19.54,138.68 19.54,138.5 19.42,138.37 18.57,138.37 18.46,138.26 18.46,137.99 18.59,137.86 v3(19.63,137.86)
  BOTTOM w0.102: RH105.2 19.24,136.83 19.11,136.96 19.11,139.97 19.24,140.09 19.82,140.09 19.95,140.22 19.95,140.93 20.07,141.05 20.25,141.05 20.37,140.93 20.37,139.98 20.49,139.87 20.66,139.87 20.78,139.98 20.78,141.01 20.9,141.14 21.11,141.14 21.24,141.01 21.24,139.68 21.34,139.57 21.54,139.57 21.65,139.68 21.65,141.02 21.77,141.14 21.93,141.14 22.05,141.02 22.05,139.68 22.15,139.57 22.36,139.57 22.46,139.68 22.46,141.01 22.58,141.14 22.75,141.14 22.87,141.01 22.87,139.69 22.99,139.57 23.15,139.57 23.26,139.69 23.26,141.02 23.38,141.14 23.61,141.14 23.71,141.03 23.71,140.73 23.82,140.63 24.02,140.63 24.12,140.73 24.12,141.03 24.22,141.14 24.43,141.14 24.53,141.03 24.53,140.73 24.63,140.63 24.83,140.63 24.93,140.73 24.93,141.03 25.04,141.14 25.82,141.14 25.94,141.01 25.94,140.35 25.82,140.22 25.16,140.22 25.03,140.09 25.03,139.69 24.9,139.56 24.69,139.56 24.56,139.69 24.56,140.09 24.43,140.22 23.8,140.22 23.67,140.09 23.67,139.26 23.54,139.13 19.57,139.13 19.44,139 19.44,138.89 19.57,138.76 20.05,138.76 20.18,138.63 20.18,137.94 20.1,137.86 v3(19.63,137.86)
CLK_PCI_MEC: length 205.3
  TOP w0.127: v1(131.85,128.65) 132.17,128.97 132.17,132.3 134.35,134.48 136.42,134.48 v1(136.98,133.92) ; R885.1 168.32,139.15 v1(168.32,139.87) 168.32,139.93 169.03,140.63 169.03,141.12 168.97,141.17 U54.A29
  BOTTOM w0.102: 20.67,137.9 CH22.2
  BOTTOM w0.127: v1(136.98,133.92) 153.5,133.92 155.74,131.69 163,131.69 166.25,134.94 166.25,139.01 167.23,139.99 168.2,139.99 v1(168.32,139.87) ; v1(131.85,128.65) 131.68,128.49 131.68,121.93 126.13,116.38 126.13,115.51 118.23,107.61 98.88,107.61 96.44,105.17 87.4,105.17 85.49,107.07 82.65,107.07 79.44,110.29 79.44,111.86 70.55,120.75 70.55,122.94 69.51,123.98 69.51,130.74 69.42,130.83 69.42,133.69 65.7,137.41 65,137.41 63.92,138.49 61.12,138.49 60.55,137.92 48.19,137.92 46.57,136.3 46.57,135.88 45.15,134.46 41.12,134.46 v2(37.67,137.91) 37.06,138.52 33.69,138.52 31.14,141.07 27.37,141.07 25.36,139.07 24.6,139.07 24.17,138.63 21.37,138.63 CH22.2 ; RH102.2 20.67,137.9
CLK_PCI_TPM_TCM: length 196.1
  TOP w0.127: v1(168.64,116.84) 168.5,116.7 168.5,111.1 170.05,109.55 170.05,109.11 171.04,108.12 RE5.1 171.04,107.47 170.86,107.28 U37.21 U39.21 ; v1(47.1,135.88) 47.01,135.97 46.58,135.97 45.92,136.63 42.14,136.63 41.6,137.17 36.35,137.17 35,138.52 29.11,138.52 28.81,138.81 24.65,138.81 24.03,138.19 22.64,138.19 21.69,137.24 RH311.1
  IN4 w0.127: v1(168.64,116.84) 167.8,116 154.76,116 152.76,114.01 134.8,114.01 130.69,118.11 129.91,118.11 v1(129.63,118.39)
  BOTTOM w0.127: v1(129.63,118.39) 127.15,115.91 127.15,115.09 117.88,105.82 103.01,105.82 100.84,103.65 84.3,103.65 82.42,105.52 81.38,105.52 79.45,107.46 79.45,108.01 75.13,112.33 75.13,114.01 69.02,120.12 69.02,122.31 67.58,123.75 67.58,132.8 67.12,133.26 66.36,133.26 64.87,134.75 64.87,135.19 63.35,136.72 62.2,136.72 61.12,135.64 v2(58.27,135.64) 57.26,135.64 56.98,135.36 53.01,135.36 52.65,135.71 52.65,135.95 52.42,136.18 51.9,136.18 51.18,136.91 48.93,136.91 47.64,135.61 47.33,135.61 47.1,135.84 v1(47.1,135.88)
CLK_PCIE_CARD: length 141.5
  TOP w0.102: v3(28.48,137.1) 28.64,136.94 28.64,136.77 28.31,136.43 RH86.2 ; JIO1.28 37.25,37.75 37.49,37.99 38.91,37.99 v1(39.09,37.81)
  IN3 w0.102: 42.77,117.72 41.46,119.02 41.46,121.82 40.98,122.31 40.98,125.17 41.68,125.87 41.68,127.1 39.67,129.11 38.71,129.11 38.47,129.35 ; 37.59,130.23 37.59,130.25
  IN3 w0.127: 37.59,130.25 37.59,131.57 35.77,133.39 32.57,133.39 32.03,133.93 32.03,135.79 32.65,136.41 32.65,137.35 32.05,137.95 28.79,137.95 28.48,137.64 v3(28.48,137.1) ; v1(39.09,37.81) 39.93,37.81 42.42,40.3 50.44,40.3 56.04,45.9 56.04,49.42 56.55,49.92 56.55,66.62 57.33,67.39 57.33,67.77 57.33,73.42 59.82,75.91 59.82,82.61 62.68,85.48 62.68,89.41 58.67,93.42 57.75,93.42 55.42,95.75 55.42,96.37 54.19,97.6 54.19,99.64 51.74,102.08 50.62,102.08 49.69,103.01 49.69,104.66 48.58,105.78 48.58,110.64 46.33,112.89 46.33,115.43 44.04,117.72 42.77,117.72 ; 38.47,129.35 37.59,130.23
CLK_PCIE_CARD#: length 141.5
  TOP w0.102: JIO1.26 37.25,38.35 37.35,38.25 38.62,38.25 v3(39.06,38.7) ; RH85.2 28.97,136.77 28.97,136.95 v1(29.12,137.1)
  IN3 w0.102: 42.77,117.41 42.66,117.41 41.18,118.89 41.18,121.71 40.7,122.19 40.7,125.29 41.4,125.99 41.4,126.99 39.56,128.83 38.59,128.83 38.07,129.35
  IN3 w0.127: v1(29.12,137.1) 29.11,137.1 28.79,137.42 28.79,137.52 28.92,137.64 31.93,137.64 32.35,137.22 32.35,136.54 31.72,135.92 31.72,133.81 32.45,133.08 35.65,133.08 37.29,131.45 37.29,130.14 38.07,129.35 ; v3(39.06,38.7) 38.63,38.7 38.58,38.65 38.58,38.39 38.72,38.25 39.3,38.25 39.44,38.11 39.8,38.11 42.29,40.6 50.32,40.6 55.74,46.02 55.74,49.54 56.25,50.05 56.25,66.74 57,67.49 57,67.62 57.02,67.64 57.02,73.55 59.51,76.03 59.51,82.74 62.38,85.61 62.38,89.29 58.55,93.12 57.62,93.12 55.12,95.62 55.12,96.24 53.88,97.47 53.88,99.51 51.62,101.78 50.49,101.78 49.39,102.88 49.39,104.53 48.27,105.65 48.27,110.52 46.02,112.76 46.02,115.3 43.92,117.41 42.77,117.41
CLK_PCIE_EXP: length 149.8
  TOP w0.102: JIO1.60 37.1,28.15 37.27,28.32 37.42,28.32 37.59,28.14 v1(37.59,28.13)
  IN3 w0.102: 42.39,121.58 42.39,121.58 41.87,122.1 41.87,124.91 42.57,125.6
  IN3 w0.127: 42.39,121.58 42.66,121.31 43.69,121.31 44.03,120.97 44.03,120.26 43.69,119.91 43.69,119.27 49.45,113.5 49.45,106.21 50.57,105.09 50.57,103.29 50.96,102.9 52.08,102.9 55.07,99.91 55.07,98.01 55.73,97.35 57.28,97.35 60.92,93.7 60.92,92.55 63.54,89.93 63.54,84.9 62.81,84.18 62.81,83.22 62.42,82.83 61.47,82.83 60.78,82.14 60.78,75.67 60.32,75.21 60.32,72.23 58.24,70.14 58.24,46.48 57.59,45.83 57.16,45.83 50.71,39.38 43.36,39.38 41.27,37.3 41.27,30.76 40.19,29.68 39.64,29.68 38.69,28.73 38.69,28.65 38.18,28.13 v1(37.59,28.13) ; 42.57,125.6 42.57,127.75 39.51,130.81 39.51,131.64 34.81,136.34 34.26,136.34 34.16,136.44 v3(34.16,137.1)
  BOTTOM w0.102: v3(34.16,137.1) 34.03,137.1 33.62,136.68 33.62,136.33 31,133.71 29.95,133.71 29.44,133.2 29.44,132.99 RH93.2
CLK_PCIE_EXP#: length 149.8
  TOP w0.102: v1(37.59,28.77) 37.41,28.58 37.28,28.58 37.11,28.75 JIO1.58
  IN3 w0.102: 42.18,121.36 42.17,121.37 42.17,121.39 42.1,121.46 42.1,121.48 41.59,121.98 41.59,125.03 42.26,125.71
  IN3 w0.127: 42.26,125.71 42.26,127.62 39.2,130.68 39.2,131.51 34.68,136.03 34.14,136.03 33.86,136.31 33.86,136.77 33.54,137.08 v3(33.54,137.33) ; 42.18,121.36 42.51,121.03 43.54,121.03 43.72,120.85 43.72,120.38 43.38,120.04 43.38,119.14 49.15,113.37 49.15,106.08 50.27,104.97 50.27,103.16 50.84,102.59 51.95,102.59 54.76,99.78 54.76,97.88 55.6,97.04 57.15,97.04 60.62,93.57 60.62,92.42 63.23,89.8 63.23,85.03 62.51,84.3 62.51,83.35 62.29,83.13 61.34,83.13 60.48,82.27 60.48,75.79 60.02,75.34 60.02,72.35 57.94,70.27 57.94,46.61 57.47,46.14 57.03,46.14 50.58,39.69 43.23,39.69 40.97,37.43 40.97,30.89 40.07,29.99 39.51,29.99 38.38,28.85 38.38,28.77 38.05,28.44 37.92,28.44 v1(37.59,28.77)
  BOTTOM w0.102: v3(33.54,137.33) 33.54,136.98 33.35,136.79 33.35,136.44 30.88,133.97 29.83,133.97 29.18,133.31 29.18,132.99 RH92.2
CLK_PCIE_LAN: length 125
  TOP w0.102: RH83.2 30.47,132.99 30.47,134.3 v3(30.67,134.51) ; v1(122.9,165.32) 122.72,165.14 122.72,165.02 122.89,164.85 123.08,164.85 123.45,164.48 U31.44
  IN1 w0.117: v1(122.9,165.32) 122.69,165.11 122.69,164.7 122.35,164.36 121.43,164.36 119.4,166.38 115.7,166.38 108.52,159.2 107.91,159.2 104.7,155.99 104.7,154.04 104.81,153.93 104.81,152.85 104.01,152.04 104.01,150.41 102.83,149.23 102.46,149.23 96.74,143.5 96.74,140.26 96.34,139.86 93.29,139.86 93.04,140.11 91.78,140.11 91.38,139.71 89.98,139.71 89.13,138.86 80.93,138.86 80.74,138.66 77.08,138.66 75.1,140.64 75.1,142.03 73.63,143.5 68.97,143.5 68.11,142.64 68.11,141.81 67.73,141.43 67.73,138.85 67.3,138.43 66.24,138.43 65.61,137.8 64.64,137.8 64.35,137.5 59.15,137.5 59.04,137.61 57.4,137.61 56.71,138.3 54.57,138.3 53.92,138.95 52.67,138.95 52.44,139.18 48.95,139.18 48.46,138.69 48.18,138.69 46.46,136.96 37.42,136.96 36.82,136.36 32.55,136.36 31.41,135.23 30.6,135.23 30.41,135.04 30.41,134.76 v3(30.67,134.51)
CLK_PCIE_LAN#: length 124.8
  TOP w0.102: U31.45 123.05,164.5 122.97,164.58 122.78,164.58 122.45,164.91 122.45,165.16 122.3,165.32 v1(122.26,165.32) ; RH82.2 30.15,132.96 30.15,134.38 v3(30.03,134.51)
  IN1 w0.117: v1(122.26,165.32) 122.41,165.17 122.41,164.82 122.24,164.64 121.55,164.64 119.52,166.67 115.59,166.67 108.41,159.49 107.8,159.49 104.42,156.11 104.42,153.92 104.53,153.82 104.53,152.96 103.73,152.16 103.73,150.53 102.71,149.51 102.34,149.51 96.45,143.62 96.45,140.37 96.23,140.15 93.41,140.15 93.15,140.4 91.67,140.4 91.26,139.99 89.86,139.99 89.01,139.14 80.82,139.14 80.62,138.94 77.2,138.94 75.39,140.75 75.39,142.15 73.75,143.78 68.85,143.78 67.83,142.76 67.83,141.93 67.44,141.55 67.44,138.97 67.19,138.71 66.12,138.71 65.49,138.08 64.52,138.08 64.23,137.79 59.27,137.79 59.16,137.9 57.51,137.9 56.82,138.59 54.69,138.59 54.04,139.24 52.78,139.24 52.55,139.46 48.83,139.46 48.34,138.97 48.07,138.97 46.34,137.25 37.3,137.25 36.7,136.65 32.43,136.65 31.3,135.51 30.48,135.51 30.13,135.16 30.13,134.64 30.15,134.62 v3(30.03,134.51)
CLK_PCIE_MINI1: length 96.1
  IN1 w0.117: v3(35.44,137.15) 35.21,137.38 35.21,137.52 35.43,137.74 46.13,137.74 47.86,139.47 48.14,139.47 48.8,140.13 51.66,140.13 52.51,140.98 54,140.98 54.44,140.54 58.42,140.54 60.2,142.32 62.26,142.32 63.42,143.48 63.86,143.48 64.37,143.99 67.6,143.99 68.78,145.16 73.57,145.16 75.94,142.79 76.17,142.79 78.73,140.23 85.03,140.23 85.9,141.1 93.23,141.1 101.19,149.06 101.19,151.02 101.45,151.27 102.79,151.27 102.93,151.13 102.93,151.04 102.78,150.88 102.78,150.47 102.7,150.39 102.55,150.39 102.34,150.61 v1(102.34,150.66)
  BOTTOM w0.102: RH308.2 31.48,132.99 31.48,133.13 31.75,133.4 31.93,133.4 35.24,136.72 35.24,136.94 v3(35.44,137.15) ; v1(102.34,150.66) 102.47,150.8 102.64,150.8 102.77,150.67 102.77,148.15 101.85,147.23 101.85,145.11 101.51,144.77 101.08,144.77 100.8,145.05 JMINI1.13
CLK_PCIE_MINI1#: length 96
  IN1 w0.117: v1(34.81,137.15) 34.92,137.26 34.92,137.64 35.31,138.03 46.01,138.03 47.74,139.76 48.02,139.76 48.68,140.42 51.54,140.42 52.4,141.27 54.12,141.27 54.56,140.83 58.3,140.83 60.09,142.61 62.14,142.61 63.3,143.76 63.74,143.76 64.25,144.27 67.49,144.27 68.66,145.45 73.69,145.45 76.06,143.08 76.29,143.08 78.85,140.51 84.91,140.51 85.78,141.38 93.11,141.38 100.91,149.18 100.91,151.13 101.33,151.55 102.91,151.55 103.22,151.25 v3(103.22,150.69)
  BOTTOM w0.102: v3(103.22,150.69) 103.03,150.5 103.03,148.04 102.12,147.12 102.12,145 101.62,144.5 101.18,144.5 100.93,144.25 JMINI1.11 ; RH307.2 31.22,133 31.22,133.24 31.64,133.67 31.82,133.67 34.97,136.83 34.97,136.98 v1(34.81,137.15)
CLK_PCIE_MINI2: length 237.7
  TOP w0.102: v1(186.75,91.86) 186.75,94.21 187.3,94.76 187.3,100.24 186.97,100.57 186.97,106.5 186.57,106.9 186.57,109.7 185.39,110.88 185.39,116.52 182.43,119.48 v1(182.43,120.85)
  IN3 w0.127: v3(28.31,140.36) 28.31,139.82 28.68,139.45 34.9,139.45 36.85,137.49 36.85,136.14 39.01,133.99 40.07,133.99 42.72,131.33 42.72,130.52 44.41,128.83 44.41,126.33 45.62,125.12 47.81,125.12 48.51,124.42 48.51,119.6 55.84,112.27 55.84,107.68 59.84,103.68 62.41,103.68 62.93,103.16 71.45,103.16 71.97,103.68 77.13,103.68 79.02,101.79 80.08,101.79 80.49,102.2 87.97,102.2 97.34,111.57 117.52,111.57 120,114.05 126.64,114.05 127.28,114.68 133.31,114.68 133.95,114.05 159.36,114.05 163.73,118.42 167.04,118.42 167.7,119.08 174.37,119.08 175.66,120.37 179.93,120.37 180.65,119.65 181.8,119.65 182.43,120.28 v1(182.43,120.85)
  BOTTOM w0.102: JMINI2.13 197.49,91.51 197.76,91.78 197.76,92.25 197.37,92.63 193.65,92.63 193.24,93.04 186.85,93.04 186.4,92.59 186.4,92.14 186.31,92.05 186.31,91.82 186.41,91.72 186.6,91.72 v1(186.75,91.86) ; v3(28.31,140.36) 28.31,140.36 28.68,139.99 28.68,139.86 29.09,139.44 29.09,138.99 28.93,138.82 28.53,138.82 28.47,138.88 28.47,139.23 RH96.2
CLK_PCIE_MINI2#: length 237.7
  TOP w0.102: v1(181.8,120.85) 182.17,120.49 182.17,119.37 185.13,116.41 185.13,110.77 186.31,109.59 186.31,106.79 186.7,106.39 186.7,100.46 187.03,100.13 187.03,94.87 186.48,94.32 186.48,92.3 186.35,92.16 186.35,92.02 186.22,91.9 186.07,91.9 185.9,92.06 v1(185.9,92.2)
  IN3 w0.127: v1(181.8,120.85) 181.81,120.85 182.13,120.53 182.13,120.41 181.68,119.96 180.78,119.96 180.06,120.68 175.54,120.68 174.24,119.38 167.58,119.38 166.92,118.72 163.6,118.72 159.23,114.35 134.07,114.35 133.44,114.99 127.15,114.99 126.52,114.35 119.87,114.35 117.4,111.87 97.22,111.87 87.84,102.5 80.36,102.5 79.96,102.1 79.14,102.1 77.25,103.99 71.84,103.99 71.32,103.47 63.05,103.47 62.53,103.99 59.97,103.99 56.15,107.81 56.15,112.4 48.82,119.72 48.82,124.55 47.94,125.43 45.74,125.43 44.72,126.45 44.72,128.96 43.03,130.64 43.03,131.46 40.19,134.29 39.14,134.29 37.16,136.27 37.16,137.62 35.02,139.75 28.81,139.75 28.61,139.95 28.61,140.04 28.94,140.36 v3(28.94,140.36)
  BOTTOM w0.102: v3(28.94,140.36) 28.94,139.97 29.36,139.55 29.36,138.88 29.04,138.56 28.76,138.56 RH95.2 ; v1(185.9,92.2) 186.13,92.43 186.13,92.7 186.74,93.31 193.35,93.31 193.76,92.9 197.48,92.9 198.02,92.36 198.02,91.78 198.29,91.51 JMINI2.11
CLK_PCIE_MINI3: length 252.4
  TOP w0.102: v1(159.23,130.34) 158.86,129.97 158.77,129.97 158.43,130.31 158.43,132.1 157.85,132.69 157.85,133.73 151.8,139.78 151.8,147.57 150.72,148.65 150.72,151.58 152.87,153.72 152.87,157.37 153.26,157.76 153.26,159.34 152.94,159.66 152.94,160.48 153.1,160.63 153.21,160.63 153.41,160.43 v1(153.41,160.38)
  IN3 w0.127: v3(30.29,140.58) 30.44,140.73 30.44,141.21 30.71,141.48 31.53,141.48 32.24,140.77 34.03,140.77 34.95,141.68 35.63,141.68 37.71,139.61 37.88,139.61 40.96,136.53 40.96,136.22 45.25,131.93 61.61,131.93 62.22,131.32 64.6,131.32 65.57,130.35 65.57,124.07 64.4,122.9 64.4,119.8 63.46,118.86 63.46,114 64.35,113.11 64.71,113.11 65,113.4 65,113.68 65.47,114.15 66.24,114.15 67.05,113.34 67.05,112.24 72.78,106.52 78.38,106.52 81.01,103.89 87.35,103.89 96.65,113.2 110.84,113.2 111.69,114.05 117.24,114.05 120.01,116.82 126.44,116.82 128.27,118.64 128.27,123.66 127.84,124.09 127.84,126.8 133.73,132.69 137.83,132.69 138,132.86 152.49,132.86 155.33,130.01 158.9,130.01 v1(159.23,130.34)
  BOTTOM w0.102: v1(153.41,160.38) 153.5,160.47 154.3,160.47 156.31,162.47 168.29,162.47 169.45,163.64 172.46,163.64 173.15,162.94 174.01,162.94 174.55,163.47 174.55,164.07 174.64,164.16 JMINI3.13 ; RH90.2 27.16,133.01 27.16,133.17 27.4,133.4 28.08,133.4 28.54,133.85 28.54,134.03 30.09,135.59 31.41,135.59 32.35,136.52 32.35,137.25 30.47,139.13 30.47,140.4 v3(30.29,140.58)
CLK_PCIE_MINI3#: length 252.4
  TOP w0.102: v3(153.41,161.01) 153.3,160.9 152.99,160.9 152.68,160.59 152.68,159.55 152.99,159.23 152.99,157.87 152.6,157.48 152.6,153.83 150.46,151.69 150.46,148.54 151.53,147.46 151.53,139.67 157.58,133.62 157.58,132.58 158.16,131.99 158.16,130.2 158.66,129.71 v1(159.23,129.71)
  IN3 w0.127: v1(159.23,129.71) 155.21,129.71 152.36,132.55 138.12,132.55 137.96,132.39 133.86,132.39 128.14,126.67 128.14,124.22 128.57,123.79 128.57,118.52 126.57,116.51 120.14,116.51 117.37,113.74 111.82,113.74 110.97,112.89 96.78,112.89 87.47,103.58 80.88,103.58 78.25,106.21 72.66,106.21 66.75,112.12 66.75,113.21 66.12,113.84 65.59,113.84 65.3,113.55 65.3,113.27 64.83,112.8 64.22,112.8 63.16,113.87 63.16,118.99 64.1,119.93 64.1,123.02 65.26,124.19 65.26,130.23 64.48,131.01 62.09,131.01 61.48,131.62 45.12,131.62 40.65,136.09 40.65,136.4 37.75,139.3 37.58,139.3 35.51,141.38 35.08,141.38 34.16,140.46 32.12,140.46 31.41,141.17 30.83,141.17 30.75,141.09 30.75,140.77 30.92,140.59 v1(30.92,140.58)
  BOTTOM w0.102: v3(153.41,161.01) 153.69,160.73 154.19,160.73 156.2,162.74 168.18,162.74 169.34,163.91 172.57,163.91 173.26,163.21 173.9,163.21 174.28,163.59 174.28,164.07 174.24,164.11 173.91,164.11 173.84,164.18 JMINI3.11 ; v1(30.92,140.58) 30.73,140.39 30.73,139.24 32.61,137.36 32.61,136.41 31.52,135.32 30.2,135.32 28.8,133.92 28.8,133.74 28.19,133.13 27.51,133.13 27.43,133.06 27.43,132.96 27.77,132.62 RH88.2
CLK_PCIE_NVR: length 42.6
  IN4 w0.117: v3(31.44,136.34) 31.28,136.5 31.28,137.08 29.05,139.31 25.6,139.31 24.72,140.2 24.72,143.23 20.46,147.49 20.46,149.33 18.46,151.32 18.46,153.21 18.6,153.35 18.6,154.67 18.05,155.22 17.77,155.22 17.41,155.59 17.41,155.78 v1(17.53,155.9)
  BOTTOM w0.102: JMINI4.13 14.44,156.83 14.21,156.6 14.21,156.4 14.72,155.89 15.81,155.89 16.52,156.6 17,156.6 17.33,156.27 17.33,156.08 17.52,155.9 v1(17.53,155.9) ; v3(31.44,136.34) 31.33,136.45 31.33,136.82 31.09,137.06 30.3,137.06 28.41,135.17 27.81,134.57 27.1,134.57 26.7,134.16 25.97,134.16 24.93,133.12 24.93,132.81 RH312.2
CLK_PCIE_NVR#: length 42.7
  IN4 w0.117: v3(16.9,155.9) 17.12,155.67 17.12,155.47 17.66,154.94 17.93,154.94 18.32,154.55 18.32,153.47 18.18,153.33 18.18,151.2 20.17,149.21 20.17,147.37 24.43,143.11 24.43,140.08 25.49,139.03 28.93,139.03 30.99,136.97 30.99,136.55 v1(30.8,136.35)
  BOTTOM w0.102: RH310.2 25.53,132.4 25.25,132.4 25.2,132.45 25.2,133.01 26.08,133.9 26.81,133.9 27.21,134.3 27.92,134.3 28.6,134.98 30.41,136.79 30.98,136.79 31.06,136.71 31.06,136.54 30.87,136.35 v1(30.8,136.35) ; v3(16.9,155.9) 17.07,156.07 17.07,156.16 16.89,156.34 16.64,156.34 15.92,155.63 14.61,155.63 13.94,156.29 13.94,156.59 13.64,156.89 JMINI4.11
CLK_PCIE_VGA: length 211.5
  TOP w0.102: v1(195.81,124.32) 195.78,124.32 195.44,124.66 195.44,124.73 195.72,125.01 196.65,125.01 196.66,125 196.75,125 196.79,124.96 196.79,124.81 196.83,124.77 JMXM1.185 ; UH4.AB38 28.3,122.75 v1(28.62,123.08)
  IN1 w0.102: 42.74,112.25 42.73,112.25 41.55,113.42 41.55,116.1 41.01,116.65 41.01,117.55 40.64,117.92 38.01,117.92 37.76,118.17 37.76,118.61 37.02,119.34 37.02,120.5 36.6,120.91 35.36,120.91 35.05,121.22 30.06,121.22 29.68,121.6 29.68,122.6 29.37,122.91 28.79,122.91 v1(28.62,123.08)
  IN1 w0.117: v3(176.54,132.23) 176.65,132.12 176.65,131.88 176.38,131.62 175.74,131.62 175.1,132.26 166.36,132.26 166.13,132.49 163.05,132.49 161.62,133.92 159.89,133.92 159.33,134.48 157.44,134.48 156.69,135.23 133.27,135.23 128.59,139.92 128.59,140.98 128.11,141.46 120.58,141.46 118.66,139.54 118.66,138.41 111.5,131.24 110.18,131.24 109.68,130.75 103.06,130.75 102.52,131.29 97.84,131.29 97.21,130.66 89.63,130.66 88.93,129.95 88.93,128.21 87.91,127.19 87.91,121.86 84.1,118.05 83.72,118.05 83.03,117.36 83.03,116.42 81.61,115.01 78.05,115.01 75.99,112.94 70.81,112.94 67.27,109.41 65.82,109.41 64.96,108.54 63.79,108.54 62.96,107.71 61.99,107.71 61.39,107.11 56.64,107.11 56.11,106.58 52.71,106.58 51.84,107.46 49.16,107.46 47.66,108.95 46.72,108.95 46.47,109.2 46.47,109.87 45.29,111.05 44,111.05 42.8,112.25 42.74,112.25
  BOTTOM w0.102: v3(176.54,132.23) 176.69,132.37 176.69,132.7 176.96,132.97 179.56,132.97 180.67,131.86 185.45,131.86 186.18,131.14 189.16,131.14 195.59,124.71 195.59,124.54 v1(195.81,124.32)
CLK_PCIE_VGA#: length 211.4
  TOP w0.102: JMXM1.183 196.77,125.27 196.77,125.27 195.61,125.27 195.17,124.84 v3(195.17,124.32) ; v1(28.62,122.38) 28.31,122.38 28.18,122.26 UH4.AB37
  IN1 w0.102: v1(28.62,122.38) 28.62,122.53 28.74,122.64 29.26,122.64 29.41,122.49 29.41,121.49 29.95,120.95 34.94,120.95 35.18,120.71 36.51,120.71 36.82,120.4 36.82,119.24 37.55,118.5 37.55,117.98 37.82,117.72 40.51,117.72 40.74,117.49 40.74,116.54 41.28,115.99 41.28,113.31 42.44,112.16 42.44,112.14 42.6,111.98 42.67,111.98 42.67,111.97
  IN1 w0.117: 42.67,111.97 43.88,110.76 45.17,110.76 46.18,109.75 46.18,109.09 46.6,108.67 47.54,108.67 49.04,107.17 51.72,107.17 52.59,106.29 56.22,106.29 56.76,106.83 61.51,106.83 62.11,107.42 63.07,107.42 63.9,108.26 65.08,108.26 65.94,109.12 67.39,109.12 70.92,112.66 76.11,112.66 78.17,114.72 81.73,114.72 83.31,116.31 83.31,117.24 83.84,117.77 84.22,117.77 88.19,121.74 88.19,127.07 89.22,128.09 89.22,129.84 89.75,130.37 97.33,130.37 97.96,131 102.4,131 102.94,130.46 109.8,130.46 110.29,130.96 111.61,130.96 118.95,138.29 118.95,139.43 120.7,141.17 127.99,141.17 128.3,140.87 128.3,139.8 133.15,134.95 156.57,134.95 157.32,134.2 159.21,134.2 159.77,133.64 161.5,133.64 162.94,132.2 166.01,132.2 166.24,131.97 174.98,131.97 175.62,131.33 176.5,131.33 176.93,131.77 176.93,131.98 v1(177.18,132.23)
  BOTTOM w0.102: v1(177.18,132.23) 176.96,132.44 176.96,132.59 177.07,132.7 179.45,132.7 180.56,131.6 185.34,131.6 186.07,130.87 189.05,130.87 195.17,124.75 v3(195.17,124.32)
CLK_SIO_14M: length 279.5
  TOP w0.102: RH313.1 18.64,133.57 v1(18.63,133.58) ; v1(125.61,115.81) 125.61,112.92 134.66,103.87 139.76,103.87 145.3,98.34 v1(145.3,98.12)
  IN4 w0.109: v1(145.3,98.12) 145.38,98.04 151.31,98.04 151.82,97.54 155.79,97.54 157.29,96.03 159.32,96.03 159.33,96.03 163.92,91.44 171.16,91.44 172.99,89.62 182.41,89.62 183.17,88.86 192.42,88.86 193.19,88.09 193.19,86.17 197.36,81.99 206.05,81.99 207.6,80.45 214.67,80.45 216.41,78.71 216.41,73.93 218.46,71.87 221.16,71.87 221.68,72.39 v1(221.68,72.53)
  BOTTOM w0.102: v1(18.63,133.58) 18.63,133.73 17.53,134.84 17.2,134.84 16.91,135.12 16.91,135.92 17.07,136.07 17.36,136.07 18.46,137.17 18.46,137.57 18.63,137.74 18.63,140.29 19.96,141.62 v2(21.46,141.62) 31.31,141.62 33.72,139.21 37.31,139.21 41.51,135 44.79,135 46.05,136.26 46.05,136.5 47.98,138.43 60.3,138.43 60.87,139 64.17,139 64.74,138.43 67.54,138.43 70.31,135.66 70.31,131.6 70.11,131.4 70.11,124.1 71.05,123.15 71.05,120.96 80.72,111.3 80.72,109.73 82.87,107.58 85.83,107.58 86.63,106.78 97.33,106.78 98.69,108.14 118.05,108.14 125.61,115.71 v1(125.61,115.81) ; v1(221.68,72.53) 222.4,72.53 224.92,75.04 225.83,75.04 225.94,74.93 R794.1 227.34,74.93 227.84,75.43 228.57,75.43 228.93,75.78 230.7,75.78 230.87,75.95 U46.A32
CLK_TP_SIO: length 272.5
  TOP w0.102: JIO1.110 39.66,13.15 39.79,13.02 40.94,13.02 v1(41.25,13.32) ; U54.A37 172.68,145.38 172.95,145.65 173.51,145.65 173.99,145.17 v1(173.99,144.74) ; v1(178.9,91.92) 178.9,91.96 178.85,92.01 178.85,92.4 179.2,92.75 179.88,92.75 180.49,93.36 180.49,94.91 177.95,97.45 177.95,101.38 178.8,102.23 178.8,104.97 180.41,106.59 180.41,110.56 177.96,113.01 174.89,116.09 174.89,124.66 v2(174.42,125.13) 173.82,125.73 173.82,133.17 174.87,134.22 v1(174.87,135.09)
  IN1 w0.109: v1(178.9,91.92) 177.57,90.59 177.57,88.88 177.02,88.34 177.02,83.39 169.34,75.7 169.34,62.02 170.5,60.86 170.5,52.74 170.41,52.65 170.41,52.63 170.39,52.61 170.39,52.58 169.6,51.79 164.71,51.79 162.23,49.31 162.23,47.14 160.37,45.29 160.37,43.68 159.84,43.15 159.84,29.62 158.97,28.75 158.54,28.75 156.17,26.38 156.17,24.35 155.78,23.96 155.78,23.93 153.43,21.59 150.87,21.59 145.78,16.5 129.06,16.5 128.47,15.91 120.34,15.91 118.32,17.94 113.4,17.94 111.72,16.26 107.67,16.26 105.26,13.85 104.56,13.85 101.83,11.11 45.22,11.11 44.54,11.8 44.54,12.77 43.97,13.34 41.26,13.34 v1(41.25,13.32) ; v1(173.99,144.74) 173.99,144.25 175.22,143.02 175.22,142.24 175.46,142 175.46,135.71 174.87,135.12 v1(174.87,135.09)
CLK_XDP: length 75.4
  TOP w0.102: RH1.1 56.27,80.32 56.27,80.16 56.17,80.06 55.1,80.06 54.08,81.08 54.08,81.79 v1(54.45,82.16) ; v1(80.83,100.07) 80.84,100.07 81.2,99.71 81.2,97.63 77.84,94.27 76.38,94.27 75.18,93.08 75.18,92.61 74.84,92.27 v3(74.84,92.22)
  BOTTOM w0.102: JXDP1.14 75.15,91.9 v3(74.84,92.22) ; v1(80.83,100.07) 81.2,100.44 81.2,100.71 80.9,101 73.57,101 68.18,106.39 63.1,106.39 62.47,105.76 62.47,102.35 60.89,100.77 60.89,99.89 60.34,99.34 60.34,95.94 60.13,95.73 60.13,93.83 60.3,93.66 60.8,93.66 62.25,92.22 63.01,92.22 63.85,91.38 63.85,87.13 63.55,86.82 63.55,84.09 62.46,83 61.24,83 60.89,82.65 60.68,82.65 60.01,81.98 56.17,81.98 55.26,82.89 54.43,82.89 54.11,82.58 54.11,82.47 54.43,82.16 v1(54.45,82.16)
CLK_XDP#: length 75.4
  TOP w0.102: v1(75.61,92.33) 75.45,92.5 75.45,92.97 76.49,94.01 77.95,94.01 81.46,97.52 v1(81.46,100.07) ; v3(53.81,82.16) 53.81,80.97 54.99,79.79 55.78,79.79 RH2.1
  BOTTOM w0.102: v1(75.61,92.33) 75.41,92.13 75.41,91.96 75.49,91.89 75.56,91.89 75.65,91.8 JXDP1.15 ; v1(81.46,100.07) 81.46,100.82 81.01,101.27 73.68,101.27 68.3,106.66 62.99,106.66 62.2,105.87 62.2,102.46 60.62,100.88 60.62,100 60.07,99.45 60.07,96.05 59.87,95.84 59.87,93.72 60.19,93.4 60.69,93.4 62.14,91.95 62.9,91.95 63.59,91.27 63.59,87.24 63.28,86.93 63.28,84.2 62.35,83.26 61.13,83.26 60.78,82.92 60.57,82.92 59.9,82.25 56.28,82.25 55.37,83.16 54.32,83.16 53.85,82.69 53.85,82.19 v3(53.81,82.16)
CLK_XDP_ITP: length 10.8
  TOP w0.102: RH3.1 59.91,80.18 60.27,80.18 v1(60.52,79.93) 60.76,79.69 60.76,78.47 64.13,75.1 64.25,75.1 65.26,74.08 65.26,73.2 65.33,73.14 65.59,73.14 JCPU1.AN35
CLK_XDP_ITP#: length 10.9
  TOP w0.102: JCPU1.AM35 65.9,72.45 65.48,72.87 65.22,72.87 65,73.09 65,73.97 64.14,74.83 64.01,74.83 60.49,78.36 v1(60.49,78.61) 60.49,79.58 60.16,79.91 59.85,79.91 RH4.1
CLKRUN#: length 313.3
  TOP w0.102: v1(224.41,68.89) 224.42,68.87 231.18,68.87 231.29,68.97 v2(231.95,68.97) v1(233.13,68.97) ; U39.15 U37.15 174.76,106.17 v1(175.26,106.67) 175.33,106.67 175.35,106.66 176.03,106.66 176.63,107.25 176.63,110.35 170.7,116.28 170.7,135.55 v1(170.78,135.62) ; UH4.N3 23.73,105.41 24.03,105.11 24.03,104.82 23.87,104.66 v1(23.87,103.78) 23.87,103.54 22.87,102.54 22.87,102.01 22.2,101.33 RH137.2 ; v1(170.47,140.92) U54.A32
  IN1 w0.109: v1(170.47,140.92) 170.47,140.89 170.19,140.61 170.19,138.33 169.84,137.97 169.84,136.03 170.22,135.65 170.75,135.65 v1(170.78,135.62)
  IN2 w0.102: 24.19,103.19 23.87,103.51 v1(23.87,103.78)
  IN2 w0.127: v1(174.97,93.92) 174.2,94.68 174.2,97.45 172.55,99.1 150.58,99.1 149.04,100.64 131.72,100.64 128.9,97.82 109.73,97.82 108.5,99.05 82.92,99.05 82.34,98.48 78.88,98.48 78.43,98.93 74.9,98.93 74.37,98.4 74.37,97.6 73.57,96.8 67.21,96.8 66.18,97.83 66.18,98.11 62.39,101.89 46.61,101.89 45.87,101.16 43.2,101.16 41.58,102.78 37.73,102.78 36.34,101.38 32.85,101.38 32.5,101.03 30.86,101.03 30.09,100.25 28.43,100.25 27.61,101.08 25.11,101.08 24.28,101.91 24.28,103.1 24.19,103.19 ; v1(175.26,106.67) 175.26,104.7 176.29,103.67 176.29,101.09 181.53,95.85 181.53,93.85 181.99,93.38 v1(182.42,93.38) 182.66,93.14 182.85,93.14 187.37,88.62 187.37,88.25 187.93,87.69 188.3,87.69 190.17,85.83 190.17,69.29 191.33,68.12 202.96,68.12 204.99,66.09 213.47,66.09 217.44,70.05 221.44,70.05 221.94,69.55 221.94,69.32 222.35,68.91 224.38,68.91 v1(224.41,68.89)
  IN3 w0.127: v1(182.42,93.38) 182.42,93.37 182.31,93.26 178.33,93.26 177.62,92.55 175.89,92.55 174.98,93.46 174.98,93.89 174.97,93.91 v1(174.97,93.92)
  BOTTOM w0.102: U46.B20 232.91,69.2 v1(233.13,68.97)
COEX1_BT_ACTIVE: length 139.9
  TOP w0.102: JBT1.3 v1(300.56,104.89) ; v1(200.62,86.22) 201.28,86.88 202.55,86.88 202.98,86.46 202.98,83.69 203.38,83.29 204.76,83.29 204.95,83.48 204.95,84.16 205.36,84.57 208.47,84.57 210.23,86.34 210.23,91.54 210.67,91.97 217.38,91.97 218.29,91.07 227.03,91.07 231.49,86.61 232.97,86.61 236.43,83.16 241.16,83.16 241.65,82.66 261.07,82.66 263.73,80.01 275.35,80.01 275.8,80.47 276.51,80.47 276.93,80.89 276.93,80.92 277.6,81.59 277.6,82.89 280.27,85.56 v1(281.38,85.56)
  IN3 w0.127: v1(289.88,84.29) 289.66,84.51 289.66,90.22 291.23,91.8 292.35,91.8 292.96,92.41 293.69,92.41 295.6,94.32 297.46,94.32 298.56,95.43 298.56,105.11 298.97,105.51 300.16,105.51 300.56,105.11 v1(300.56,104.89)
  BOTTOM w0.102: v1(281.38,85.56) 282.32,84.62 v2(283.07,84.62) 289.52,84.62 289.85,84.29 v1(289.88,84.29) ; v1(200.62,86.22) 200.51,86.34 R702.1
COEX2_WLAN_ACTIVE: length 251
  TOP w0.102: v3(295.63,107.89) 295.56,107.82 JBT1.8
  IN2 w0.127: v1(183.31,139.34) 184.66,139.34 187.91,136.09 187.91,134.69 189.39,133.21 189.39,110.47 190.44,109.42 190.74,109.42 192.15,108.02 192.15,106.58 194.89,103.84 194.89,103.3 195.82,102.37 195.82,100.28 196.07,100.03 196.07,98.23 197.34,96.96 197.34,96.22 198.86,94.7 198.86,94.36 199.66,93.55 v1(200.14,93.55)
  IN3 w0.127: v1(183.31,139.34) 182.68,139.98 182.68,140.81 181.48,142.01 181.48,146.96 181.11,147.33 181.11,156.11 182.42,157.42 182.42,163.65 178.9,167.17 v1(178.62,167.17) ; v1(200.14,93.55) 198.59,93.55 198.25,93.21 198.25,91.38 200.29,89.33 200.29,87.81 201.86,86.23 v1(202,86.23) 202,87.83 203.22,89.05 216.66,89.05 218.53,87.19 220.15,87.19 220.86,86.47 232.61,86.47 234.34,84.75 236.96,84.75 237.95,83.76 239.84,83.76 241,82.6 244.3,82.6 245.57,81.33 246.8,81.33 247.9,80.23 247.9,78.92 250.49,76.33 250.49,71.18 251.31,70.37 272.02,70.37 272.6,69.79 273.35,69.79 274.66,68.48 278.33,68.48 278.73,68.87 292.17,68.87 292.62,69.32 292.62,79.56 288.48,83.7 288.48,93.74 290.68,95.94 290.68,101.69 295.63,106.64 v3(295.63,107.89)
  BOTTOM w0.102: R904.1 C753.1 295.5,108.01 v3(295.63,107.89) ; v1(202,86.23) 202.54,86.77 C600.1 R707.1 ; v1(178.62,167.17) 178.86,167.4 R724.1
COMP: length 20.3
  TOP w0.203: v1(29.82,74.05) 29.82,74.35 29.59,74.57 28.9,74.57 28.33,75.15 28.33,75.48 28.18,75.63 28.18,75.65 28.07,75.76 PU702.18
  IN4 w0.254: v1(26.41,69.16) 26.5,69.16 27.43,70.09 27.43,72.29 29.2,74.05 v1(29.82,74.05)
  BOTTOM w0.254: PR750.1 28.21,76.87 PC736.1 28.24,76.04 PC741.1 29.31,74.96 29.31,74.68 29.82,74.17 v1(29.82,74.05) ; PC733.2 22.74,71.48 22.74,70.54 23.75,69.53 v2(24.85,69.53) 25.08,69.3 26.27,69.3 v1(26.41,69.16)
CONTACTLESS_DET#: length 386.1
  TOP w0.102: JUSH1.17 115.99,28.8 115.48,28.29 v1(115.48,25.55) ; v1(158.29,98.15) 158.29,102.88 157.88,103.29 157.88,111.7 159.56,113.38 159.56,125.95 157.69,127.81 v3(157.69,128.26) ; UH4.C40 18.66,123.78 18.52,123.64 18.18,123.64 18.02,123.47 17.73,123.47 17.68,123.53 16.1,123.53 15.02,124.6 v1(15.02,124.64) 14.91,124.52 RH256.1
  IN2 w0.127: v3(157.69,128.26) 157.35,128.6 156.85,128.6 151.91,133.54 138.03,133.54 137.46,132.97 132.8,132.97 132.1,132.27 114.67,132.27 114.02,131.62 107.31,131.62 106.13,132.8 84.9,132.8 83.69,134.01 81.04,134.01 79.42,132.4 77.54,132.4 76.25,133.69 74.62,133.69 72.52,135.8 70.62,135.8 70.19,136.23 70.11,136.23 68.08,138.27 65.08,138.27 64.63,138.71 61.46,138.71 61.06,138.31 60.9,138.15 55.02,138.15 54.89,138.02 47.65,138.02 44.82,135.19 36.54,135.19 35.83,135.9 33.55,135.9 31.86,137.59 28.66,137.59 28.22,138.02 27.53,138.02 26.69,138.86 25.8,138.86 25.45,139.22 24.54,139.22 24.4,139.08 22.35,139.08 22.34,139.07 22.27,139.07 21.01,137.8 21.01,137.51 19.59,136.09 18.92,136.09 18.45,135.63 18.32,135.63 17.8,135.11 17.8,134.34 17.82,134.32 17.82,133.98 17.77,133.92 17.77,133.4 17.77,133.4 17.77,133.18 17.77,133.17 17.77,132.91 16.74,131.88 16.74,130.87 16.23,130.36 16.23,126.71 15.02,125.51 v1(15.02,124.64) ; v1(194.38,64.1) 194.22,63.93 190.64,63.93 185.22,69.36 185.22,82.49 182.75,84.95 182.75,88.66 181.5,89.92 177.69,89.92 173.5,94.1 173.5,97.09 172.38,98.22 158.37,98.22 v1(158.29,98.15)
  IN4 w0.109: v1(115.48,25.55) 115.71,25.55 119.09,22.17 119.09,20.77 120.84,19.02 122.24,19.02 123.02,18.24 130.48,18.24 133.17,15.55 150.45,15.55 152.03,17.13 154.33,17.13 154.77,17.58 156.55,17.58 162.65,23.68 162.65,38.86 176.84,53.05 179.22,53.05 180.88,54.71 183.26,54.71 183.87,55.32 183.87,55.99 184.38,56.5 185.35,56.5 185.82,56.03 188.61,56.03 189.24,56.67 191.83,56.67 196.28,61.12 196.28,62.2 v1(194.38,64.1)
CPU1.5V_S3_GATE: length 186.6
  TOP w0.102: v1(182.31,86.35) 182.03,86.63 181.02,86.63 179.22,88.43 179.22,89.53 178,90.74 178,92.85 178.59,93.43 179.55,93.43 179.81,93.69 179.81,94.52 177.25,97.08 177.25,101.65 178.12,102.52 178.12,105.42 v2(179.04,106.35) 179.54,106.85 179.54,110.47 172.83,117.17 172.83,135.04 v1(173.09,135.29) ; U54.A36 172.89,144.88 173.91,143.85 173.91,142.46 v1(173.94,142.43) 174.06,142.3 R889.2 ; v1(112.56,46.34) 112.56,46.38 112.85,46.67 114.19,46.67 114.48,46.38 118.85,46.38 120.08,47.61 120.08,48.97 119.71,49.34 RC83.1
  IN1 w0.109: v1(173.09,135.29) 173.09,135.74 173.48,136.14 173.48,142.13 173.81,142.46 173.91,142.46 v1(173.94,142.43)
  IN2 w0.127: v1(182.31,86.35) 182.31,83.27 183.23,82.34 183.23,74.81 184.96,73.08 184.96,62.88 v1(184.39,62.31)
  IN4 w0.109: v1(184.39,62.31) 184.15,62.55 179.16,62.55 177.93,63.78 177.27,63.78 168.98,55.5 167.16,55.5 166.59,54.94 157.51,54.94 156.54,53.98 149.83,53.98 148.33,52.48 142.11,52.48 141.34,53.24 136.46,53.24 132.92,49.7 116.38,49.7 113.03,46.34 v1(112.56,46.34)
CPU_DETECT#: length 232.5
  TOP w0.102: v1(174.29,90.11) 174.87,89.53 174.87,88.72 176.05,87.55 176.05,86.36 177.73,84.67 179.26,84.67 181.84,82.09 185.03,82.09 185.35,82.41 187.48,82.41 v2(187.93,81.96) 188.36,81.52 195.2,81.52 198.52,78.2 198.52,70.43 199.64,69.31 202.69,69.31 207.08,64.92 228.42,64.92 229.42,63.92 231.17,63.92 231.68,63.41 235.47,63.41 235.88,63.82 238.74,63.82 239.5,64.57 v1(239.5,64.77) ; JCPU1.AN34 66.9,73.5 66.47,73.93 65.67,73.93 65.48,74.12 65.48,74.4 64.87,75.01 64.87,75.39 62.19,78.07 62.19,79.58 v1(62.08,79.69)
  IN2 w0.127: v1(169.56,96.19) 169.56,95.99 169.18,95.61 164.36,95.61 163.68,96.29 162.7,96.29 162.39,95.99 151.33,95.99 150.85,95.5 145.87,95.5 145.06,94.69 141.91,94.69 138.85,91.63 134.05,91.63 133.17,92.51 110.42,92.51 107.44,95.49 87.37,95.49 85.2,93.32 82.07,93.32 80.03,91.29 80.03,84.84 79.23,84.04 77.09,84.04 75.23,85.89 71.54,85.89 70.6,84.95 64.57,84.95 62.61,83 61.36,83 60.82,82.45 60.82,80.95 v1(62.08,79.69)
  IN3 w0.127: v1(169.56,96.19) 169.61,96.14 169.72,96.14 170.67,95.19 172.55,95.19 174.76,92.98 174.76,90.58 v1(174.29,90.11)
  BOTTOM w0.102: v1(239.5,64.77) 239.5,64.17 R765.2 240.08,63.99 240.08,65.34 239.58,65.84 U46.A3
CPU_DMI: length 6.1
  TOP w0.089: 73.23,39.69 73.23,39.73 73.23,39.74 73.23,39.82 73.24,39.83 73.24,41.11 JCPU1.A28
  TOP w0.102: RC17.1 74.17,36.51 74.17,37.19 73.23,38.13 73.23,39.69
CPU_DMI#: length 6.1
  TOP w0.089: 73.49,39.69 73.49,41.04 JCPU1.A27
  TOP w0.102: RC18.1 74.43,36.44 v1(74.43,37.08) 74.43,37.3 73.49,38.24 73.49,39.69
CPU_DPLL: length 6.1
  TOP w0.089: 85.31,39.69 85.31,41.04 JCPU1.A16
  TOP w0.102: 85.31,39.69 85.31,37.8 84.25,36.74 84.25,36.43 RC19.1
CPU_DPLL#: length 6.1
  TOP w0.089: JCPU1.A15 85.56,41.11 85.56,39.8 85.57,39.8 85.57,39.71 85.58,39.7 85.58,39.69
  TOP w0.102: 85.58,39.69 85.58,37.69 84.95,37.06 ; v1(84.95,37.06) 84.95,37.06 ; 84.95,37.06 84.52,36.63 84.52,36.52 RC20.1
CPU_VTT_ON: length 242.4
  TOP w0.127: v1(109.12,16.99) 109.12,16.76 109.52,16.36 109.52,10.44 v1(110.55,9.41)
  IN1 w0.254: v1(109.12,16.99) 109.12,17.13 108.84,17.41 108.83,17.41 108.82,17.42 108.82,19.31 107.09,21.05 105.91,21.05 105.51,21.45 94.06,21.45 91.73,23.79 80.03,23.79 77.21,26.61 61.5,26.61 61.5,26.67 60.81,27.37 57.76,27.37 54.33,23.94 54.33,20.77 v1(54.71,20.38)
  IN3 w0.127: v1(110.55,9.41) 110.59,9.45 111.39,9.45 111.66,9.72 111.66,12.05 114.67,15.06 117.08,15.06 120.01,12.13 121.78,12.13 122.5,11.41 157.72,11.41 159.07,12.75 159.07,13.74 161.23,15.91 161.23,17.83 163.65,20.25 163.65,41.56 176.02,53.94 184.05,53.94 184.73,54.62 185.72,54.62 187.21,56.1 187.21,56.87 187.63,57.29 193.21,57.29 194.28,58.36 201.13,58.36 207.28,64.5 230.53,64.5 v3(230.58,64.55)
  BOTTOM w0.127: v3(230.58,64.55) 230.58,64.36 231.16,63.78 R789.1 231.24,65.7 232.83,67.29 U46.B17
  BOTTOM w0.254: v1(54.71,20.38) 54.97,20.65 54.97,20.74 55.51,21.28 PR504.1
