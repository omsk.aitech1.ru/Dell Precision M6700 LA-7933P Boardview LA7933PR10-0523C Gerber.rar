# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Nets (continued)
CLK_BUF_BCLK: RH91.1 UH4.BG30 UH4.BJ30
CLK_BUF_CKSSCD: RH79.1 UH4.AK5
CLK_BUF_CKSSCD#: RH78.1 UH4.AK7
CLK_BUF_DMI: RH75.1 UH4.BE18
CLK_BUF_DMI#: RH74.1 UH4.BF18
CLK_BUF_DOT96: RH77.1 UH4.E24
CLK_BUF_DOT96#: RH76.1 UH4.G24
CLK_CPU_DMI: RC17.2 UH4.AU22
CLK_CPU_DMI#: RC18.2 UH4.AV22
CLK_CPU_ITP: RH1.2 RH3.2 RH281.2
CLK_CPU_ITP#: RH2.2 RH4.2 RH280.2
CLK_DDC2_CRT: JCRT1.15 R48.2 U19.35
CLK_DDC2_DOCK: JDOCK1.48 U19.26
CLK_KBD: JDOCK1.78 R845.1 U54.A38
CLK_MSE: JDOCK1.71 R851.1 U54.A39
CLK_PCH_14M: RH183.1 UH4.K45
CLK_PCI_5048: CH23.2 R795.1 RH160.2 U46.A28
CLK_PCI_DOCK: CH21.2 JDOCK1.121 R756.1 RH103.2
CLK_PCI_LOOPBACK: CH20.2 RH105.2 UH4.H45
CLK_PCI_MEC: CH22.2 R885.1 RH102.2 U54.A29
CLK_PCI_TPM_TCM: RE5.1 RH311.1 U37.21 U39.21
CLK_PCIE_CARD: JIO1.28 RH86.2
CLK_PCIE_CARD#: JIO1.26 RH85.2
CLK_PCIE_EXP: JIO1.60 RH93.2
CLK_PCIE_EXP#: JIO1.58 RH92.2
CLK_PCIE_LAN: RH83.2 U31.44
CLK_PCIE_LAN#: RH82.2 U31.45
CLK_PCIE_MINI1: JMINI1.13 RH308.2
CLK_PCIE_MINI1#: JMINI1.11 RH307.2
CLK_PCIE_MINI2: JMINI2.13 RH96.2
CLK_PCIE_MINI2#: JMINI2.11 RH95.2
CLK_PCIE_MINI3: JMINI3.13 RH90.2
CLK_PCIE_MINI3#: JMINI3.11 RH88.2
CLK_PCIE_NVR: JMINI4.13 RH312.2
CLK_PCIE_NVR#: JMINI4.11 RH310.2
CLK_PCIE_VGA: JMXM1.185 UH4.AB38
CLK_PCIE_VGA#: JMXM1.183 UH4.AB37
CLK_SIO_14M: R794.1 RH313.1 U46.A32
CLK_TP_SIO: JIO1.110 U54.A37
CLK_XDP: JXDP1.14 RH1.1
CLK_XDP#: JXDP1.15 RH2.1
CLK_XDP_ITP: JCPU1.AN35 RH3.1
CLK_XDP_ITP#: JCPU1.AM35 RH4.1
CLKRUN#: RH137.2 U37.15 U39.15 U46.B20 U54.A32 UH4.N3
COEX1_BT_ACTIVE: JBT1.3 R702.1
COEX2_WLAN_ACTIVE: C600.1 C753.1 JBT1.8 R707.1 R724.1 R904.1
COMP: PC733.2 PC736.1 PC741.1 PR750.1 PU702.18
CONTACTLESS_DET#: JUSH1.17 RH256.1 UH4.C40
CPU1.5V_S3_GATE: R889.2 RC83.1 U54.A36
CPU_DETECT#: JCPU1.AN34 R765.2 U46.A3
CPU_DMI: JCPU1.A28 RC17.1
CPU_DMI#: JCPU1.A27 RC18.1
CPU_DPLL: JCPU1.A16 RC19.1
CPU_DPLL#: JCPU1.A15 RC20.1
CPU_VTT_ON: PR504.1 R789.1 U46.B17
CRT_11: JCRT1.11 T61.1(TP-1)
CRT_EN: R421.2 U19.2
CRT_IREF: RH126.1 UH4.T43
CRT_SWITCH: U19.38 U19.40 U46.B52
CS_1.5V: PR202.2 PU201.13
CSS_GC: PR903.1 PU1001.10
CSSN_1: PQ902.3 PQ904.2 PR904.1 PR906.1 PR908.1
CSSP_1: PQ903.3 PQ904.5 PR904.2 PR905.1 PR907.1
D_CLKRUN#: JDOCK1.111 R777.1 U46.A19
D_DLDRQ1#: JDOCK1.117 R782.1 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 R780.1 U46.A20
DAI_12MHZ#: JDOCK1.89 JIO1.17 RE11.1
DAI_BCLK#: JDOCK1.77 JIO1.25 RE12.1
DAI_DI: JDOCK1.83 JIO1.21
DAI_DO#: JDOCK1.85 JIO1.23
DAI_LRCK#: JDOCK1.79 JIO1.27
DAT_DDC2_CRT: JCRT1.12 R47.2 U19.34
DAT_DDC2_DOCK: JDOCK1.46 U19.25
DAT_KBD: JDOCK1.80 R846.1 U54.B41
DAT_MSE: JDOCK1.73 R852.1 U54.B42
DAT_TP_SIO: JIO1.108 U54.B40
DC_BLOCK_GC: PR902.2 PU1001.7
DDR3_DRAMRST#: QC2.1 RD3.2 RD4.2
DDR3_DRAMRST#_CPU: JCPU1.R8 QC2.3 RC23.1
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 JDIMM3.30 JDIMM4.30 RD3.1
DDR_1.5V_CNTRL0: PR216.2 PR219.1 U46.A49
DDR_1.5V_CNTRL1: PR222.2 PR223.1 U46.A16
DDR_A_BS0: JCPU1.AE10 JDIMM1.109 JDIMM2.109
DDR_A_BS1: JCPU1.AF10 JDIMM1.108 JDIMM2.108
DDR_A_BS2: JCPU1.V6 JDIMM1.79 JDIMM2.79
DDR_A_CAS#: JCPU1.AE8 JDIMM1.115 JDIMM2.115
DDR_A_D0: JCPU1.C5 JDIMM1.5 JDIMM2.4
DDR_A_D1: JCPU1.D5 JDIMM1.7 JDIMM2.6
DDR_A_D2: JCPU1.D3 JDIMM1.16 JDIMM2.15
DDR_A_D3: JCPU1.D2 JDIMM1.18 JDIMM2.17
DDR_A_D4: JCPU1.D6 JDIMM1.4 JDIMM2.5
DDR_A_D5: JCPU1.C6 JDIMM1.6 JDIMM2.7
DDR_A_D6: JCPU1.C2 JDIMM1.15 JDIMM2.16
DDR_A_D7: JCPU1.C3 JDIMM1.17 JDIMM2.18
DDR_A_D8: JCPU1.F10 JDIMM1.22 JDIMM2.21
DDR_A_D9: JCPU1.F8 JDIMM1.24 JDIMM2.23
DDR_A_D10: JCPU1.G10 JDIMM1.33 JDIMM2.34
DDR_A_D11: JCPU1.G9 JDIMM1.35 JDIMM2.36
DDR_A_D12: JCPU1.F9 JDIMM1.21 JDIMM2.22
DDR_A_D13: JCPU1.F7 JDIMM1.23 JDIMM2.24
DDR_A_D14: JCPU1.G8 JDIMM1.34 JDIMM2.33
DDR_A_D15: JCPU1.G7 JDIMM1.36 JDIMM2.35
DDR_A_D16: JCPU1.K4 JDIMM1.40 JDIMM2.39
DDR_A_D17: JCPU1.K5 JDIMM1.42 JDIMM2.41
DDR_A_D18: JCPU1.K1 JDIMM1.51 JDIMM2.50
DDR_A_D19: JCPU1.J1 JDIMM1.53 JDIMM2.52
DDR_A_D20: JCPU1.J5 JDIMM1.39 JDIMM2.40
DDR_A_D21: JCPU1.J4 JDIMM1.41 JDIMM2.42
DDR_A_D22: JCPU1.J2 JDIMM1.50 JDIMM2.51
DDR_A_D23: JCPU1.K2 JDIMM1.52 JDIMM2.53
DDR_A_D24: JCPU1.M8 JDIMM1.56 JDIMM2.57
DDR_A_D25: JCPU1.N10 JDIMM1.58 JDIMM2.59
DDR_A_D26: JCPU1.N8 JDIMM1.67 JDIMM2.68
DDR_A_D27: JCPU1.N7 JDIMM1.69 JDIMM2.70
DDR_A_D28: JCPU1.M10 JDIMM1.57 JDIMM2.56
DDR_A_D29: JCPU1.M9 JDIMM1.59 JDIMM2.58
DDR_A_D30: JCPU1.N9 JDIMM1.68 JDIMM2.67
DDR_A_D31: JCPU1.M7 JDIMM1.70 JDIMM2.69
DDR_A_D32: JCPU1.AG6 JDIMM1.130 JDIMM2.129
DDR_A_D33: JCPU1.AG5 JDIMM1.132 JDIMM2.131
DDR_A_D34: JCPU1.AK6 JDIMM1.141 JDIMM2.140
DDR_A_D35: JCPU1.AK5 JDIMM1.142 JDIMM2.143
DDR_A_D36: JCPU1.AH5 JDIMM1.129 JDIMM2.130
DDR_A_D37: JCPU1.AH6 JDIMM1.131 JDIMM2.132
DDR_A_D38: JCPU1.AJ5 JDIMM1.140 JDIMM2.141
DDR_A_D39: JCPU1.AJ6 JDIMM1.143 JDIMM2.142
DDR_A_D40: JCPU1.AJ8 JDIMM1.148 JDIMM2.149
DDR_A_D41: JCPU1.AK8 JDIMM1.147 JDIMM2.146
DDR_A_D42: JCPU1.AJ9 JDIMM1.158 JDIMM2.157
DDR_A_D43: JCPU1.AK9 JDIMM1.160 JDIMM2.159
DDR_A_D44: JCPU1.AH8 JDIMM1.146 JDIMM2.147
DDR_A_D45: JCPU1.AH9 JDIMM1.149 JDIMM2.148
DDR_A_D46: JCPU1.AL9 JDIMM1.157 JDIMM2.158
DDR_A_D47: JCPU1.AL8 JDIMM1.159 JDIMM2.160
DDR_A_D48: JCPU1.AP11 JDIMM1.164 JDIMM2.163
DDR_A_D49: JCPU1.AN11 JDIMM1.166 JDIMM2.165
DDR_A_D50: JCPU1.AL12 JDIMM1.175 JDIMM2.174
DDR_A_D51: JCPU1.AM12 JDIMM1.177 JDIMM2.176
DDR_A_D52: JCPU1.AM11 JDIMM1.163 JDIMM2.164
DDR_A_D53: JCPU1.AL11 JDIMM1.165 JDIMM2.166
DDR_A_D54: JCPU1.AP12 JDIMM1.174 JDIMM2.175
DDR_A_D55: JCPU1.AN12 JDIMM1.176 JDIMM2.177
DDR_A_D56: JCPU1.AJ14 JDIMM1.183 JDIMM2.182
DDR_A_D57: JCPU1.AH14 JDIMM1.182 JDIMM2.183
DDR_A_D58: JCPU1.AL15 JDIMM1.192 JDIMM2.191
DDR_A_D59: JCPU1.AK15 JDIMM1.194 JDIMM2.193
DDR_A_D60: JCPU1.AL14 JDIMM1.181 JDIMM2.180
DDR_A_D61: JCPU1.AK14 JDIMM1.180 JDIMM2.181
DDR_A_D62: JCPU1.AJ15 JDIMM1.191 JDIMM2.192
DDR_A_D63: JCPU1.AH15 JDIMM1.193 JDIMM2.194
DDR_A_DQS0: JCPU1.D4 JDIMM1.12 JDIMM2.12
DDR_A_DQS1: JCPU1.F6 JDIMM1.29 JDIMM2.29
DDR_A_DQS2: JCPU1.K3 JDIMM1.47 JDIMM2.47
DDR_A_DQS3: JCPU1.N6 JDIMM1.64 JDIMM2.64
DDR_A_DQS4: JCPU1.AL5 JDIMM1.137 JDIMM2.137
DDR_A_DQS5: JCPU1.AM9 JDIMM1.154 JDIMM2.154
DDR_A_DQS6: JCPU1.AR11 JDIMM1.171 JDIMM2.171
DDR_A_DQS7: JCPU1.AM14 JDIMM1.188 JDIMM2.188
DDR_A_DQS#0: JCPU1.C4 JDIMM1.10 JDIMM2.10
DDR_A_DQS#1: JCPU1.G6 JDIMM1.27 JDIMM2.27
DDR_A_DQS#2: JCPU1.J3 JDIMM1.45 JDIMM2.45
DDR_A_DQS#3: JCPU1.M6 JDIMM1.62 JDIMM2.62
DDR_A_DQS#4: JCPU1.AL6 JDIMM1.135 JDIMM2.135
DDR_A_DQS#5: JCPU1.AM8 JDIMM1.152 JDIMM2.152
DDR_A_DQS#6: JCPU1.AR12 JDIMM1.169 JDIMM2.169
DDR_A_DQS#7: JCPU1.AM15 JDIMM1.186 JDIMM2.186
DDR_A_MA0: JCPU1.AD10 JDIMM1.98 JDIMM2.98
DDR_A_MA1: JCPU1.W1 JDIMM1.97 JDIMM2.97
DDR_A_MA2: JCPU1.W2 JDIMM1.96 JDIMM2.96
DDR_A_MA3: JCPU1.W7 JDIMM1.95 JDIMM2.95
DDR_A_MA4: JCPU1.V3 JDIMM1.92 JDIMM2.92
DDR_A_MA5: JCPU1.V2 JDIMM1.91 JDIMM2.91
DDR_A_MA6: JCPU1.W3 JDIMM1.90 JDIMM2.90
DDR_A_MA7: JCPU1.W6 JDIMM1.86 JDIMM2.86
DDR_A_MA8: JCPU1.V1 JDIMM1.89 JDIMM2.89
DDR_A_MA9: JCPU1.W5 JDIMM1.85 JDIMM2.85
DDR_A_MA10: JCPU1.AD8 JDIMM1.107 JDIMM2.107
DDR_A_MA11: JCPU1.V4 JDIMM1.84 JDIMM2.84
DDR_A_MA12: JCPU1.W4 JDIMM1.83 JDIMM2.83
DDR_A_MA13: JCPU1.AF8 JDIMM1.119 JDIMM2.119
DDR_A_MA14: JCPU1.V5 JDIMM1.80 JDIMM2.80
DDR_A_MA15: JCPU1.V7 JDIMM1.78 JDIMM2.78
DDR_A_RAS#: JCPU1.AD9 JDIMM1.110 JDIMM2.110
DDR_A_WE#: JCPU1.AF9 JDIMM1.113 JDIMM2.113
DDR_B_BS0: JCPU1.AA9 JDIMM3.109 JDIMM4.109
DDR_B_BS1: JCPU1.AA7 JDIMM3.108 JDIMM4.108
DDR_B_BS2: JCPU1.R6 JDIMM3.79 JDIMM4.79
DDR_B_CAS#: JCPU1.AA10 JDIMM3.115 JDIMM4.115
DDR_B_D0: JCPU1.C9 JDIMM3.4 JDIMM4.5
DDR_B_D1: JCPU1.A7 JDIMM3.7 JDIMM4.6
DDR_B_D2: JCPU1.D10 JDIMM3.16 JDIMM4.15
DDR_B_D3: JCPU1.C8 JDIMM3.17 JDIMM4.18
DDR_B_D4: JCPU1.A9 JDIMM3.6 JDIMM4.7
DDR_B_D5: JCPU1.A8 JDIMM3.5 JDIMM4.4
DDR_B_D6: JCPU1.D9 JDIMM3.18 JDIMM4.17
DDR_B_D7: JCPU1.D8 JDIMM3.15 JDIMM4.16
DDR_B_D8: JCPU1.G4 JDIMM3.22 JDIMM4.21
DDR_B_D9: JCPU1.F4 JDIMM3.23 JDIMM4.24
DDR_B_D10: JCPU1.F1 JDIMM3.34 JDIMM4.33
DDR_B_D11: JCPU1.G1 JDIMM3.36 JDIMM4.35
DDR_B_D12: JCPU1.G5 JDIMM3.24 JDIMM4.23
DDR_B_D13: JCPU1.F5 JDIMM3.21 JDIMM4.22
DDR_B_D14: JCPU1.F2 JDIMM3.33 JDIMM4.34
DDR_B_D15: JCPU1.G2 JDIMM3.35 JDIMM4.36
DDR_B_D16: JCPU1.J7 JDIMM3.40 JDIMM4.39
DDR_B_D17: JCPU1.J8 JDIMM3.42 JDIMM4.41
DDR_B_D18: JCPU1.K10 JDIMM3.51 JDIMM4.50
DDR_B_D19: JCPU1.K9 JDIMM3.53 JDIMM4.52
DDR_B_D20: JCPU1.J9 JDIMM3.39 JDIMM4.40
DDR_B_D21: JCPU1.J10 JDIMM3.41 JDIMM4.42
DDR_B_D22: JCPU1.K8 JDIMM3.50 JDIMM4.51
DDR_B_D23: JCPU1.K7 JDIMM3.52 JDIMM4.53
DDR_B_D24: JCPU1.M5 JDIMM3.59 JDIMM4.58
DDR_B_D25: JCPU1.N4 JDIMM3.56 JDIMM4.57
DDR_B_D26: JCPU1.N2 JDIMM3.68 JDIMM4.67
DDR_B_D27: JCPU1.N1 JDIMM3.70 JDIMM4.69
DDR_B_D28: JCPU1.M4 JDIMM3.57 JDIMM4.56
DDR_B_D29: JCPU1.N5 JDIMM3.58 JDIMM4.59
DDR_B_D30: JCPU1.M2 JDIMM3.67 JDIMM4.68
DDR_B_D31: JCPU1.M1 JDIMM3.69 JDIMM4.70
DDR_B_D32: JCPU1.AM5 JDIMM3.130 JDIMM4.129
DDR_B_D33: JCPU1.AM6 JDIMM3.132 JDIMM4.131
DDR_B_D34: JCPU1.AR3 JDIMM3.140 JDIMM4.141
DDR_B_D35: JCPU1.AP3 JDIMM3.142 JDIMM4.143
DDR_B_D36: JCPU1.AN3 JDIMM3.129 JDIMM4.130
DDR_B_D37: JCPU1.AN2 JDIMM3.131 JDIMM4.132
DDR_B_D38: JCPU1.AN1 JDIMM3.141 JDIMM4.140
DDR_B_D39: JCPU1.AP2 JDIMM3.143 JDIMM4.142
DDR_B_D40: JCPU1.AP5 JDIMM3.147 JDIMM4.146
DDR_B_D41: JCPU1.AN9 JDIMM3.149 JDIMM4.148
DDR_B_D42: JCPU1.AT5 JDIMM3.158 JDIMM4.157
DDR_B_D43: JCPU1.AT6 JDIMM3.160 JDIMM4.159
DDR_B_D44: JCPU1.AP6 JDIMM3.146 JDIMM4.147
DDR_B_D45: JCPU1.AN8 JDIMM3.148 JDIMM4.149
DDR_B_D46: JCPU1.AR6 JDIMM3.157 JDIMM4.158
DDR_B_D47: JCPU1.AR5 JDIMM3.159 JDIMM4.160
DDR_B_D48: JCPU1.AR9 JDIMM3.164 JDIMM4.163
DDR_B_D49: JCPU1.AJ11 JDIMM3.166 JDIMM4.165
DDR_B_D50: JCPU1.AT8 JDIMM3.175 JDIMM4.174
DDR_B_D51: JCPU1.AT9 JDIMM3.177 JDIMM4.176
DDR_B_D52: JCPU1.AH11 JDIMM3.163 JDIMM4.164
DDR_B_D53: JCPU1.AR8 JDIMM3.165 JDIMM4.166
DDR_B_D54: JCPU1.AJ12 JDIMM3.174 JDIMM4.175
DDR_B_D55: JCPU1.AH12 JDIMM3.176 JDIMM4.177
DDR_B_D56: JCPU1.AT11 JDIMM3.180 JDIMM4.181
DDR_B_D57: JCPU1.AN14 JDIMM3.182 JDIMM4.183
DDR_B_D58: JCPU1.AR14 JDIMM3.192 JDIMM4.191
DDR_B_D59: JCPU1.AT14 JDIMM3.194 JDIMM4.193
DDR_B_D60: JCPU1.AT12 JDIMM3.181 JDIMM4.180
DDR_B_D61: JCPU1.AN15 JDIMM3.183 JDIMM4.182
DDR_B_D62: JCPU1.AR15 JDIMM3.191 JDIMM4.192
DDR_B_D63: JCPU1.AT15 JDIMM3.193 JDIMM4.194
DDR_B_DQS0: JCPU1.C7 JDIMM3.12 JDIMM4.12
DDR_B_DQS1: JCPU1.G3 JDIMM3.29 JDIMM4.29
DDR_B_DQS2: JCPU1.J6 JDIMM3.47 JDIMM4.47
DDR_B_DQS3: JCPU1.M3 JDIMM3.64 JDIMM4.64
DDR_B_DQS4: JCPU1.AN6 JDIMM3.137 JDIMM4.137
DDR_B_DQS5: JCPU1.AP8 JDIMM3.154 JDIMM4.154
DDR_B_DQS6: JCPU1.AK11 JDIMM3.171 JDIMM4.171
DDR_B_DQS7: JCPU1.AP14 JDIMM3.188 JDIMM4.188
DDR_B_DQS#0: JCPU1.D7 JDIMM3.10 JDIMM4.10
DDR_B_DQS#1: JCPU1.F3 JDIMM3.27 JDIMM4.27
DDR_B_DQS#2: JCPU1.K6 JDIMM3.45 JDIMM4.45
DDR_B_DQS#3: JCPU1.N3 JDIMM3.62 JDIMM4.62
DDR_B_DQS#4: JCPU1.AN5 JDIMM3.135 JDIMM4.135
DDR_B_DQS#5: JCPU1.AP9 JDIMM3.152 JDIMM4.152
DDR_B_DQS#6: JCPU1.AK12 JDIMM3.169 JDIMM4.169
DDR_B_DQS#7: JCPU1.AP15 JDIMM3.186 JDIMM4.186
DDR_B_MA0: JCPU1.AA8 JDIMM3.98 JDIMM4.98
DDR_B_MA1: JCPU1.T7 JDIMM3.97 JDIMM4.97
DDR_B_MA2: JCPU1.R7 JDIMM3.96 JDIMM4.96
DDR_B_MA3: JCPU1.T6 JDIMM3.95 JDIMM4.95
DDR_B_MA4: JCPU1.T2 JDIMM3.92 JDIMM4.92
DDR_B_MA5: JCPU1.T4 JDIMM3.91 JDIMM4.91
DDR_B_MA6: JCPU1.T3 JDIMM3.90 JDIMM4.90
DDR_B_MA7: JCPU1.R2 JDIMM3.86 JDIMM4.86
DDR_B_MA8: JCPU1.T5 JDIMM3.89 JDIMM4.89
DDR_B_MA9: JCPU1.R3 JDIMM3.85 JDIMM4.85
DDR_B_MA10: JCPU1.AB7 JDIMM3.107 JDIMM4.107
DDR_B_MA11: JCPU1.R1 JDIMM3.84 JDIMM4.84
DDR_B_MA12: JCPU1.T1 JDIMM3.83 JDIMM4.83
DDR_B_MA13: JCPU1.AB10 JDIMM3.119 JDIMM4.119
DDR_B_MA14: JCPU1.R5 JDIMM3.80 JDIMM4.80
DDR_B_MA15: JCPU1.R4 JDIMM3.78 JDIMM4.78
DDR_B_RAS#: JCPU1.AB8 JDIMM3.110 JDIMM4.110
DDR_B_WE#: JCPU1.AB9 JDIMM3.113 JDIMM4.113
DDR_CKE0_DIMM2: JCPU1.V9 JDIMM2.73
DDR_CKE1_DIMM2: JCPU1.V10 JDIMM2.74
DDR_CKE2_DIMM4: JCPU1.R9 JDIMM4.73
DDR_CKE3_DIMM4: JCPU1.R10 JDIMM4.74
DDR_CKE4_DIMM1: JCPU1.W9 JDIMM1.73
DDR_CKE5_DIMM1: JCPU1.W10 JDIMM1.74
DDR_CKE6_DIMM3: JCPU1.T9 JDIMM3.73
DDR_CKE7_DIMM3: JCPU1.T10 JDIMM3.74
DDR_CS0_DIMM2#: JCPU1.AK3 JDIMM2.114
DDR_CS1_DIMM2#: JCPU1.AL3 JDIMM2.121
DDR_CS2_DIMM4#: JCPU1.AD3 JDIMM4.114
DDR_CS3_DIMM4#: JCPU1.AE3 JDIMM4.121
DDR_CS4_DIMM1#: JCPU1.AG1 JDIMM1.114
DDR_CS5_DIMM1#: JCPU1.AH1 JDIMM1.121
DDR_CS6_DIMM3#: JCPU1.AD6 JDIMM3.114
DDR_CS7_DIMM3#: JCPU1.AE6 JDIMM3.121
DDR_HVREF_RST: CC68.1 QC2.2 QD1.2 QD2.2 RC25.2 RC26.2
DDR_HVREF_RST_GATE: RC26.1 U54.A34
DDR_HVREF_RST_PCH: RC25.1 RH300.1 UH4.A12
DDR_ON: PR210.1 R876.2 U54.B14
DDR_XDP_WAN_SMBCLK: QH5.1 R502.2 R1157.2 RD11.2 RD22.2 RD31.2 RD40.2 RH285.1 U88.4
DDR_XDP_WAN_SMBCLK_R2: JXDP2.53 RH285.2
DDR_XDP_WAN_SMBDAT: QH5.4 R501.2 R1158.2 RD10.2 RD21.2 RD30.2 RD39.2 RH284.1 U88.6
DDR_XDP_WAN_SMBDAT_R2: JXDP2.51 RH284.2
DEVICE_DET#: JODD1.8 R1125.1 U54.A17
DF_TVS: RH358.2 UH4.AY1
DF_TVS_R: RH149.2 RH150.2 RH358.1
DGPU_ALERT#: Q5.1 R788.2 U46.A42
DGPU_HOLD_RST#: R36.2 U16.1 UH4.K1
DGPU_PEX_RST#: JMXM1.184 R38.2 U16.4
DGPU_PWR_EN: JMXM1.44 R1582.2 U8.2 U46.B45
DGPU_PWR_GOOD: JMXM1.42 R8.2 U8.1
DGPU_PWROK: U8.4 U14.1 U25.1 U27.1 U46.A56 UH4.B41
DGPU_SELECT#: U3.1 U11.27 U13.27 U19.39 U46.B14
DGPU_THERMTRIP#: Q4.1 Q115.3 R11.2 R400.2
DH_1.5V: PQ201.4 PU201.17
DIMM1_SA0: JDIMM1.197 RD8.1 RD12.2
DIMM1_SA1: JDIMM1.201 RD9.1 RD13.2
DIMM1_SMBCLK: JDIMM1.202 RD11.1
DIMM1_SMBDAT: JDIMM1.200 RD10.1
DIMM2_SA0: JDIMM2.197 RD17.1 RD19.2
DIMM2_SA1: JDIMM2.201 RD18.1 RD20.2
DIMM2_SMBCLK: JDIMM2.202 RD22.1
DIMM2_SMBDAT: JDIMM2.200 RD21.1
DIMM3_SA0: JDIMM3.197 RD26.1 RD28.2
DIMM3_SA1: JDIMM3.201 RD27.1 RD29.2
DIMM3_SMBCLK: JDIMM3.202 RD31.1
DIMM3_SMBDAT: JDIMM3.200 RD30.1
DIMM4_SA0: JDIMM4.197 RD35.1 RD37.2
DIMM4_SA1: JDIMM4.201 RD36.1 RD38.2
DIMM4_SMBCLK: JDIMM4.202 RD40.1
DIMM4_SMBDAT: JDIMM4.200 RD39.1
DISP_ON: D64.1 D67.1 D69.1 JEDP1.2 JLVDS1.2 R1138.1
DK_AC_OFF: PR1014.1 PU1001.25
DK_AC_OFF_EN: PR1020.1 PU1001.22
DK_CSS_GC: PR910.2 PU1001.11
DK_PWR_BAR: PR1007.2 PU1001.33
DL_1.5V: PC299.1 PQ202.4 PU201.15
DMI_COMP_R: RH111.2 UH4.BG25 UH4.BJ24
DMI_CRX_PTX_N0: JCPU1.B27 UH4.AW24
DMI_CRX_PTX_N1: JCPU1.B25 UH4.AW20
DMI_CRX_PTX_N2: JCPU1.A25 UH4.BB18
DMI_CRX_PTX_N3: JCPU1.B24 UH4.AV18
DMI_CRX_PTX_P0: JCPU1.B28 UH4.AY24
DMI_CRX_PTX_P1: JCPU1.B26 UH4.AY20
DMI_CRX_PTX_P2: JCPU1.A24 UH4.AY18
DMI_CRX_PTX_P3: JCPU1.B23 UH4.AU18
DMI_CTX_PRX_N0: JCPU1.G21 UH4.BC24
DMI_CTX_PRX_N1: JCPU1.E22 UH4.BE20
DMI_CTX_PRX_N2: JCPU1.F21 UH4.BG18
DMI_CTX_PRX_N3: JCPU1.D21 UH4.BG20
DMI_CTX_PRX_P0: JCPU1.G22 UH4.BE24
DMI_CTX_PRX_P1: JCPU1.D22 UH4.BC20
DMI_CTX_PRX_P2: JCPU1.F20 UH4.BJ18
DMI_CTX_PRX_P3: JCPU1.C21 UH4.BJ20
DMIC0: D13.2 JCAM1.13 JIO1.33
DMIC_CLK: D13.3 JCAM1.11 JIO1.31
DOCK_AC_OFF: D34.1 JDOCK1.2 PR1014.2 R770.1
DOCK_AC_OFF_EC: PR1018.1 PR1020.2 U46.A63 U47.2
DOCK_DCIN_IS+: JDOCK1.134 PQ904.6
DOCK_DCIN_IS-: JDOCK1.136 PQ904.4
DOCK_DET#: D32.2 R755.2 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: JIO1.35 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_LOM_TRD0+: JDOCK1.104 U32.22
DOCK_LOM_TRD0-: JDOCK1.106 U32.23
DOCK_LOM_TRD1+: JDOCK1.110 U32.26
DOCK_LOM_TRD1-: JDOCK1.112 U32.27
DOCK_LOM_TRD2+: JDOCK1.122 U32.31
DOCK_LOM_TRD2-: JDOCK1.124 U32.32
DOCK_LOM_TRD3+: JDOCK1.128 U32.35
DOCK_LOM_TRD3-: JDOCK1.130 U32.36
DOCK_MIC_DET: JIO1.37 U46.B8
DOCK_POR_RST#: C736.1 JDOCK1.140 R881.2 U54.B22
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: C733.1 JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R819.2 R825.1 U10.1 U54.A1
DOCK_SMB_ALERT#: JDOCK1.133 PQ1.3 R763.2 U46.A51
DOCK_SMB_CLK: JDOCK1.127 R841.1 U54.B4
DOCK_SMB_DAT: JDOCK1.129 R838.1 U54.A3
DOCKED: Q326.2 U32.13 U46.A38
DOCKED#: Q326.6 R518.2 U9.45
DP_A_MXM_AUX_Q: Q339.3 Q340.2 Q340.5 R2193.2
DP_CFG0: R61.2 R64.2 U9.44
DP_CFG1: R72.2 R73.2 U9.29
DP_MB_P14: JDP1.14 R801.2
DP_MUX_PRIORITY: RH163.2 UH4.H36
DP_RP_CEXT: C87.1 U22.2
DP_RP_CFG0: R76.2 R77.1 U22.5
DP_RP_CFG1: R78.2 R79.1 U22.40
DP_RP_PEQ: R80.2 R81.1 U22.4
DP_RP_REXT: R75.2 U22.7
DPC_CA_DET: C1174.1 JDOCK1.6 Q110.2 R492.2 U20.1 U20.4 U21.2
DPC_CA_DET#: U20.10 U20.13 U21.4
DPC_DOCK_AUX: C387.1 U20.2
DPC_DOCK_AUX#: C388.1 U20.5
DPC_DOCK_LANE_C_N0: C438.1 R2173.2
DPC_DOCK_LANE_C_N1: C440.1 R2175.2
DPC_DOCK_LANE_C_N2: C442.1 R2177.2
DPC_DOCK_LANE_C_N3: C444.1 R2179.2
DPC_DOCK_LANE_C_P0: C431.1 R2172.2
DPC_DOCK_LANE_C_P1: C439.1 R2174.2
DPC_DOCK_LANE_C_P2: C441.1 R2176.2
DPC_DOCK_LANE_C_P3: C443.1 R2178.2
DPC_DOCK_LANE_N0_R: JDOCK1.12 R2173.1
DPC_DOCK_LANE_N1_R: JDOCK1.18 R2175.1
DPC_DOCK_LANE_N2_R: JDOCK1.24 R2177.1
DPC_DOCK_LANE_N3_R: JDOCK1.30 R2179.1
DPC_DOCK_LANE_P0_R: JDOCK1.10 R2172.1
DPC_DOCK_LANE_P1_R: JDOCK1.16 R2174.1
DPC_DOCK_LANE_P2_R: JDOCK1.22 R2176.1
DPC_DOCK_LANE_P3_R: JDOCK1.28 R2178.1
DPC_DOCK_SW_AUX: JDOCK1.34 Q113.1 R1538.2 U20.3 U20.11
DPC_DOCK_SW_AUX#: JDOCK1.36 Q113.4 R1523.2 U20.6 U20.8
DPD_CA_DET: C1332.1 JDOCK1.5 Q336.2 R491.2 U9.42
DPD_DOCK_AUX: JDOCK1.33 Q337.1 R2162.2 U9.55
DPD_DOCK_AUX#: JDOCK1.35 Q337.4 R2163.2 U9.54
DPD_DOCK_AUX_Q: Q335.2 Q335.5 Q336.3 Q337.2 Q337.5 R2153.2
DPD_DOCK_LANE_N0: C367.1 R2165.1
DPD_DOCK_LANE_N0_R: JDOCK1.11 R2165.2
DPD_DOCK_LANE_N1: C369.1 R2167.1
DPD_DOCK_LANE_N1_R: JDOCK1.17 R2167.2
DPD_DOCK_LANE_N2: C425.1 R2169.1
DPD_DOCK_LANE_N2_R: JDOCK1.23 R2169.2
DPD_DOCK_LANE_N3: C427.1 R2171.1
DPD_DOCK_LANE_N3_R: JDOCK1.29 R2171.2
DPD_DOCK_LANE_P0: C366.1 R2164.1
DPD_DOCK_LANE_P0_R: JDOCK1.9 R2164.2
DPD_DOCK_LANE_P1: C368.1 R2166.1
DPD_DOCK_LANE_P1_R: JDOCK1.15 R2166.2
DPD_DOCK_LANE_P2: C424.1 R2168.1
DPD_DOCK_LANE_P2_R: JDOCK1.21 R2168.2
DPD_DOCK_LANE_P3: C426.1 R2170.1
DPD_DOCK_LANE_P3_R: JDOCK1.27 R2170.2
DPD_GPU_HPD: C695.1 JDOCK1.39 R757.1 U9.32
DPD_GPU_LANE_N0: C367.2 U9.39
DPD_GPU_LANE_N1: C369.2 U9.36
DPD_GPU_LANE_N2: C425.2 U9.33
DPD_GPU_LANE_N3: C427.2 U9.30
DPD_GPU_LANE_P0: C366.2 U9.40
DPD_GPU_LANE_P1: C368.2 U9.37
DPD_GPU_LANE_P2: C424.2 U9.34
DPD_GPU_LANE_P3: C426.2 U9.31
DSCHRG_MOSFET_GC: PR1004.2 PU1001.29
DSWODVREN: RH127.1 RH129.2 UH4.A18
DYN_TUR_CURRNT_SET#: PQ909.2 R1178.1 U54.A35
DYN_TURB_GPU_PWR_ALRT#: D19.1 PR30.2 R14.2 U54.A44
DYN_TURB_SYS_PWR_ALRT#: R35.2 U46.A46
EC_32KHZ_ECE5048: R867.1 U46.B35
EDID_SELECT#: U19.1 U46.B61
EDP_COMP: JCPU1.A17 JCPU1.A18 RC1.1
EDP_DET#: JEDP1.1 R779.2 U46.A14 U627.1
EMC4022_GPIO2: R404.1 U18.14
EN_1.5VSP: PC311.1 PR311.2 PR312.1 PR314.2 PU302.5
EN_1.8VSP: PC305.1 PR304.2 PR305.1 PR307.2 PU301.5
EN_+V1.05S_VCCPP: PC507.1 PR504.2 PU501.3
EN_+V1.05SP: PC407.1 PR404.2 PU401.3
EN_DK_PWRBAR: PR1027.1 PR1028.1 PU1001.17
EN_DOCK_PWR_BAR: PR1027.2 U46.B37
EN_I2S_NB_CODEC#: JIO1.29 U46.B36
EN_INVPWR: Q22.2 R882.2 U54.A25
EN_LCDPWR: D6.1 D53.1 JEDP1.24 Q20.2 Q23.2
ENTRIP1: PQ106.6 PR107.1 PU101.1
ENTRIP2: PQ106.3 PR106.2 PU101.6
ENVDD_PCH: D53.2 RH134.2 U46.B38 UH4.M45
ER_EDP#: C255.1 JEDP1.17 Q12.3 Q13.3 R158.2
ERC1: PC1007.1 PU1001.3
ERC2: PC1009.1 PU1001.13
ERC3: PC1008.1 PU1001.12
ESATA_PRX_DTX_N4_C: C673.1 UH4.Y7
ESATA_PRX_DTX_P4_C: C674.1 UH4.Y5
ESATA_PTX_DRX_N4_C: C672.1 UH4.AD3
ESATA_PTX_DRX_P4_C: C671.1 UH4.AD1
ESATA_USB_PWR_EN#: R769.2 U46.B44 U48.4 U48.5
EXPCLK_REQ#: JIO1.54 RH94.1 UH4.L12
FAN1_PWM: JFAN1.2 R407.2 U18.20
FAN1_TACH_FB: JFAN1.4 R408.2 U18.15
FAN2_PWM: D90.1 R213.2 R403.2 U18.13
FAN2_PWM_D: D90.2 JFAN2.2 R213.1 R409.2
FAN2_TACH_FB: JFAN2.4 R405.2 U18.16
FB_3V: PC120.1 PR101.2 PR103.2 PU101.5
FB_5V: PC121.2 PR102.1 PR104.1 PU101.2
FB_+V1.05S_VCCPP: PR508.2 PR511.2 PR512.1 PU501.4
FB_+V1.05SP: PR407.2 PR408.2 PU401.4
FDI_CTX_PRX_N0: JCPU1.A21 UH4.BJ14
FDI_CTX_PRX_N1: JCPU1.H19 UH4.AY14
FDI_CTX_PRX_N2: JCPU1.E19 UH4.BE14
FDI_CTX_PRX_N3: JCPU1.F18 UH4.BH13
FDI_CTX_PRX_N4: JCPU1.B21 UH4.BC12
FDI_CTX_PRX_N5: JCPU1.C20 UH4.BJ12
FDI_CTX_PRX_N6: JCPU1.D18 UH4.BG10
FDI_CTX_PRX_N7: JCPU1.E17 UH4.BG9
FDI_CTX_PRX_P0: JCPU1.A22 UH4.BG14
FDI_CTX_PRX_P1: JCPU1.G19 UH4.BB14
FDI_CTX_PRX_P2: JCPU1.E20 UH4.BF14
FDI_CTX_PRX_P3: JCPU1.G18 UH4.BG13
FDI_CTX_PRX_P4: JCPU1.B20 UH4.BE12
FDI_CTX_PRX_P5: JCPU1.C19 UH4.BG12
FDI_CTX_PRX_P6: JCPU1.D19 UH4.BJ10
FDI_CTX_PRX_P7: JCPU1.F17 UH4.BH9
FDI_FSYNC0: JCPU1.J18 UH4.AV12
FDI_FSYNC1: JCPU1.J17 UH4.BC10
FDI_INT: JCPU1.H20 UH4.AW16
FDI_LSYNC0: JCPU1.J19 UH4.AV14
FDI_LSYNC1: JCPU1.H17 UH4.BB10
FFS_INT2: Q29.2 U88.9 UH4.V13
FFS_INT2_Q: JSATA1.18 JSATA2.18 Q29.3 R506.2
FFS_PCH_INT: RH334.2 UH4.D44
FWP#: R872.2 R879.2 U54.B65
GFX_CLK_REQ#: QH2.1 RH80.1 UH4.M10
GP1_SNUB: PC772.1 PR770.2
GP1_SW: PL705.2 PQ708.5 PQ708.6 PQ708.7 PR770.1 PR771.2 PR772.2
GP2_SNUB: PC765.1 PR765.2
GP2_SW: PL704.2 PQ707.5 PQ707.6 PQ707.7 PR765.1 PR766.1 PR767.1
GPIO_PSID_SELECT: PU1.6 U46.A6
GPU_PWR_LEVEL: R787.2 U17.2 U46.A52
GPU_SMBCLK: Q295.3 R822.1 U54.B49
GPU_SMBCLK_R: JMXM1.70 Q295.4 R1.2 R2182.1
GPU_SMBDAT: Q295.6 R829.1 U54.B48
GPU_SMBDAT_R: JMXM1.68 Q295.1 R2.2 R2183.1
GREEN_CRT: C23.1 L2.1 R54.1 U19.32
GREEN_CRT_L: C12.1 D10.3 JCRT1.2 L2.2
GREEN_DOCK: JDOCK1.59 U19.23
H_CATERR#: JCPU1.AL33 RC15.2
H_CPU_SVIDALRT#: JCPU1.AJ29 RC64.1
H_CPUPWRGD: RC8.1 RC27.1 RC46.1 UH4.AY11
H_CPUPWRGD_R: JCPU1.AP33 RC27.2
H_CPUPWRGD_XDP: JXDP1.10 RC8.2
H_PM_SYNC: JCPU1.AM34 T63.1(TP-1) UH4.AP14
H_PROCHOT#: CC92.1 PC732.1 PR729.1 PR732.2 PR935.2 Q47.1 R1180.2 RC16.2 RC22.1
H_PROCHOT#_R: JCPU1.AL32 RC22.2
H_SNB_IVB#: JCPU1.C26 RH150.1
H_THERMTRIP#: Q28.3 RC14.2 RC24.1
H_THERMTRIP#_R: JCPU1.AN32 RC24.2
HDD1_DET#: JSATA1.12 RH30.1 RH290.2
HDD2_DET#: JSATA2.12 QH1.3
HDD_DET#_R: RH13.1 RH290.1 UH4.V14
HDD_EN_5V: C393.1 Q27.3 Q300.3 R499.2 R1630.1
HDD_FALL_INT: R503.2 RH334.1 U88.11
HDMI_CEC: JHDMI1.13 R1165.1
HDMI_HPD_SINK: R1128.1 R1164.1 U9.17
HDMI_HPD_SINK_R: JHDMI1.19 R1164.2
HDMI_SCL_SINK: JHDMI1.15 R461.2 U9.48
HDMI_SDA_SINK: JHDMI1.16 R460.2 U9.47
HOST_DEB_RX: JDEG2.9 R855.1
HOST_DEB_TX: JDEG2.8 R853.1
HOST_DEBUG_RX: JMINI2.17 R849.2 R855.2 U54.B46
HOST_DEBUG_TX: C595.1 JMINI2.16 R848.2 R853.2 U54.B44
HSYNC: RH123.2 UH4.M47
HSYNC_BUF: R43.1 U19.37
HSYNC_DOCK: JDOCK1.65 U19.28
HSYNC_L: C19.1 JCRT1.13 L4.2 R52.2
HW_GPS_DISABLE2#: JMINI1.51 R798.2 U46.B34
ICOUT: PC908.1 PR918.2 PU901.26
IMVP_PWRGD: PR707.2 PR734.2 PR736.2 U46.A62
IMVP_VR_ON: PR730.1 R771.2
INIT3_3V#: T106.1(TP-1) UH4.T14
INTRUDER#: RH11.2 UH4.K22
IRQ_SERIRQ: RH28.1 U37.27 U39.27 U46.B21 U54.A28 UH4.V5
ISEN1: PC742.1 PR719.1 PR742.1 PR758.1 PU702.13
ISEN1G: PC719.1 PR769.2 PR771.1 PU702.2
ISEN2: PC739.1 PR723.1 PR740.2 PR741.1 PR759.1 PU702.12
ISEN2G: PC720.1 PR720.2 PR766.2 PR774.1 PU702.3
ISEN3: PC733.1 PC738.1 PR716.1 PR747.1 PR762.1 PU702.11
JETWAY_14M: RH315.2 UH4.K49
JETWAY_CLK14M: RE6.1 RH315.1 U37.13 U39.13
JTAG_CLK: JDEG2.4 R860.2 U54.B56
JTAG_RST#: C735.1 JTAG1.1 R824.2 R836.1 U54.B57
JTAG_TDI: JDEG2.2 R858.2 U54.A51
JTAG_TDO: JDEG2.5 R861.2 U54.B55
JTAG_TMS: JDEG2.3 R859.2 U54.A53
KB_DET#: JKB1.19 JKB1.20 RH170.1 UH4.D6
LAN_ACTLED_YEL#: R1171.1 U32.17
LAN_DISABLE#_R: R549.2 R555.2 R557.1 U31.3 U46.B47
LAN_SMBCLK: R551.1 RH305.1 UH4.C8
LAN_SMBCLK_R: R551.2 U31.28
LAN_SMBDATA: R552.1 RH306.1 UH4.G12
LAN_SMBDATA_R: R552.2 U31.31
LAN_TEST_EN: R561.1 U31.30
LAN_TX0+: L30.1 U31.13
LAN_TX0+R: L30.2 U32.12
LAN_TX0-: L31.1 U31.14
LAN_TX0-R: L31.2 U32.11
LAN_TX1+: L33.1 U31.17
LAN_TX1+R: L33.2 U32.10
LAN_TX1-: L32.1 U31.18
LAN_TX1-R: L32.2 U32.9
LAN_TX2+: L34.1 U31.20
LAN_TX2+R: L34.2 U32.7
LAN_TX2-: L35.1 U31.21
LAN_TX2-R: L35.2 U32.6
LAN_TX3+: L36.1 U31.23
LAN_TX3+R: L36.2 U32.3
LAN_TX3-: L37.1 U31.24
LAN_TX3-R: L37.2 U32.2
LANCLK_REQ#: R1187.1 UH4.M1
LANCLK_REQ#_R: R547.2 R1187.2 U31.48
LAT_ON_SW#: R870.2 U54.B63
LCD_A0+_PCH: U11.16 UH4.AN47
LCD_A0-_PCH: U11.15 UH4.AN48
LCD_A1+_PCH: U11.20 UH4.AM49
LCD_A1-_PCH: U11.19 UH4.AM47
LCD_A2+_PCH: U11.24 UH4.AK49
LCD_A2-_PCH: U11.23 UH4.AK47
LCD_ACLK+_PCH: U11.29 UH4.AK40
LCD_ACLK-_PCH: U11.28 UH4.AK39
LCD_B0+_PCH: U13.16 UH4.AH43
LCD_B0-_PCH: U13.15 UH4.AH45
LCD_B1+_PCH: U13.20 UH4.AH49
LCD_B1-_PCH: U13.19 UH4.AH47
LCD_B2+_PCH: U13.24 UH4.AF47
LCD_B2-_PCH: U13.23 UH4.AF49
LCD_BCLK+_PCH: U13.29 UH4.AF39
LCD_BCLK-_PCH: U13.28 UH4.AF40
LCD_CBL_DET#: JLVDS1.1 RH330.2 UH4.G42
LCD_SMBCLK: JEDP1.20 R418.1 U54.B5
LCD_SMBDAT: JEDP1.21 R420.1 U54.A4
LCD_TST: JEDP1.12 JLVDS1.12 R767.2 U46.A36
LCD_VCC_TEST_EN: D6.2 U46.A40
LDDC_CLK_PCH: R1124.2 U11.6 UH4.T40
LDDC_CLK_SW: C1188.1 JLVDS1.18 R159.2 U11.4
LDDC_DATA_PCH: R1123.2 U11.14 UH4.K47
LDDC_DATA_SW: JLVDS1.19 R160.2 U11.12
LDO_SET: R392.1 U18.33
LED_10_GRN#: R1170.1 U32.41
LED_100_ORG#: R1167.1 U32.18
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LED_WLAN_WWAN_DIAG_OUT#: D63.1 U46.B12
LED_WWAN_OUT#: JMINI1.42 Q77.3 R719.1
LG_3V: PC199.1 PQ103.4 PU101.12
LG_5V: PC198.1 PQ104.4 PU101.19
LG_+V1.05S_VCCPP: PC599.1 PQ502.4 PU501.6
LG_+V1.05SP: PC499.1 PQ402.4 PU401.6
LGATE1: PC795.2 PC796.2 PQ705.4 PQ706.4 PU702.23
LGATE1G: PC798.2 PQ708.4 PU702.34
LGATE2: PC793.2 PC794.2 PQ703.4 PQ704.4 PU702.27
LGATE2G: PC797.2 PQ707.4 PU703.5
LGATE3: PC791.2 PC792.2 PQ701.4 PQ702.4 PU701.5
LID_CL#: JIO1.71 R807.1 U58.2
LID_CL_SIO#: C716.1 C750.2 R805.2 R807.2 U46.B54
LOM_ACTLED_YEL#: U31.26 U32.15
LOM_SPD10LED_GRN#: U15.2 U31.25 U32.42
LOM_SPD100LED_ORG#: U15.1 U31.27 U32.16
LPC_LAD0: JMINI3.16 U37.26 U39.26 U46.A27 U54.A30 UH4.C38
LPC_LAD1: JMINI3.14 U37.23 U39.23 U46.A26 U54.B32 UH4.A38
LPC_LAD2: JMINI3.12 U37.20 U39.20 U46.B26 U54.A31 UH4.B37
LPC_LAD3: JMINI3.10 U37.17 U39.17 U46.B25 U54.B33 UH4.C37
LPC_LDRQ1#: U46.A22 UH4.K36
LPC_LDRQ#_MEC: R823.2 U54.B29
LPC_LFRAME#: JMINI3.8 U37.22 U39.22 U46.A21 U54.B31 UH4.D36
LVD_IBG: RH344.2 UH4.AF37
LX_3V: PC100.1 PL103.2 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR110.1 PU101.11
LX_5V: PC110.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ104.5 PR111.1 PU101.20
M_CLK_DDR0: JCPU1.AB6 JDIMM2.101
M_CLK_DDR1: JCPU1.AA5 JDIMM2.102
M_CLK_DDR2: JCPU1.AE2 JDIMM4.101
M_CLK_DDR3: JCPU1.AE1 JDIMM4.102
M_CLK_DDR4: JCPU1.AB4 JDIMM1.101
M_CLK_DDR5: JCPU1.AB3 JDIMM1.102
M_CLK_DDR6: JCPU1.AB2 JDIMM3.101
M_CLK_DDR7: JCPU1.AA1 JDIMM3.102
M_CLK_DDR#0: JCPU1.AA6 JDIMM2.103
M_CLK_DDR#1: JCPU1.AB5 JDIMM2.104
M_CLK_DDR#2: JCPU1.AD2 JDIMM4.103
M_CLK_DDR#3: JCPU1.AD1 JDIMM4.104
M_CLK_DDR#4: JCPU1.AA4 JDIMM1.103
M_CLK_DDR#5: JCPU1.AA3 JDIMM1.104
M_CLK_DDR#6: JCPU1.AA2 JDIMM3.103
M_CLK_DDR#7: JCPU1.AB1 JDIMM3.104
M_ID2#: C15.1 JCRT1.4
M_ODT0: JCPU1.AH3 JDIMM2.116
M_ODT1: JCPU1.AG3 JDIMM2.120
M_ODT2: JCPU1.AE4 JDIMM4.116
M_ODT3: JCPU1.AD4 JDIMM4.120
M_ODT4: JCPU1.AG2 JDIMM1.116
M_ODT5: JCPU1.AH2 JDIMM1.120
M_ODT6: JCPU1.AD5 JDIMM3.116
M_ODT7: JCPU1.AE5 JDIMM3.120
MASK_BASE_LEDS#: JIO1.106 Q74.2 Q78.2 Q84.2 Q318.2 U58.4
MASK_SATA_LED#: Q74.5 Q78.5 U46.B9
MAX8731_IINP: PC922.1 PR925.1 PR939.1 PU901.8 R388.2
MAX8731_REF: PC924.1 PR912.1 PR924.1 PR933.1 PR934.1 PU901.3
MAX8731A_LDO: PC911.1 PD903.2 PR911.1 PR918.1 PU901.21
MB_DP_CA_DET: C1341.1 JDP1.13 Q339.2 R62.2 U22.10
MB_DP_HPD: JDP1.18 U22.11
MB_DP_RP_AUX: JDP1.15 R59.2 U22.28
MB_DP_RP_AUX#: JDP1.17 R56.2 U22.27
MB_DP_RP_C_N0: C304.2 U22.22
MB_DP_RP_C_N1: C308.2 U22.19
MB_DP_RP_C_N2: C309.2 U22.16
MB_DP_RP_C_N3: C302.2 U22.13
MB_DP_RP_C_P0: C307.2 U22.23
MB_DP_RP_C_P1: C295.2 U22.20
MB_DP_RP_C_P2: C306.2 U22.17
MB_DP_RP_C_P3: C303.2 U22.14
MB_DP_RP_N0: C304.1 JDP1.3
MB_DP_RP_N1: C308.1 JDP1.6
MB_DP_RP_N2: C309.1 JDP1.9
MB_DP_RP_N3: C302.1 JDP1.12
MB_DP_RP_P0: C307.1 JDP1.1
MB_DP_RP_P1: C295.1 JDP1.4
MB_DP_RP_P2: C306.1 JDP1.7
MB_DP_RP_P3: C303.1 JDP1.10
MB_DP_RST#: C88.1 R415.2 U22.35
MCARD_MISC_PWREN: Q312.2 R733.1 U46.B53
MCARD_MISC_PWREN#: Q312.5 Q312.6 R735.2
MCARD_PCIE_SATA: Q322.5 Q322.6 R740.2
MCARD_PCIE_SATA#: JMINI4.51 Q322.2 R457.2 U46.B3
MCARD_WWAN_PWREN: Q311.2 R727.1 U46.B42
MCARD_WWAN_PWREN#: Q73.2 Q311.5 Q311.6 R721.2
ME_FWP: R793.1 RH50.1 U46.A8
ME_RESET#: RH138.2 RH141.1 UC3.2
ME_SUS_PWR_ACK: RH121.1 RH144.2 U54.A8
ME_SUS_PWR_ACK_R: RH121.2 RH323.1 UH4.K16
MEC_XTAL1: C741.1 U54.A61 Y6.1
MEC_XTAL2: R1068.2 U54.A62
MEC_XTAL2_R: C743.2 R1068.1 Y6.2
MEM_SMBCLK: QH5.6 RH302.1 UH4.H14
MEM_SMBDATA: QH5.3 RH303.1 UH4.C9
MINI1CLK_REQ#: JMINI1.7 RH81.1 UH4.J2
MINI2CLK_REQ#: JMINI2.7 RH97.1 UH4.L14
MINI3CLK_REQ#: JMINI3.7 RH152.1 UH4.A8
MOD_EN: C416.1 Q30.3 Q301.3 R515.2 R1627.1
MODC_EN: Q301.2 R514.1 U46.B7
MODC_EN#: Q301.5 Q301.6 R516.2
MODE: R58.2 R63.2 U9.53
MSCLK: JDEG2.6 JMINI2.19 R847.2 U54.B43
MSDATA: JDEG2.7 JMINI2.14 R706.2 R850.2 R869.2 U54.A40
MXM_ALERT#: JMXM1.58 Q5.3 R4.2
MXM_BIA_PWM: JMXM1.63 U3.2
MXM_CLK_REQ#: JMXM1.182 R7.2
MXM_CRT_BLU: JMXM1.200 U19.9
MXM_CRT_DDC_CLK: JMXM1.188 R5.2 U19.5
MXM_CRT_DDC_DAT: JMXM1.186 R3.2 U19.6
MXM_CRT_GRN: JMXM1.198 U19.8
MXM_CRT_HSYNC: JMXM1.192 U19.3
MXM_CRT_RED: JMXM1.196 U19.7
MXM_CRT_VSYNC: JMXM1.190 U19.4
MXM_CURI2C_CLK: R2182.2 U60.5
MXM_CURI2C_DATA: R2183.2 U60.6
MXM_DP_HDMI_HPD: D7.1 D8.1 D18.1 R17.2 U46.B4
MXM_DPB_AUX: C387.2 JMXM1.300 U20.12
MXM_DPB_AUX#: C388.2 JMXM1.298 U20.9
MXM_DPB_HPD: C696.1 D18.2 JDOCK1.40 R2160.1 U14.2
MXM_DPB_HPD_GATE: JMXM1.302 R758.1 U14.4
MXM_DPB_N0: C438.2 JMXM1.274
MXM_DPB_N1: C440.2 JMXM1.280
MXM_DPB_N2: C442.2 JMXM1.286
MXM_DPB_N3: C444.2 JMXM1.292
MXM_DPB_P0: C431.2 JMXM1.276
MXM_DPB_P1: C439.2 JMXM1.282
MXM_DPB_P2: C441.2 JMXM1.288
MXM_DPB_P3: C443.2 JMXM1.294
MXM_DPC_AUX: C389.2 JMXM1.255 Q335.1 R2156.2 U9.50
MXM_DPC_AUX#: C390.2 JMXM1.253 Q335.4 R2155.2 U9.49
MXM_DPC_AUX#_C: C390.1 U9.51
MXM_DPC_AUX_C: C389.1 U9.52
MXM_DPC_HPD: D7.2 U9.5 U25.2
MXM_DPC_HPD_GATE: JMXM1.262 R519.2 U25.4
MXM_DPC_N0: C247.2 JMXM1.229
MXM_DPC_N0_C: C247.1 U9.4
MXM_DPC_N1: C252.2 JMXM1.235
MXM_DPC_N1_C: C252.1 U9.7
MXM_DPC_N2: C254.2 JMXM1.241
MXM_DPC_N2_C: C254.1 U9.10
MXM_DPC_N3: C246.2 JMXM1.247
MXM_DPC_N3_C: C246.1 U9.13
MXM_DPC_P0: C253.2 JMXM1.231
MXM_DPC_P0_C: C253.1 U9.3
MXM_DPC_P1: C242.2 JMXM1.237
MXM_DPC_P1_C: C242.1 U9.6
MXM_DPC_P2: C251.2 JMXM1.243
MXM_DPC_P2_C: C251.1 U9.9
MXM_DPC_P3: C245.2 JMXM1.249
MXM_DPC_P3_C: C245.1 U9.12
MXM_EDP_AUX+: C371.1 JMXM1.260
MXM_EDP_AUX+_C: C371.2 JEDP1.38 R336.2
MXM_EDP_AUX-: C373.1 JMXM1.258
MXM_EDP_AUX-_C: C373.2 JEDP1.39 R339.2
MXM_EDP_HPD: JEDP1.22 JMXM1.264 R222.2
MXM_EDP_TX0+: C379.1 JMXM1.236
MXM_EDP_TX0+_C: C379.2 JEDP1.35
MXM_EDP_TX0-: C380.1 JMXM1.234
MXM_EDP_TX0-_C: C380.2 JEDP1.36
MXM_EDP_TX1+: C377.1 JMXM1.242
MXM_EDP_TX1+_C: C377.2 JEDP1.32
MXM_EDP_TX1-: C378.1 JMXM1.240
MXM_EDP_TX1-_C: C378.2 JEDP1.33
MXM_EDP_TX2+: C375.1 JMXM1.248
MXM_EDP_TX2+_C: C375.2 JEDP1.29
MXM_EDP_TX2-: C376.1 JMXM1.246
MXM_EDP_TX2-_C: C376.2 JEDP1.30
MXM_EDP_TX3+: C372.1 JMXM1.254
MXM_EDP_TX3+_C: C372.2 JEDP1.26
MXM_EDP_TX3-: C374.1 JMXM1.252
MXM_EDP_TX3-_C: C374.2 JEDP1.27
MXM_ENVDD: D6.3 JMXM1.59
MXM_LVDS_A0+: JMXM1.230 U11.18
MXM_LVDS_A0-: JMXM1.228 U11.17
MXM_LVDS_A1+: JMXM1.224 U11.22
MXM_LVDS_A1-: JMXM1.222 U11.21
MXM_LVDS_A2+: JMXM1.218 U11.26
MXM_LVDS_A2-: JMXM1.216 U11.25
MXM_LVDS_ACLK+: JMXM1.206 U11.31
MXM_LVDS_ACLK-: JMXM1.204 U11.30
MXM_LVDS_B0+: JMXM1.225 U13.18
MXM_LVDS_B0-: JMXM1.223 U13.17
MXM_LVDS_B1+: JMXM1.219 U13.22
MXM_LVDS_B1-: JMXM1.217 U13.21
MXM_LVDS_B2+: JMXM1.213 U13.26
MXM_LVDS_B2-: JMXM1.211 U13.25
MXM_LVDS_BCLK+: JMXM1.201 U13.31
MXM_LVDS_BCLK-: JMXM1.199 U13.30
MXM_LVDS_DDC_CLK: JMXM1.71 R1122.2 U11.5
MXM_LVDS_DDC_DAT: JMXM1.69 R1121.2 U11.13
MXM_MB_DP_AUX: C397.1 JMXM1.309 Q340.1 U22.33
MXM_MB_DP_AUX#: C398.1 JMXM1.307 Q340.4 U22.34
MXM_MB_DP_AUX#_C: C398.2 U22.29
MXM_MB_DP_AUX_C: C397.2 U22.30
MXM_MB_DP_HPD: D8.2 U22.9 U27.2
MXM_MB_DP_HPD_GATE: JMXM1.304 R60.1 U27.4
MXM_MB_DP_N0: C284.1 JMXM1.283
MXM_MB_DP_N0_C: C284.2 U22.39
MXM_MB_DP_N1: C283.1 JMXM1.289
MXM_MB_DP_N1_C: C283.2 U22.42
MXM_MB_DP_N2: C286.1 JMXM1.295
MXM_MB_DP_N2_C: C286.2 U22.45
MXM_MB_DP_N3: C282.1 JMXM1.301
MXM_MB_DP_N3_C: C282.2 U22.48
MXM_MB_DP_P0: C285.1 JMXM1.285
MXM_MB_DP_P0_C: C285.2 U22.38
MXM_MB_DP_P1: C280.1 JMXM1.291
MXM_MB_DP_P1_C: C280.2 U22.41
MXM_MB_DP_P2: C281.1 JMXM1.297
MXM_MB_DP_P2_C: C281.2 U22.44
MXM_MB_DP_P3: C279.1 JMXM1.303
MXM_MB_DP_P3_C: C279.2 U22.47
MXM_OVERT#: JMXM1.56 Q4.3 R10.2
MXM_PANEL_BKEN: D64.2 JMXM1.61
MXM_PIN80: Q85.3 R1161.1 R1976.1
MXM_PIN80_R: JMINI1.37 Q85.1 R1161.2
MXM_PRESENTL#: JMXM1.310 RH178.1 UH4.E38
MXM_PRESENTR#: JMXM1.38 RH179.1 UH4.C41
MXM_PWR_LEVEL: D19.2 JMXM1.54 R37.2 U17.4
MXM_RSVD1: JMXM1.268 R6.2
MXM_RSVD2: JMXM1.270 R9.2
NB_LAN_TX0+: R575.1 T156.24
NB_LAN_TX0+_R: JLOM1.1 R575.2
NB_LAN_TX0-: R576.1 T156.23
NB_LAN_TX0-_R: JLOM1.2 R576.2
NB_LAN_TX1+: R577.1 T156.20
NB_LAN_TX1+_R: JLOM1.3 R577.2
NB_LAN_TX1-: R578.1 T156.19
NB_LAN_TX1-_R: JLOM1.6 R578.2
NB_LAN_TX2+: JLOM1.4 T156.18
NB_LAN_TX2-: JLOM1.5 T156.17
NB_LAN_TX3+: JLOM1.7 T156.14
NB_LAN_TX3-: JLOM1.8 T156.13
NB_PSID: PJPDC1.2 PL3.2
NB_PSID_TS5A63157: PD7.1 PR8.1 PR9.2 PU1.3
NC_1: T108.1(TP-1) UH4.P37
NC_P: C554.1 U37.14 U39.14
NTC: PH703.1 PR735.1 PU702.10
NTCG: PH702.1 PR717.1 PU702.4
NUM_LED: JIO1.90 R942.2
NUM_LED#: Q80.2 U46.A2
NVRAM_PWR_EN: Q313.2 R739.1 U46.B32
NVRAM_PWR_EN#: Q313.5 Q313.6 R738.2
NVRCLK_REQ#: JMINI4.7 RH106.1 UH4.K12
P1_SNUB: PC757.1 PR756.2
P1_SW: PL703.2 PQ705.5 PQ705.6 PQ705.7 PQ706.5 PQ706.6 PQ706.7 PR756.1 PR758.2 PR761.2
P2_SNUB: PC737.1 PR739.2
P2_SW: PL702.2 PQ703.5 PQ703.6 PQ703.7 PQ704.5 PQ704.6 PQ704.7 PR739.1 PR741.2 PR746.2
P3_SNUB: PC721.1 PR721.2
P3_SW: PL701.2 PQ701.5 PQ701.6 PQ701.7 PQ702.5 PQ702.6 PQ702.7 PR716.2 PR721.1 PR724.2
P33ALW: PR1025.1 PU1001.18
P33ALW2: PR1022.2 PU1001.9
P50ALW: PR1012.1 PU1001.27
PANEL_BKEN_EC: D69.2 U46.A35
PANEL_BKEN_PCH: D67.2 UH4.J47
PBAT_PRES#: PD5.1 PR2.2 PR4.2 U46.B40
PBAT_SMBCLK: PR3.2 R820.2 U54.A56
PBAT_SMBDAT: PR5.2 R818.2 U54.B59
PBATT+: PL2.2 PL6.2 PQ1002.1 PQ1002.2 PQ1002.3 PQ1003.1 PQ1003.2 PQ1003.3 PR1008.2
PBATT+_C: PBATT1.1 PBATT1.2 PC3.1 PC4.1 PL2.1 PL6.1
PBATT_IN_SS: PD1002.2 PD1002.3 PQ1003.5 PQ1004.5 PR1003.1 PR1005.1
PCH_ALW_ON: PR23.1 Q305.2 R880.2 U54.A23
PCH_AZ_BITCLK: RH25.2 UH4.N34
PCH_AZ_CODEC_BITCLK: CH101.1 JIO1.3 RH25.1
PCH_AZ_CODEC_RST#: JIO1.15 RH41.1
PCH_AZ_CODEC_SDIN0: JIO1.7 UH4.E34
PCH_AZ_CODEC_SDOUT: JIO1.9 RH29.1
PCH_AZ_CODEC_SYNC: JIO1.13 RH27.1
PCH_AZ_RST#: RH41.2 UH4.K34
PCH_AZ_SDOUT: RH29.2 RH50.2 RH287.2 UH4.A36
PCH_AZ_SYNC: QH7.1 RH66.2 RH282.1 UH4.L34
PCH_AZ_SYNC_Q: QH7.3 RH27.2 RH31.2
PCH_BATLOW#: RH139.2 UH4.E10
PCH_CL_CLK1: JMINI2.45 UH4.M7
PCH_CL_DATA1: JMINI2.47 UH4.T11
PCH_CL_RST1#: R709.1 UH4.P10
PCH_CRT_BLU: RH131.2 U19.19 UH4.N48
PCH_CRT_DDC_CLK: RH317.2 U19.15 UH4.T39
PCH_CRT_DDC_DAT: RH316.1 U19.16 UH4.M40
PCH_CRT_GRN: RH132.2 U19.18 UH4.P49
PCH_CRT_HSYNC: RH123.1 U19.13
PCH_CRT_RED: RH133.2 U19.17 UH4.T49
PCH_CRT_VSYNC: RH124.1 U19.14
PCH_DPWROK: R802.1 RH113.1 UH4.E22
PCH_GPIO3: RH332.2 UH4.G40
PCH_GPIO15: RH19.1 RH354.2 UH4.G2
PCH_GPIO16: RH17.1 RH272.2 RH274.1 UH4.U2
PCH_GPIO17: RH269.2 RH273.1 UH4.D40
PCH_GPIO22: RH181.1 UH4.T5
PCH_GPIO24: T107.1(TP-1) UH4.E8
PCH_GPIO27: RH175.1 UH4.E16
PCH_GPIO33: RH355.1 UH4.C36
PCH_GPIO35: RH12.1 RH275.2 UH4.K4
PCH_GPIO36: RH20.1 RH171.1 RH174.1 UH4.V8
PCH_GPIO37: RH34.1 RH172.1 RH173.1 UH4.M5
PCH_GPIO52: RH340.2 UH4.C44
PCH_GPIO54: RH328.2 UH4.E40
PCH_GPIO71: T109.1(TP-1) UH4.A40
PCH_GPIO74: RH301.1 UH4.C13
PCH_INTVRMEN: RH38.2 RH39.1 UH4.C17
PCH_JTAG_TCK: JXDP2.57 RH59.1 UH4.J3
PCH_JTAG_TDI: JXDP2.56 RH45.1 RH49.1 UH4.K5
PCH_JTAG_TDO: JXDP2.52 RH43.1 RH47.1 UH4.H1
PCH_JTAG_TMS: JXDP2.58 RH44.1 RH48.1 UH4.H7
PCH_PCIE_WAKE#: RH142.2 U54.A18 UH4.B9
PCH_PLTRST#: QH1.2 RH335.2 RH336.2 RH337.2 RH338.2 RH343.2 UC2.2 UH3.1 UH3.2 UH4.C6
PCH_PLTRST#_BUF: RC49.2 RC51.1 UC2.4
PCH_PLTRST#_EC: JIO1.38 JMINI3.17 R703.1 R704.2 R713.2 R730.2 U37.16 U39.16 U46.B22 U54.B30 UH3.4
PCH_PLTRST#_R: JCPU1.AR33 RC51.2
PCH_PWRBTN#_XDP: JXDP2.41 RH21.2
PCH_PWRGD#: Q52.1 R391.1 R893.2
PCH_PWROK: RH117.2 UH4.L22
PCH_RI#: RH140.2 UH4.A10
PCH_RSMRST#: R892.2 R1623.1 U7.1 U54.B47
PCH_RSMRST#_Q: R1623.2 R1633.2 RH24.1 RH120.1
PCH_RSMRST#_R: RH113.2 RH120.2 UH4.C21
PCH_RTCRST#: CH4.2 CMOS1.2 RH22.2 UH4.D20
PCH_RTCX1: CH2.1 RH15.1 UH4.A20 YH1.1
PCH_RTCX2: RH15.2 RH286.2 UH4.C20
PCH_RTCX2_R: CH3.1 RH286.1 YH1.2
PCH_SMB_ALERT#: RH304.1 UH4.E12
PCH_SPI_CLK: JSPI1.8 RH348.2 UH4.T3
PCH_SPI_CS0#: JSPI1.10 RH349.2 UH4.Y14
PCH_SPI_CS1#: JSPI1.2 RH345.2 UH4.T1
PCH_SPI_DIN: JSPI1.6 RH347.2 UH4.U3
PCH_SPI_DO: JSPI1.4 RH346.2 UH4.V4
PCH_THRMTRIP#_R: CH97.1 RH262.2 UH4.AY10
PCI_5048: RH160.1 UH4.H49
PCI_DOCK: RH103.1 UH4.J48
PCI_GNT3#: RH333.1 UH4.F46
PCI_LOOPBACKOUT: RH105.1 UH4.H40
PCI_MEC: RH102.1 UH4.H43
PCI_PIRQA#: RH324.2 UH4.K40
PCI_PIRQB#: RH325.2 UH4.K38
PCI_PIRQC#: RH326.2 UH4.H38
PCI_PIRQD#: RH329.2 UH4.G38
PCI_REQ1#: RH327.2 UH4.C46
PCI_TPM_TCM: RH311.2 UH4.K43
PCIE_CARD: RH86.1 UH4.AA47
PCIE_CARD#: RH85.1 UH4.AA48
PCIE_EXP: RH93.1 UH4.Y45
PCIE_EXP#: RH92.1 UH4.Y43
PCIE_LAN: RH83.1 UH4.AB47
PCIE_LAN#: RH82.1 UH4.AB49
PCIE_MINI1: RH308.1 UH4.Y39
PCIE_MINI1#: RH307.1 UH4.Y40
PCIE_MINI2: RH96.1 UH4.V46
PCIE_MINI2#: RH95.1 UH4.V45
PCIE_MINI3: RH90.1 UH4.Y36
PCIE_MINI3#: RH88.1 UH4.Y37
PCIE_NVR: RH312.1 UH4.V37
PCIE_NVR#: RH310.1 UH4.V38
PCIE_PRX_EXPTX_N3: JIO1.64 UH4.BG36
PCIE_PRX_EXPTX_P3: JIO1.66 UH4.BJ36
PCIE_PRX_GLANTX_N7: C459.2 UH4.BG40
PCIE_PRX_GLANTX_N7_C: C459.1 U31.39
PCIE_PRX_GLANTX_P7: C458.2 UH4.BJ40
PCIE_PRX_GLANTX_P7_C: C458.1 U31.38
PCIE_PRX_MMITX_N8: JIO1.16 UH4.BE38
PCIE_PRX_MMITX_P8: JIO1.14 UH4.BC38
PCIE_PRX_NVRTX_N6: U12.18 UH4.BJ38
PCIE_PRX_NVRTX_P6: U12.17 UH4.BG38
PCIE_PRX_WANTX_N1: JMINI1.23 UH4.BG34
PCIE_PRX_WANTX_P1: JMINI1.25 UH4.BJ34
PCIE_PRX_WLANTX_N2: JMINI2.23 UH4.BE34
PCIE_PRX_WLANTX_P2: JMINI2.25 UH4.BF34
PCIE_PRX_WPANTX_N5: JMINI3.23 UH4.BG37
PCIE_PRX_WPANTX_P5: JMINI3.25 UH4.BH37
PCIE_PTX_EXPRX_N3: JIO1.70 UH4.AV34
PCIE_PTX_EXPRX_P3: JIO1.72 UH4.AU34
PCIE_PTX_GLANRX_N7: C461.1 UH4.AY40
PCIE_PTX_GLANRX_N7_C: C461.2 U31.42
PCIE_PTX_GLANRX_P7: C460.1 UH4.BB40
PCIE_PTX_GLANRX_P7_C: C460.2 U31.41
PCIE_PTX_MMIRX_N8: JIO1.22 UH4.AW38
PCIE_PTX_MMIRX_P8: JIO1.20 UH4.AY38
PCIE_PTX_NVRRX_N6: C640.2 UH4.AU36
PCIE_PTX_NVRRX_N6_C: C640.1 U12.16
PCIE_PTX_NVRRX_P6: C641.2 UH4.AV36
PCIE_PTX_NVRRX_P6_C: C641.1 U12.15
PCIE_PTX_WANRX_N1: C597.1 UH4.AV32
PCIE_PTX_WANRX_N1_C: C597.2 JMINI1.31
PCIE_PTX_WANRX_P1: C599.1 UH4.AU32
PCIE_PTX_WANRX_P1_C: C599.2 JMINI1.33
PCIE_PTX_WLANRX_N2: C596.1 UH4.BB32
PCIE_PTX_WLANRX_N2_C: C596.2 JMINI2.31
PCIE_PTX_WLANRX_P2: C598.1 UH4.AY32
PCIE_PTX_WLANRX_P2_C: C598.2 JMINI2.33
PCIE_PTX_WPANRX_N5: C636.1 UH4.AY36
PCIE_PTX_WPANRX_N5_C: C636.2 JMINI3.31
PCIE_PTX_WPANRX_P5: C626.1 UH4.BB36
PCIE_PTX_WPANRX_P5_C: C626.2 JMINI3.33
PCIE_SATA#: Q322.3 R785.2 U12.3
PCIE_SATA_PRX_NVRTX_N6: JMINI4.23 U12.4
PCIE_SATA_PRX_NVRTX_P6: JMINI4.25 U12.5
PCIE_SATA_PTX_NVRRX_N6: JMINI4.31 U12.6
PCIE_SATA_PTX_NVRRX_P6: JMINI4.33 U12.7
PCIE_WAKE#: JIO1.52 JMINI1.1 JMINI2.1 JMINI3.1 R759.2 R1972.2 U54.B19
PCIECLKRQ6#: RH101.2 UH4.T13
PCLK_80H: JMINI3.19 RH314.1
PECI_EC: JCPU1.AN33 R863.2
PECI_EC_R: R863.1 U54.A48
PEG_B_CLKRQ#: RH98.2 UH4.E6
PEG_COMP: JCPU1.H22 JCPU1.J21 JCPU1.J22 RC2.2
PEG_CRX_GTX_C_N0: CC1.1 JMXM1.177
PEG_CRX_GTX_C_N1: CC2.1 JMXM1.171
PEG_CRX_GTX_C_N2: CC3.1 JMXM1.165
PEG_CRX_GTX_C_N3: CC4.1 JMXM1.157
PEG_CRX_GTX_C_N4: CC5.1 JMXM1.151
PEG_CRX_GTX_C_N5: CC6.1 JMXM1.145
PEG_CRX_GTX_C_N6: CC7.1 JMXM1.139
PEG_CRX_GTX_C_N7: CC8.1 JMXM1.133
PEG_CRX_GTX_C_N8: CC9.1 JMXM1.127
PEG_CRX_GTX_C_N9: CC10.1 JMXM1.121
PEG_CRX_GTX_C_N10: CC11.1 JMXM1.115
PEG_CRX_GTX_C_N11: CC12.1 JMXM1.109
PEG_CRX_GTX_C_N12: CC13.1 JMXM1.103
PEG_CRX_GTX_C_N13: CC14.1 JMXM1.97
PEG_CRX_GTX_C_N14: CC15.1 JMXM1.91
PEG_CRX_GTX_C_N15: CC16.1 JMXM1.85
PEG_CRX_GTX_C_P0: CC17.1 JMXM1.179
PEG_CRX_GTX_C_P1: CC18.1 JMXM1.173
PEG_CRX_GTX_C_P2: CC19.1 JMXM1.167
PEG_CRX_GTX_C_P3: CC20.1 JMXM1.159
PEG_CRX_GTX_C_P4: CC21.1 JMXM1.153
PEG_CRX_GTX_C_P5: CC22.1 JMXM1.147
PEG_CRX_GTX_C_P6: CC23.1 JMXM1.141
PEG_CRX_GTX_C_P7: CC24.1 JMXM1.135
PEG_CRX_GTX_C_P8: CC25.1 JMXM1.129
PEG_CRX_GTX_C_P9: CC26.1 JMXM1.123
PEG_CRX_GTX_C_P10: CC27.1 JMXM1.117
PEG_CRX_GTX_C_P11: CC28.1 JMXM1.111
PEG_CRX_GTX_C_P12: CC29.1 JMXM1.105
PEG_CRX_GTX_C_P13: CC30.1 JMXM1.99
PEG_CRX_GTX_C_P14: CC31.1 JMXM1.93
PEG_CRX_GTX_C_P15: CC32.1 JMXM1.87
PEG_CRX_GTX_N0: CC1.2 JCPU1.K33
PEG_CRX_GTX_N1: CC2.2 JCPU1.M35
PEG_CRX_GTX_N2: CC3.2 JCPU1.L34
PEG_CRX_GTX_N3: CC4.2 JCPU1.J35
PEG_CRX_GTX_N4: CC5.2 JCPU1.J32
PEG_CRX_GTX_N5: CC6.2 JCPU1.H34
PEG_CRX_GTX_N6: CC7.2 JCPU1.H31
PEG_CRX_GTX_N7: CC8.2 JCPU1.G33
PEG_CRX_GTX_N8: CC9.2 JCPU1.G30
PEG_CRX_GTX_N9: CC10.2 JCPU1.F35
PEG_CRX_GTX_N10: CC11.2 JCPU1.E34
PEG_CRX_GTX_N11: CC12.2 JCPU1.E32
PEG_CRX_GTX_N12: CC13.2 JCPU1.D33
PEG_CRX_GTX_N13: CC14.2 JCPU1.D31
PEG_CRX_GTX_N14: CC15.2 JCPU1.B33
PEG_CRX_GTX_N15: CC16.2 JCPU1.C32
PEG_CRX_GTX_P0: CC17.2 JCPU1.J33
PEG_CRX_GTX_P1: CC18.2 JCPU1.L35
PEG_CRX_GTX_P2: CC19.2 JCPU1.K34
PEG_CRX_GTX_P3: CC20.2 JCPU1.H35
PEG_CRX_GTX_P4: CC21.2 JCPU1.H32
PEG_CRX_GTX_P5: CC22.2 JCPU1.G34
PEG_CRX_GTX_P6: CC23.2 JCPU1.G31
PEG_CRX_GTX_P7: CC24.2 JCPU1.F33
PEG_CRX_GTX_P8: CC25.2 JCPU1.F30
PEG_CRX_GTX_P9: CC26.2 JCPU1.E35
PEG_CRX_GTX_P10: CC27.2 JCPU1.E33
PEG_CRX_GTX_P11: CC28.2 JCPU1.F32
PEG_CRX_GTX_P12: CC29.2 JCPU1.D34
PEG_CRX_GTX_P13: CC30.2 JCPU1.E31
PEG_CRX_GTX_P14: CC31.2 JCPU1.C33
PEG_CRX_GTX_P15: CC32.2 JCPU1.B32
PEG_CTX_GRX_C_N0: CC33.2 JCPU1.M29
PEG_CTX_GRX_C_N1: CC34.2 JCPU1.M32
PEG_CTX_GRX_C_N2: CC35.2 JCPU1.M31
PEG_CTX_GRX_C_N3: CC36.2 JCPU1.L32
PEG_CTX_GRX_C_N4: CC37.2 JCPU1.L29
PEG_CTX_GRX_C_N5: CC38.2 JCPU1.K31
PEG_CTX_GRX_C_N6: CC39.2 JCPU1.K28
PEG_CTX_GRX_C_N7: CC40.2 JCPU1.J30
PEG_CTX_GRX_C_N8: CC41.2 JCPU1.J28
PEG_CTX_GRX_C_N9: CC42.2 JCPU1.H29
PEG_CTX_GRX_C_N10: CC43.2 JCPU1.G27
PEG_CTX_GRX_C_N11: CC44.2 JCPU1.E29
PEG_CTX_GRX_C_N12: CC45.2 JCPU1.F27
PEG_CTX_GRX_C_N13: CC46.2 JCPU1.D28
PEG_CTX_GRX_C_N14: CC47.2 JCPU1.F26
PEG_CTX_GRX_C_N15: CC48.2 JCPU1.E25
PEG_CTX_GRX_C_P0: CC49.2 JCPU1.M28
PEG_CTX_GRX_C_P1: CC50.2 JCPU1.M33
PEG_CTX_GRX_C_P2: CC51.2 JCPU1.M30
PEG_CTX_GRX_C_P3: CC52.2 JCPU1.L31
PEG_CTX_GRX_C_P4: CC53.2 JCPU1.L28
PEG_CTX_GRX_C_P5: CC54.2 JCPU1.K30
PEG_CTX_GRX_C_P6: CC55.2 JCPU1.K27
PEG_CTX_GRX_C_P7: CC56.2 JCPU1.J29
PEG_CTX_GRX_C_P8: CC57.2 JCPU1.J27
PEG_CTX_GRX_C_P9: CC58.2 JCPU1.H28
PEG_CTX_GRX_C_P10: CC59.2 JCPU1.G28
PEG_CTX_GRX_C_P11: CC60.2 JCPU1.E28
PEG_CTX_GRX_C_P12: CC61.2 JCPU1.F28
PEG_CTX_GRX_C_P13: CC62.2 JCPU1.D27
PEG_CTX_GRX_C_P14: CC63.2 JCPU1.E26
PEG_CTX_GRX_C_P15: CC64.2 JCPU1.D25
PEG_CTX_GRX_N0: CC33.1 JMXM1.176
PEG_CTX_GRX_N1: CC34.1 JMXM1.170
PEG_CTX_GRX_N2: CC35.1 JMXM1.164
PEG_CTX_GRX_N3: CC36.1 JMXM1.156
PEG_CTX_GRX_N4: CC37.1 JMXM1.150
PEG_CTX_GRX_N5: CC38.1 JMXM1.144
PEG_CTX_GRX_N6: CC39.1 JMXM1.138
PEG_CTX_GRX_N7: CC40.1 JMXM1.132
PEG_CTX_GRX_N8: CC41.1 JMXM1.126
PEG_CTX_GRX_N9: CC42.1 JMXM1.120
PEG_CTX_GRX_N10: CC43.1 JMXM1.114
PEG_CTX_GRX_N11: CC44.1 JMXM1.108
PEG_CTX_GRX_N12: CC45.1 JMXM1.102
PEG_CTX_GRX_N13: CC46.1 JMXM1.96
PEG_CTX_GRX_N14: CC47.1 JMXM1.90
PEG_CTX_GRX_N15: CC48.1 JMXM1.84
PEG_CTX_GRX_P0: CC49.1 JMXM1.178
PEG_CTX_GRX_P1: CC50.1 JMXM1.172
PEG_CTX_GRX_P2: CC51.1 JMXM1.166
PEG_CTX_GRX_P3: CC52.1 JMXM1.158
PEG_CTX_GRX_P4: CC53.1 JMXM1.152
PEG_CTX_GRX_P5: CC54.1 JMXM1.146
PEG_CTX_GRX_P6: CC55.1 JMXM1.140
PEG_CTX_GRX_P7: CC56.1 JMXM1.134
PEG_CTX_GRX_P8: CC57.1 JMXM1.128
PEG_CTX_GRX_P9: CC58.1 JMXM1.122
PEG_CTX_GRX_P10: CC59.1 JMXM1.116
PEG_CTX_GRX_P11: CC60.1 JMXM1.110
PEG_CTX_GRX_P12: CC61.1 JMXM1.104
PEG_CTX_GRX_P13: CC62.1 JMXM1.98
PEG_CTX_GRX_P14: CC63.1 JMXM1.92
PEG_CTX_GRX_P15: CC64.1 JMXM1.86
PEQ: R69.2 R70.2 U9.8
PGOOD: PR734.1 PU702.19
PGOODG: PR707.1 PU702.36
PHASE1: PC754.2 PQ705.3 PQ706.3 PU702.22
PHASE1G: PC771.2 PQ708.3 PU702.33
PHASE2: PC734.2 PQ703.3 PQ704.3 PU702.28
PHASE2G: PC764.2 PQ707.3 PU703.8
PHASE3: PC712.1 PQ701.3 PQ702.3 PU701.8
PLTRST_GPU#: RH343.1 U16.2
PLTRST_LAN#: RH338.1 U31.36
PLTRST_MMI#: JIO1.10 RH336.1
PLTRST_USH#: JUSH1.15 RH335.1
PLTRST_XDP#: RC21.1 RH337.1
PM_APWROK: RH118.1 U54.A9 UC4.2
PM_APWROK_R: RH118.2 UC4.4 UH4.L10
PM_DRAM_PWRGD: RC6.2 RH320.1 UC1.2
PM_DRAM_PWRGD_R: RH320.2 UH4.B13
PM_LANPHY_ENABLE: R555.1 UH4.C4
POWER_SW#: U10.4 U18.26
POWER_SW#_MB: C746.1 C759.1 JPB1.1 PWRSW1.1 R811.2
POWER_SW_IN#: C757.1 R810.2 R811.1 U10.2 U54.B67
PP: R656.1 U37.7 U39.7
PROCHOT#_EC: Q47.2 R812.2 R1179.2 R1180.1 U54.A46
PROCHOT_GATE: PU903.2 R761.2 U46.A50
PS2_CLK_TS: JIO1.116 JKB1.17 JKB1.18
PS2_DAT_TS: JIO1.114 JKB1.15 JKB1.16
PS_ID: PU1.4 U54.A55
PSATA_PRX_DTX_N0: C418.1 U26.4
PSATA_PRX_DTX_N0_C: C418.2 UH4.AM3
PSATA_PRX_DTX_N0_RP: C385.2 U26.12
PSATA_PRX_DTX_P0: C421.1 U26.5
PSATA_PRX_DTX_P0_C: C421.2 UH4.AM1
PSATA_PRX_DTX_P0_RP: C386.2 U26.11
PSATA_PTX_DRX_N0: C422.1 U26.2
PSATA_PTX_DRX_N0_C: C422.2 UH4.AP7
PSATA_PTX_DRX_N0_RP: C384.2 U26.14
PSATA_PTX_DRX_P0: C423.1 U26.1
PSATA_PTX_DRX_P0_C: C423.2 UH4.AP5
PSATA_PTX_DRX_P0_RP: C383.2 U26.15
PSID_DISABLE#: PR13.2 U46.A37
PWM3: PR713.2 PR715.1 PU702.24
PWM3_1: PR713.1 PU701.3
PWMG2: PU702.35 PU703.3
PWR_SRC_ON: C297.2 Q21.3 R422.2 R423.1
PWRSHARE_EN: Q55.2 R784.2 U2.1
PWRSHARE_EN#: Q55.1 Q91.2 R816.1 U45.4
RBIAS_CPY: RH112.2 UH4.BH21
RBIAS_SATA3: RH46.1 UH4.AH1
RED_CRT: C20.1 L1.1 R53.1 U19.33
RED_CRT_L: C21.1 D11.3 JCRT1.1 L1.2
RED_DOCK: JDOCK1.53 U19.24
REGCTL_PNP10: L29.1 U31.7
REM_DIODE1_N_4002: C334.1 C339.1 Q26.3 U18.35
REM_DIODE1_P_4002: C334.2 C339.2 Q26.1 Q26.2 U18.36
REM_DIODE2_N_4002: C340.2 C344.1 Q17.3 U18.37
REM_DIODE2_P_4002: C340.1 C344.2 Q17.1 Q17.2 U18.38
REM_DIODE3_N_4002: C272.2 C346.1 Q14.3 U18.40
REM_DIODE3_P_4002: C272.1 C346.2 Q14.1 Q14.2 U18.41
REM_DIODE4_N_4002: C288.2 C294.1 C335.2 Q15.3 Q16.1 Q16.2 U18.43
REM_DIODE4_P_4002: C288.1 C294.2 C335.1 Q15.1 Q15.2 Q16.3 U18.44
REM_DIODE5_N_4002: C347.2 C349.1 Q33.3 U18.46
REM_DIODE5_P_4002: C347.1 C349.2 Q33.1 Q33.2 U18.47
RES_BIAS: R562.1 U31.12
RESET_OUT#: Q52.2 R843.2 RH117.1 RH321.1 U54.B39
REXT: R51.2 R84.1 U26.20
REXT3: R74.2 U9.27
RF_+V1.05S_VCCPP: PR506.1 PU501.5
RF_+V1.05SP: PR406.1 PU401.5
RGB_PNL_DET: Q88.1 R341.2 U627.2
RGB_PNL_DET#: JEDP1.18 Q88.2 R340.2
RSMRST#: R1622.1 U4.3 U7.2
RSMRST#_XDP: JXDP2.46 RH24.2
RUN_GFX_ON: C362.1 C749.2 Q87.2 Q294.2 QH2.2 R301.1 U46.A55
RUN_GFX_ON#: Q36.2 Q48.2 Q50.2 Q294.5 Q294.6 R294.2
RUN_ON: JIO1.36 PR304.1 PR314.1 R762.1 R786.1 R1621.1 U46.A11
RUN_ON_CPU1.5VS3: CC71.1 QC3.4 QC4.2 QC5.3 RC73.2 RC79.1
RUN_ON_CPU1.5VS3#: Q71.2 Q72.2 QC1.2 QC5.5 QC5.6 RC76.2
RUN_ON_ENABLE#: Q45.2 Q59.2 Q61.2 Q67.2 Q68.2 Q69.2 Q70.2 Q304.5 Q304.6 R909.2
RUNPWROK: Q45.1 R799.2 U46.A4 U54.B26 UC1.1
S3_1.5V: PR214.2 PU201.7
S5_1.5V: PC213.1 PR210.2 PR226.2 PU201.8
SATA3_COMP: RH42.1 UH4.AB12 UH4.AB13
SATA_ACT#: Q74.4 UH4.P3
SATA_COMP: RH40.1 UH4.Y10 UH4.Y11
SATA_LED: JIO1.96 R934.2
SATA_NVR_PRX_DTX_N2: C448.2 U12.23
SATA_NVR_PRX_DTX_P2: C447.2 U12.24
SATA_NVR_PTX_DRX_N2: C445.2 U12.22
SATA_NVR_PTX_DRX_P2: C446.2 U12.21
SATA_NVRAM_PRX_DTX_N2_C: C448.1 UH4.AD7
SATA_NVRAM_PRX_DTX_P2_C: C447.1 UH4.AD5
SATA_NVRAM_PTX_DRX_N2_C: C445.1 UH4.AH5
SATA_NVRAM_PTX_DRX_P2_C: C446.1 UH4.AH4
SATA_ODD_PRX_DTX_N3: C432.1 JODD1.5
SATA_ODD_PRX_DTX_N3_C: C432.2 UH4.AB8
SATA_ODD_PRX_DTX_P3: C430.1 JODD1.6
SATA_ODD_PRX_DTX_P3_C: C430.2 UH4.AB10
SATA_ODD_PTX_DRX_N3: C434.1 JODD1.3
SATA_ODD_PTX_DRX_N3_C: C434.2 UH4.AF3
SATA_ODD_PTX_DRX_P3: C433.1 JODD1.2
SATA_ODD_PTX_DRX_P3_C: C433.2 UH4.AF1
SATA_PRX_DKTX_N5: C698.2 JDOCK1.56
SATA_PRX_DKTX_N5_C: C698.1 UH4.Y3
SATA_PRX_DKTX_P5: C697.2 JDOCK1.54
SATA_PRX_DKTX_P5_C: C697.1 UH4.Y1
SATA_PRX_DTX_N0: C385.1 JSATA1.5
SATA_PRX_DTX_N1: C414.1 JSATA2.5
SATA_PRX_DTX_N1_C: C414.2 UH4.AM10
SATA_PRX_DTX_N4: C673.2 JESA1.9
SATA_PRX_DTX_P0: C386.1 JSATA1.6
SATA_PRX_DTX_P1: C412.1 JSATA2.6
SATA_PRX_DTX_P1_C: C412.2 UH4.AM8
SATA_PRX_DTX_P4: C674.2 JESA1.10
SATA_PTX_DKRX_N5: C700.1 JDOCK1.62
SATA_PTX_DKRX_N5_C: C700.2 UH4.AB3
SATA_PTX_DKRX_P5: C699.1 JDOCK1.60
SATA_PTX_DKRX_P5_C: C699.2 UH4.AB1
SATA_PTX_DRX_N0: C384.1 JSATA1.3
SATA_PTX_DRX_N1: C411.1 JSATA2.3
SATA_PTX_DRX_N1_C: C411.2 UH4.AP11
SATA_PTX_DRX_N4: C672.2 JESA1.7
SATA_PTX_DRX_P0: C383.1 JSATA1.2
SATA_PTX_DRX_P1: C413.1 JSATA2.2
SATA_PTX_DRX_P1_C: C413.2 UH4.AP10
SATA_PTX_DRX_P4: C671.2 JESA1.6
SATA_REPEATER_EN: C24.2 R85.1 U26.7
SATA_SIDE_LED: JIO1.88 R943.2
SB#: Q338.2 R1626.2 U2.8
SCLK: PR722.2 PR737.1 PU702.5
SDA: PR727.2 PR745.1 PU702.7
SEL: Q338.1 R1613.2 R1614.1 U2.4
SIO_14M: RH313.2 UH4.F47
SIO_A20GATE: RH158.1 U54.A45 UH4.P4
SIO_EXT_SCI#: RH259.1 RH263.2 U54.A33
SIO_EXT_SCI#_R: RH53.1 RH259.2 UH4.T7
SIO_EXT_SMI#: RH9.1 RPH2.2 U54.A6 UH4.C14
SIO_EXT_WAKE#: R797.1 RH177.1 UH4.C10
SIO_PWRBTN#: RH122.1 U54.B58
SIO_PWRBTN#_R: RC9.1 RH21.1 RH122.2 UH4.E20
SIO_RCIN#: RH203.1 U54.A27 UH4.P5
SIO_SLP_A#: PR404.1 Q306.2 U46.B63 UC4.1 UH4.G10
SIO_SLP_LAN#: Q297.2 RH319.2 U46.A5 UH4.K14
SIO_SLP_S3#: JIO1.34 PR307.1 PR311.1 R781.1 R1624.1 RC82.1 U46.B65 UH4.F4
SIO_SLP_S4#: PR226.1 R808.1 T59.1(TP-1) U46.A61 UH4.H4
SIO_SLP_S5#: T58.1(TP-1) U54.B16 UH4.D10
SIO_SLP_SUS#: T62.1(TP-1) U46.B6 UH4.G16
SL_BAT_PRES#: PR1023.1 PU1001.21
SLICE_BAT_ON: PR1016.2 R791.1 U46.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PR6.1 PR1023.2 R760.2 U46.B33
SLP_ME_CSW_DEV#: RH10.1 RH54.1 RH353.1 U46.B58 UH4.P8
SM_RCOMP0: JCPU1.AK1 RC50.1
SM_RCOMP1: JCPU1.A5 RC48.1
SM_RCOMP2: JCPU1.A4 RC47.1
SML1_SMBCLK: RH298.2 U54.B6 UH4.E14
SML1_SMBDATA: RH299.2 U54.A5 UH4.M16
SNUB_1.5V: PC212.1 PR203.2
SNUB_1.5VSP: PC312.1 PR309.2
SNUB_1.8VSP: PC306.1 PR302.2
SNUB_3V: PC114.1 PR110.2
SNUB_5V: PC115.1 PR111.2
SNUB_+V1.05S_VCCPP: PC509.1 PR505.2
SNUB_+V1.05SP: PC409.1 PR405.2
SOFT_START_GC: PR20.2 PU1001.2
SP_TPM_LPC_EN: D103.1 R772.2 R2188.1 U46.B56
SP_TPM_LPC_EN_R: D103.2 R2188.2 R2189.2 U37.28 U39.28
SPI_CLK32: R897.1 R913.2 U53.6
SPI_CLK64: R899.1 R910.2 U52.6
SPI_DIN32: R895.2 U53.2
SPI_DIN64: R894.2 U52.2
SPI_DO32: R900.1 U53.5
SPI_DO64: R901.1 U52.5
SPI_HOLD#: R891.2 U52.7 U53.7
SPI_PCH_CLK: JSPI1.7 R897.2 R899.2 RH348.1
SPI_PCH_CS0#: JSPI1.9 R963.1 RH349.1
SPI_PCH_CS0#_R: R963.2 U52.1
SPI_PCH_CS1#: JSPI1.1 R936.1 RH345.1
SPI_PCH_CS1#_R: R936.2 U53.1
SPI_PCH_DIN: JSPI1.5 R894.1 R895.1 RH347.1
SPI_PCH_DO: JSPI1.3 R900.2 R901.2 RH346.1
SPI_WP#_SEL: R898.1 U46.A12
SPI_WP#_SEL_R: R890.2 R898.2 U52.3 U53.3
SPKR: JIO1.47 RH35.1 UH4.T10
SRTCRST#: CH5.2 ME1.2 RH23.2 UH4.G22
STSTART_DCBLOCK_GC: PR1002.1 PU1001.16
SUS_ON: R806.1 R888.1 U46.B60
SUS_ON_3.3V#: Q65.2 Q303.5 Q303.6 R915.2
SUS_STAT#/LPCPD#: RH318.2 T56.1(TP-1) UH4.G8
SUSACK#: RH114.1 U46.A58
SUSACK#_R: RH114.2 RH323.2 UH4.C12
SUSCLK: T57.1(TP-1) UH4.N14
SW_1.5V: PC205.1 PL201.2 PQ201.1 PQ201.2 PQ201.3 PQ202.5 PR203.1 PU201.16
SW_+V1.05S_VCCPP: PC505.1 PL501.1 PQ501.1 PQ501.2 PQ501.3 PQ502.5 PR505.1 PU501.8
SW_+V1.05SP: PC405.1 PL401.1 PQ401.1 PQ401.2 PQ401.3 PQ402.5 PR405.1 PU401.8
SW_LAN_TX0+: C500.1 T156.1 U32.24
SW_LAN_TX0-: C500.2 T156.2 U32.25
SW_LAN_TX1+: C501.1 T156.5 U32.28
SW_LAN_TX1-: C501.2 T156.6 U32.29
SW_LAN_TX2+: C502.1 T156.7 U32.33
SW_LAN_TX2-: C502.2 T156.8 U32.34
SW_LAN_TX3+: C503.1 T156.11 U32.37
SW_LAN_TX3-: C503.2 T156.12 U32.38
SW_LVDS_A0+: JLVDS1.21 U11.9
SW_LVDS_A0-: JLVDS1.22 U11.10
SW_LVDS_A1+: JLVDS1.23 U11.7
SW_LVDS_A1-: JLVDS1.24 U11.8
SW_LVDS_A2+: JLVDS1.25 U11.2
SW_LVDS_A2-: JLVDS1.26 U11.3
SW_LVDS_ACLK+: C1183.1 JLVDS1.28 U11.36
SW_LVDS_ACLK-: C1184.1 JLVDS1.29 U11.1
