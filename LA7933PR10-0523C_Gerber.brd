# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5V_RUNP: length 20.2
  IN1 w0.254: v1(214.54,72.44) 214.6,72.5 214.6,77.28 214.3,77.58 203.33,77.58 202.96,77.22 v1(202.96,76.4)
  BOTTOM w0.254: 215.06,72.54 214.95,72.43 214.55,72.43 v1(214.54,72.44) ; 215.06,72.54 215.21,72.69 PR310.1 PC308.1 ; 215.06,72.54 v2(215.07,72.54)
+1.5VP: length 70.4
  IN1 w0.254: v1(215.24,56.27) 216.84,54.67 233.11,54.67 234.66,53.12 v1(234.66,51.36) ; v1(243.29,45.02) 243.29,49.99 238.23,55.06 217.04,55.06 216.13,55.97 v1(216.13,56.33)
  BOTTOM w0.254: v1(243.29,45.02) PR208.2 PC218.2
  BOTTOM w0.508: v1(234.66,51.36) PR206.1
  BOTTOM w1.016: 224.23,49.7 224.23,52.01 223.38,52.86 216.52,52.86
  vias: v2(214.29,63.61)
+1.05VTTP: length 31.9
  IN4 w0.254: v1(73.82,26.04) 73.82,28.13 73.38,28.58 53.82,28.58 52.93,27.69 v1(52.93,22.92)
  BOTTOM w0.102: 74.8,27.19 74.8,29.43 v2(74.55,29.68)
  BOTTOM w0.254: v1(52.93,22.92) 53.47,22.38 PC511.1
+1.8V_RUN: length 214.4
  TOP w0.254: JCPU1.A6 94.9,41.48 v5(95.4,41.98) 94.93,42.45 JCPU1.B6
  TOP w2.032: 109.42,87.27 109.42,88.93 105.47,92.88 100.86,92.88 88.77,104.97 86.55,104.97
  IN1 w1.016: 40.42,36.45 38.01,36.45 37.97,36.49 36.27,36.49 35.6,35.81 31.98,35.81 30.8,37 30.8,45.26 27.84,48.22 27.84,57.3 24.5,60.64 13.97,60.64 8.83,65.78 8.83,72.48 12.15,75.79 12.15,84.18 13.35,85.37 13.35,93.89 13.38,93.93
  IN4 w1.016: 92.59,23.34 92.31,23.62 83.04,23.62 77.01,29.66 66.31,29.66 58.81,37.15 43.43,37.15
  IN4 w2.032: 110.36,84.39 110.36,84.11 109.42,83.17 109.42,79.39 106.5,76.47 106.5,46.42 104.49,44.41
  vias: v1(28.08,95.06) v1(29.37,94.98) v1(42.19,37.44) v1(42.82,37.44) v1(46.47,130.24) v1(47.04,130.73) v1(47.38,130.19) v1(47.98,130.73) v1(66.72,120.18) v1(66.7,119.55) v1(66.78,121.41) v1(66.95,120.8) v1(84.19,106.25) v1(84.86,106.25) v1(84.87,105.61) v1(85.52,106.25) v1(92.89,37.02) v1(92.89,36.22) v1(93.43,37.5) v1(93.46,36.74) v1(93.57,23.43) v1(94.21,23.43) v1(94.84,23.43) v1(109.42,85.81) v1(110.06,85.81) v1(110.69,85.8) v1(111.33,85.81) v4(95.41,30.26) v5(101.01,42.37) v5(101.01,41.61)
+1.8V_RUN_LVDS: length 6.1
  TOP w0.254: v1(33.67,122.38) 33.99,122.07 UH4.AP37 UH4.AP36 ; v1(33.67,122.38) 33.35,122.07 UH4.AM37 ; v1(33.67,122.38) v1(33.67,123.04) 33.43,123.04 UH4.AM38
  BOTTOM w0.508: CH104.1 33.53,124.45 CH103.1 33.64,123.08 v1(33.67,123.04)
  vias: v1(43.95,127.24) v1(43.95,126.58) v2(43.88,127.8)
+1.8V_RUNP: length 26.4
  BOTTOM w0.254: 97.51,14.8 96.87,14.16 96.87,12.57 96.95,12.49 96.95,11.29 97.38,10.86 105.8,10.86 106.22,11.28 107.07,11.28 109.57,13.78 109.57,15.15 111.69,17.27 111.69,18.48 PR303.1 PC302.1
  vias: v2(101.36,23.58)
+3.3V_ALW: length 843
  TOP w0.356: U50.5 27.67,11.51 27.53,11.37 C720.1
  TOP w0.381: C90.1 211.79,132.81 211.09,132.11 210.84,132.11 210.68,132.27 U16.5 ; 158.05,12.99 158.05,15.23 155.8,17.48 152.21,17.48 151.14,18.54 146.53,18.54 141.22,13.23
  TOP w0.508: v1(209.9,78.42) 209.23,79.1 198.78,79.1 195.45,82.42 v1(193.29,82.42) ; v1(212.61,120.09) 211.73,119.21 R849.1 ; v1(13.27,155.16) 13.64,155.52 16.19,155.52 16.48,155.23 20.34,155.23 20.98,154.6 20.98,153.24 R738.1 ; v1(130.77,126.81) 132.47,125.11 PR21.1 ; R824.1 171.04,159.09 v1(171.05,159.08) 171.09,159.08 171.83,159.82 174.36,159.82 175.16,160.62 175.16,162.83 v1(175.6,163.27) ; PR2.1 v1(202.54,10.22) ; v1(178.76,151.24) 178.71,151.3 178.43,151.3 177.77,151.96 R827.1 ; R11.1 v1(211.24,153.01) ; v1(7.66,154.28) 8.18,154.8 PR401.1 ; v1(115.39,125.41) 115.42,125.44 115.42,125.82 115.92,126.33 R755.1 ; R871.1 156.84,145.34 156.53,145.66 v1(156.53,145.9) ; R847.1 R860.1 R858.1 R848.1 207.78,120.02 209.23,121.47 210.26,121.47 211.38,122.59 211.38,125.21 212.46,126.29 212.46,131.52 212.16,131.81 v1(211.72,131.81) 211.72,131.92 211.81,132 C90.1 ; R850.1 213.98,107.56 v1(214.25,107.29) 214.25,106.63 R861.1 214.29,106.05 214.39,105.95 R859.1 R864.1 ; v1(152.07,95.48) 150.87,96.67 150.87,106.17 149.39,107.66 v1(149.39,108.09) 149.39,108.68 C258.1 ; R856.2 157.4,148.53 R418.2 v1(156.5,148.58) ; v1(248.8,67.03) 248.77,67.03 247.17,68.63 247.17,71.41 246.59,71.98 246.12,71.98 245.68,72.43 245.68,74.27 246.3,74.89 v1(246.35,74.89) ; v1(28.16,10.78) 28.16,10.78 27.82,10.44 C720.1 ; v1(163.13,137) 163.13,137.55 R1125.2 ; v1(164.31,100.34) 164.37,100.28 C257.1 164.11,98.98 163.55,98.41 v1(163.55,95.61) ; v1(178,140.78) 177.39,140.78 176.88,141.29 R1178.2 ; R419.1 v1(11.4,130.87) ; C756.1 88.06,108.84 87.64,109.26 86.92,109.26 86.47,109.7 86.47,110.23 86.75,110.5 JKB1.13 JKB1.14 86.75,115.65 89.51,118.42 89.51,122.09 88.97,122.62 88.97,129.39 v1(88.28,130.09) ; v1(131.39,129.24) 131.39,132.39 129.47,134.31 129.47,137.01 131.09,138.62 v1(131.09,141.5) ; v1(29.26,24.94) 29.01,24.94 28.31,25.64 26.97,25.64 26.55,25.22 R796.1 ; PR1025.2 v1(183.68,76.01) ; R838.2 157.35,149.61 R420.2 156.72,149.59 v1(156.51,149.8) ; C259.1 144.08,109.03 v1(145.02,108.09) ; v1(166.98,155.96) R820.1 ; R14.1 v1(173.94,172.28)
  TOP w1.143: 158.05,12.99 157.8,12.99 156.77,14.02 155.17,14.02 154.46,13.32 154.46,12.19 154.02,11.75 146.52,11.75 145.03,13.23 141.22,13.23
  TOP w1.524: 177.04,13.74 174.62,13.74 173.39,12.51 158.53,12.51 158.05,12.99 ; 141.22,13.23 133.98,13.23 132.37,11.62 128.04,11.62 127.48,12.18 127.48,21.54 125.88,23.14 125.42,23.14 125.11,23.45
  IN1 w0.508: v1(298.26,44.73) 298.26,48.77 292.89,54.14 292.89,56.54 291.3,58.13 291.3,64.21 293.36,66.27 293.36,79.82 289.08,84.1 289.08,100.01 290.76,101.7 v1(290.76,102.82) ; v1(156.5,148.58) 156.6,148.58 157.22,147.96 157.22,146.65 156.53,145.95 v1(156.53,145.9) ; 235.29,83.52 237.96,83.52 238.48,83 240.39,83 240.7,82.69 242.17,82.69 242.63,82.23 v1(242.63,82.08) 242.77,82.22 244.68,82.22 245.97,80.92 245.97,79.87 247.34,78.5 247.34,75.26 246.98,74.89 v1(246.35,74.89) ; 235.29,83.52 235.29,82.82 234.49,82.02 v1(234.42,82.02) ; 235.29,83.52 234.1,83.52 233.21,84.4 231.57,84.4 230.83,85.14 223.05,85.14 221.77,83.86 v1(221.77,83.1) 221.77,82.84 226.43,78.18 v1(226.43,78.13) ; v1(174.71,103) 174.76,103 175.6,102.16 177.07,102.16 179.09,104.18 v1(179.58,104.18) 180.61,104.18 180.92,103.86 183.72,103.86 185.38,102.2 v1(185.98,102.2) ; v1(214.25,107.29) 213.04,108.5 213.04,110.68 211.89,111.84 211.89,114.16 212.88,115.15 212.88,119.83 v1(212.61,120.09)
  IN2 w0.508: v1(98.75,130.53) 98.61,130.67 88.85,130.67 88.28,130.1 v1(88.28,130.09) ; v1(100.66,130.53) 100.94,130.25 106.45,130.25 106.71,129.99 111.63,129.99 112.25,129.36 112.25,127.8 113.12,126.93 114.18,126.93 115.39,125.72 115.39,125.5 ; v1(207.3,156.76) 207.3,156.62 210.91,153.01 v1(211.24,153.01) ; v1(72.45,149.25) 72.35,149.35 72.35,150.08 70.99,151.44 68.81,151.44 v1(67.64,150.27) ; 115.39,125.5 v1(115.39,125.41) ; 115.39,125.5 116.99,127.1 119.66,127.1 120.41,127.85 124.6,127.85 124.92,127.53 130.05,127.53 v1(130.77,126.81) ; v1(163.55,95.61) 163.41,95.75 162.85,95.75 162.12,95.02 158.91,95.02 157.81,93.92 155.56,93.92 154,95.48 v1(152.07,95.48) ; v1(166.98,155.96) 166.05,155.96 166,155.91 165.3,155.91 164.78,155.39 164.08,155.39 163.64,154.94 161.2,154.94 160.97,155.17 v1(160.97,156.11)
  IN2 w1.524: 177.62,14.36 176.64,15.34 176.64,15.62 166.33,25.93 166.33,32.68 166.83,33.17 166.83,38.38 174.93,46.48 178.69,46.48 182.88,50.67 191.93,50.67 192.11,50.85 202.14,50.85 203.39,49.61 205.9,49.61 207.73,51.44 207.73,54.55 209.33,56.15 210.35,56.15
  IN3 w0.508: v1(202.54,10.22) 202.54,12.48 212.2,22.15 223.34,22.15 225.49,20 225.49,16.28 227.63,14.14 246.19,14.14 v1(247.34,15.29) 247.34,18.17 v1(248.11,18.94) 248.11,22.41 v1(247.78,22.75) ; v1(177.32,147.89) 177.84,147.89 178.85,148.91 178.85,151.16 v1(178.76,151.24) ; v1(173.94,172.28) 173.94,172.25 172.74,171.06 172.74,166.1 175.58,163.27 v1(175.6,163.27) ; v1(28.16,10.78) 28.16,10.8 28.16,10.82 28.17,10.82 28.17,10.84 28.17,10.84 28.17,12.76 27.41,13.53 27.41,19.1 27.53,19.23 27.53,19.76 27.41,19.89 27.41,22.54 29.18,24.32 29.18,24.87 v1(29.26,24.94) 29.26,24.98 27.71,26.53 27.71,27.5 27.93,27.71 27.93,29.73 27.7,29.95 27.7,32.79 27.41,33.08 v1(27.41,34.74)
  IN4 w0.508: v1(211.24,153.01) 210.81,153.01 210.2,152.4 210.2,149.23 211.42,148.01 211.42,136.46 210.97,136.02 210.97,132.55 211.71,131.81 v1(211.72,131.81) ; v1(145.02,108.09) 145.65,108.73 147.83,108.73 148.46,108.09 v1(149.39,108.09) ; v1(166.98,155.96) 166.98,156.26 168.81,158.09 170.28,158.09 171.05,158.86 v1(171.05,159.08) ; v1(229.39,60.06) 229.22,59.89 227.97,59.89 227.84,60.02 v1(227.77,60.02) ; v1(131.39,129.24) 130.77,128.61 v1(130.77,126.81) ; v1(182.93,148.36) 182.81,148.48 178.41,148.48 177.82,147.89 v1(177.32,147.89) ; v1(181.68,150.81) 181.84,150.65 185.38,150.65 187.23,148.79 191.7,148.79 192.43,148.07 193.84,148.07 195.36,149.59 198.77,149.59 203.02,153.85 203.02,155.14 204.62,156.74 207.29,156.74 v1(207.3,156.76) ; v1(153.96,154.71) 154.04,154.79 154.04,155.8 154.37,156.13 156.75,156.13 157.41,155.47 160.3,155.47 160.93,156.11 v1(160.97,156.11)
  BOTTOM w0.254: U17.5 202.29,153.75 201.79,153.25 C92.1
  BOTTOM w0.356: PC942.2 248,18.16 PU903.5
  BOTTOM w0.381: C289.1 181.9,149.92 182.36,149.46 U7.5 ; v1(156.53,145.9) 156.5,145.92 156.5,146.56 157.33,147.38 R854.2
  BOTTOM w0.508: v1(269.4,62.29) PR114.2 ; v1(237.93,49.12) PR216.1 PR213.1 ; v1(156.51,149.8) 156.61,149.7 157.26,149.7 R420.2 ; PR945.1 247.98,17.03 248.41,16.6 248.41,15.81 247.89,15.29 v1(247.34,15.29) ; C289.1 v1(181.68,150.81) ; R769.1 234.54,81.92 234.44,82.02 v1(234.42,82.02) 234.42,82.13 234.9,82.61 R768.1 ; v1(166.98,155.96) R820.1 ; 30.58,43.88 30.58,38.62 30.1,38.14 28.38,38.14 27.71,37.47 27.71,35.04 v1(27.41,34.74) ; v1(211.72,131.81) 212.01,131.81 212.37,131.46 212.37,130.58 211.92,130.14 211.92,120.78 v1(212.61,120.09) ; R693.1 177.46,85.6 v1(177.9,86.04) ; R779.1 v1(233.27,62.17) R932.1 ; v1(185.98,102.2) 186.96,103.18 R692.1 ; R800.1 R774.1 245.95,74.49 v1(246.35,74.89) ; R759.1 157.07,139.55 156.92,139.55 v1(156.59,139.88) ; v1(178.76,151.24) 178.71,151.3 178.38,151.3 177.72,151.96 R827.1 ; v1(227.77,60.02) 227.73,60.06 227.48,60.06 227.18,60.36 R944.1 ; v1(17.31,89.47) 16.96,89.47 16.07,90.36 R35.1 ; v1(235.89,42.77) PR205.1 ; PR308.1 v1(209.9,78.42) 209.87,78.42 209.43,78.85 209.43,79.5 209.71,79.78 215.37,79.78 215.75,80.16 215.75,80.5 216.63,81.39 216.63,81.39 217.86,82.63 218.37,82.63 218.84,83.1 v1(221.77,83.1) ; R715.1 178.66,105.03 179.51,104.18 v1(179.58,104.18) ; R817.1 157.36,137.93 v1(157.81,137.48) ; PR221.1 PR222.1 v1(236.4,40.74) ; v1(68.22,162.83) 68.3,162.91 R162.1 ; v1(67.64,150.27) 67.64,150.31 67.19,150.75 R414.1 ; v1(10.63,79.97) 10.23,80.37 6.51,80.37 5.94,79.79 5.94,77.5 6.67,76.77 PR8.2 ; R821.2 157.07,142.3 v1(156.56,142.81) 157.07,143.32 R875.1 ; R872.1 160.63,155.78 160.96,156.11 v1(160.97,156.11) ; R937.1 229.75,60.33 229.65,60.33 v1(229.39,60.06) ; v1(168.9,143.52) 168.98,143.43 R823.1 ; v1(207.3,156.76) 207.28,156.78 204.09,156.78 203.04,155.73 U17.5 ; R938.1 291.18,103.24 v1(290.76,102.82) ; v1(239.88,58.22) R776.1 ; PC942.2 v1(248.11,18.94) ; v1(177.32,147.89) R814.1 ; v1(239.88,62.14) R765.1
  vias: v1(7.59,94.96) v1(7.59,94.32) v1(11.05,131.53) v1(11.16,80.37) v1(11.62,131.81) v1(11.95,131.26) v1(12.57,155.17) v1(12.57,154.53) v1(13.27,154.52) v1(34.45,44.39) v1(34.45,43.75) v1(34.68,45.05) v1(73.05,149.49) v1(73.68,149.49) v1(74.32,149.52) v1(77.9,152.25) v1(78.4,151.84) v1(78.52,152.49) v1(79.07,151.84) v1(97.81,151.04) v1(97.81,150.41) v1(98.45,151.05) v1(98.46,150.42) v1(99.39,130.53) v1(100.02,130.53) v1(131.09,142.14) v1(133.72,141.95) v1(133.72,141.31) v1(135.69,146.1) v1(136.35,146.1) v1(136.98,146.1) v1(137.67,146.09) v1(151.84,149.56) v1(152.36,149.17) v1(154.68,162.89) v1(154.7,162.2) v1(170.47,136.98) v1(170.46,136.35) v1(171.11,136.98) v1(171.14,136.35) v1(172.71,103.02) v1(174.06,103.2) v1(178.04,13.11) v1(178.34,12.46) v1(178.75,13.09) v1(192.63,82.37) v1(211.57,55.69) v1(211.91,56.3) v1(212.23,55.7) v1(218.25,66.22) v1(218.9,66.22) v1(247.45,65.34) v1(247.45,64.68) v1(248.08,64.68) v1(248.72,64.68) v1(257.91,62.17) v1(258.55,62.17) v1(259.18,62.17) v1(282.8,26.23) v1(282.8,25.08) v1(284.07,26.23) v1(284.07,25.08) v1(284.96,26.23) v1(284.96,25.08) v1(285.85,26.23) v1(285.85,25.08) v1(286.99,26.23) v1(286.99,25.08) v1(289.15,44.9) v1(289.15,44.13) v1(289.53,42.74) v1(289.53,41.97) v1(289.53,26.35) v1(289.53,25.21) v1(290.42,42.74) v1(290.42,41.97) v1(290.55,26.35) v1(290.55,25.21) v1(291.57,26.35) v1(291.57,25.21) v1(292.58,26.35) v1(292.58,25.21) v4(2.77,117.29) v4(28.14,56.3) v4(98.97,133.87)
+3.3V_ALW2: length 943.9
  TOP w0.508: v1(209.8,35.38) v1(209.8,41.49) ; v1(28.88,93.56) 29.41,93.56 30.81,94.96 30.81,95.83 RH253.1 ; v1(46.98,123.04) 46.16,123.04 45.91,123.29 R909.1 ; v1(178.8,60.88) 178.88,60.97 v1(178.88,63.78) PR1013.1 179.7,64.58 179.93,64.81 PR1022.1 ; v1(183.2,60.36) 183.13,60.3 R500.1 ; v1(51.84,130.92) 51.98,131.06 51.98,134.53 52.86,135.41 52.86,137.71 53.73,138.58 v1(53.73,140.51) ; v1(104.84,137.4) 104.92,137.32 R1532.1 ; v1(130.88,151.19) 130.82,151.26 130.82,151.73 131.05,151.96 R918.1 ; v1(191.62,77.79) 190.16,76.33 190.16,65.7 v1(188.86,64.4) ; RC76.1 116.15,47.69 115.63,47.18 114.59,47.18 114.34,47.44 112.29,47.44 108.44,43.59 108.44,31.76 102.69,26.01 93.93,26.01 v1(93.41,25.49) ; R915.1 128.4,22.76 129.4,21.77 129.4,16.84 130.19,16.05 v1(131.02,16.05) ; v1(131.28,135.69) 132.56,136.97 R565.1 ; v1(296.82,23.39) 296.82,42.29 291.53,47.59 291.53,53.66 289.42,55.77 v1(289.42,64.99) 289,65.41 282.6,65.41 280.64,63.45 v1(280.64,61.66)
  IN1 w0.508: v1(18.24,76.04) 18.1,76.04 17.59,76.55 17.59,78.64 19.02,80.07 19.02,87.69 19.91,88.58 22.07,88.58 24.48,91 26.64,91 28.88,93.23 v1(28.88,93.56) ; v1(131.02,16.05) 131.48,15.6 145.48,15.6 146.21,16.33 149.27,16.33 150.13,17.18 150.13,19.03 151.17,20.07 155.54,20.07 156.65,21.18 156.65,26.28 158.68,28.31 159.19,28.31 160.26,29.38 160.26,42.82 162.01,44.58 162.01,46.04 162.65,46.67 162.65,49.14 164.88,51.37 169.86,51.37 171.08,52.59 171.08,61.76 171.31,61.99 v1(171.32,61.99) ; v1(209.8,35.38) 209.8,35.28 218.02,27.06 v1(242.86,27.06) 273.4,27.06 278.51,21.96 295.39,21.96 v1(296.82,23.39)
  IN2 w0.508: v1(15.05,136.31) 15.38,136.64 15.38,136.69 17.7,139.01 19.91,139.01 22.31,141.42 22.34,141.42 22.36,141.44 25.51,141.44 25.54,141.42 25.58,141.42 26.48,140.51 27.25,140.51 28.18,139.59 28.89,139.59 29.31,139.17 32.56,139.17 32.7,139.03 35.45,139.03 36.52,137.96 45.33,137.96 46.96,139.59 52.81,139.59 v1(53.73,140.51) 53.76,140.54 62.09,140.54 62.34,140.28 65.19,140.28 65.21,140.27 65.31,140.27 65.72,139.86 68.67,139.86 68.71,139.83 68.73,139.83 70.76,137.8 71.31,137.8 71.73,137.38 73.25,137.38 75.26,135.37 76.95,135.37 77.29,135.71 77.29,136.78 78.07,137.55 81.88,137.55 82.65,138.33 86.73,138.33 87.98,137.07 104.48,137.07 104.81,137.4 v1(104.84,137.4) 105.01,137.4 105.69,136.73 112.81,136.73 115.24,134.3 130.07,134.3 131.28,135.51 v1(131.28,135.69) ; v1(49.86,11.79) 51.7,13.63 57.02,13.63 58.9,11.75 94.05,11.75 96.1,13.79 96.1,23.1 93.71,25.49 v1(93.41,25.49) ; v1(84.77,96.04) 84.58,95.85 77.37,95.85 75.45,93.93 74.76,93.93 74.53,93.7 73.36,93.7 72.4,92.75 71.38,92.75 70.19,93.94 64.98,93.94 64.6,94.32 63.81,94.32 63.39,93.9 60.09,93.9 57.85,96.14 56.44,96.14 55.38,95.09 55.37,95.09 55.05,94.77 51.75,94.77 51.43,95.09 45.48,95.09 44.77,94.37 41.63,94.37 v1(41.45,94.55) 40.69,95.31 39.07,95.31 37.3,93.55 36.44,93.55 35.97,93.08 33.06,93.08 32.05,94.08 30.52,94.08 30,93.56 v1(28.88,93.56) ; v1(178.8,60.88) 177.9,61.79 177.7,61.99 v1(171.32,61.99)
  IN3 w0.508: v1(131.02,16.05) 130.89,15.92 119.88,15.92 118.49,17.31 110.95,17.31 110.44,17.82 110.41,17.82 107.63,20.6 107.52,20.6 106.48,21.63 98.79,21.63 94.93,25.49 v1(93.41,25.49) ; v1(209.24,60.19) 208.86,59.8 208.86,55.87 208.21,55.22 208.21,53.37 209.09,52.49 209.09,42.2 v1(209.8,41.49) ; v1(36.8,98.16) 36.8,97.46 38.07,96.19 40.79,96.19 41.45,95.53 v1(41.45,94.55)
  IN4 w0.381: v1(84.77,96.04) 83.3,97.51 83.3,100.51 79.78,104.03 77.25,104.03 v1(76.58,104.7)
  IN4 w0.508: v1(178.88,63.78) 187.01,63.78 187.01,63.78 188.24,63.78 v1(188.86,64.4) 188.92,64.4 189.88,65.35 202.46,65.35 207.69,60.12 209.18,60.12 v1(209.24,60.19) ; v1(178.8,60.88) 179.32,60.36 v1(183.2,60.36)
  BOTTOM w0.381: UC4.5 36.76,96.73 CH100.1
  BOTTOM w0.508: v1(191.62,77.79) R294.1 ; PR937.1 241.21,23.89 241.23,23.91 241.63,23.91 242.86,25.15 v1(242.86,27.06) ; 47.13,123.04 47.28,123.04 47.62,122.7 47.62,120.28 49.21,118.69 49.21,118.3 53.34,114.17 59.12,114.17 65.35,107.94 69.06,107.94 69.92,107.07 69.92,106.49 72.53,103.89 75.8,103.89 76.58,104.66 v1(76.58,104.7) ; 47.13,123.04 v1(46.98,123.04) ; 47.13,123.04 47.83,123.74 47.83,129.63 49.07,130.87 51.79,130.87 v1(51.84,130.92) ; R2192.1 291.08,65.96 290.13,65.96 289.42,65.25 v1(289.42,64.99) ; v1(49.86,11.79) 49.86,10.31 48.11,8.56 30.02,8.56 28.81,9.77 26.49,9.77 25.04,11.21 25.04,14.69 25.27,14.92 26.17,14.92 26.78,14.32 R516.1 27.33,14.32 27.77,13.88 29.97,13.88 31.42,15.33 32.41,15.33 32.99,15.91 32.99,19.5 33.5,20 33.5,35.18 35.41,37.08 35.41,45.53 35.41,45.56 35.06,45.91 33.25,45.91 33.24,45.92 30.58,48.58 30.58,56.96 21.18,66.36 19.02,66.36 16.09,69.29 16.09,72.65 15.87,72.87 15.87,74.3 17.61,76.04 v1(18.24,76.04) ; v1(131.28,135.69) 131.28,136.55 131.74,137.01 v2(131.74,139.34) 131.74,150 130.88,150.85 v1(130.88,151.19) ; R2152.1 48.9,154.77 51.38,152.29 51.38,149.77 52.92,148.23 52.92,148.2 52.83,148.11 52.83,141.63 53.73,140.73 v1(53.73,140.51) ; v1(36.8,98.16) 36.68,98.03 CH100.1 ; v1(15.05,136.31) 14.76,136.6 13.61,136.6 13.34,136.33 R907.1
+3.3V_ALW_PCH: length 361.8
  TOP w0.254: v1(32.93,116.35) 32.93,116.35 33.33,115.94 UH4.AN24 ; v1(23.63,119.37) 23.67,119.33 24.15,119.33 UH4.P32
  TOP w0.279: CH1.1 64.57,111.6 66.06,110.11 JXDP2.43 ; JXDP2.44 66.06,103.98 66.61,104.53 67.27,104.53 v1(67.29,104.56)
  TOP w0.305: v1(67.29,104.56) 66.06,105.79 JXDP2.43
  TOP w0.406: RH201.1 29.66,95.69 26.99,95.69 26.99,95.7 26.31,95.7 RH80.2 ; CC65.1 96.37,84.67 96.37,83.92 96.1,83.64 95.53,83.64 95.24,83.93 UC1.5
  TOP w0.508: RH81.2 19.15,99.92 19.32,99.76 19.32,99.28 18.93,98.9 18.77,98.9 v1(18.64,98.77) ; 80.02,100.2 79.81,99.99 79.81,97.57 77.38,95.15 76.08,95.15 74.03,93.09 74.03,91.45 75.96,89.52 v1(76.4,89.52) ; 80.02,100.2 v1(80.02,100.2) ; 80.02,100.2 80.01,100.2 80.01,100.41 80.72,101.12 84.01,101.12 84.67,100.46 86.62,100.46 95.34,91.74 v1(95.34,90.31) 95.34,90.19 RC6.1 ; R835.2 167.99,155.89 168.03,155.93 v1(168.03,155.98) ; RH80.2 25.23,95.86 24.95,95.58 23.62,95.58 v1(23.16,95.12) ; v1(12.66,109.11) 12.66,109.17 12.77,109.28 RH300.2 ; CC65.1 v1(98.1,84.68) ; CH1.1 64.49,110.95 v1(64.57,110.87) ; RH354.1 15.72,100.17 15.33,99.78 v1(15.33,99.34) ; RH66.1 10.97,129.1 11.3,128.77 v1(11.48,128.77) ; RH287.1 12.58,122.55 v5(12.46,122.43) ; RH301.2 9.1,109.28 v1(9.04,109.22) ; v1(155,125.44) 154.43,126.01 154.43,130.96 151.97,133.43 151.56,133.43 147.04,137.95 v1(147.04,143.26)
  IN1 w0.508: v1(12.53,112.67) 12.61,112.75 12.61,113.28 14.46,115.13 15.26,115.13 15.37,115.02 17.78,115.02 18.45,115.7 18.48,115.7 18.86,116.08 23.77,116.08 24.23,115.62 24.23,115.45 v1(24.29,115.38) ; v1(13.44,100.17) 13.54,100.28 14.72,100.28 15.33,99.67 ; 15.33,99.67 15.33,99.91 15.8,100.38 19,100.38 19.3,100.08 19.3,99.26 18.93,98.9 18.77,98.9 v1(18.64,98.77) ; 15.33,99.67 v1(15.33,99.34) ; v1(180.72,144.82) 181.1,145.2 181.1,149.94 180.72,150.32 180.72,153.62 179.27,155.07 v1(179.27,155.52) ; v1(147.25,151.26) 147.66,150.85 152.08,150.85 154.74,153.51 157.38,153.51 158.06,154.19 160.64,154.19 161.12,154.67 161.92,154.67 162.95,155.7 166.32,155.7 166.77,155.25 167.35,155.25 168.03,155.93 v1(168.03,155.98) ; v1(6.04,132.78) v1(6.04,129.65)
  IN2 w0.254: 42.37,112.64 42.23,112.64 42.16,112.71 ; 42.16,112.71 41.45,112.71 40.35,113.82 34.16,113.82 33.58,114.4 33.58,115.65 33.89,115.33 33.89,115.15 34.19,114.86 40.16,114.86 41.92,113.09 41.92,112.95 42.16,112.71
  IN2 w0.508: v1(18.64,98.77) 19.05,98.36 19.05,98.13 21.25,95.94 22.48,95.94 23.16,95.25 v1(23.16,95.12) ; v1(67.29,104.56) 69.74,102.11 78.12,102.11 v1(80.02,100.2) ; v5(12.46,122.43) 13.16,122.43 14.37,121.21 17.71,121.21 18.63,120.29 22.92,120.29 23.62,119.6 23.62,119.38 v1(23.63,119.37) ; 33.58,115.65 33.58,115.89 33.12,116.35 v1(32.93,116.35) ; v1(64.57,110.87) 61.9,113.54 52.7,113.54 52.3,113.14 51.02,113.14 50.63,113.54 49.35,113.54 48.54,114.35 46.21,114.35 45.69,113.83 43.56,113.83 42.37,112.64
  IN3 w0.508: v1(6.04,129.65) 7.1,128.6 10.65,128.6 11.15,128.11 v1(11.44,128.11)
  IN4 w0.508: v1(168.03,155.98) 168.03,156.05 169.04,157.05 169.96,157.05 170.57,156.44 178.36,156.44 v1(179.27,155.52) ; v1(124.52,99.71) 124.19,99.38 108.53,99.38 106.9,97.74 98.7,97.74 95.34,94.38 v1(95.34,90.31)
  BOTTOM w0.508: R928.1 7.14,133.55 7.14,133.17 6.74,132.78 v1(6.04,132.78) ; v1(23.63,119.37) 23.63,119.67 22.99,120.31 CH91.1 ; v1(180.72,144.82) 180.72,145.26 180.73,145.27 R1622.2 ; RH54.2 23.63,95.52 23.24,95.12 v1(23.16,95.12) ; v1(124.52,99.71) 125.41,98.82 129.58,98.82 133.16,102.4 152.37,102.4 153.88,103.91 153.88,117.78 152.97,118.69 152.97,124.27 154.14,125.44 v1(155,125.44) ; RC3.1 75.84,89 76.36,89.52 v1(76.4,89.52) ; v1(147.25,151.26) 147.25,143.47 v1(147.04,143.26) ; v1(95.34,90.31) 95.34,87.45 98.1,84.69 v1(98.1,84.68)
  vias: v1(6.68,108.38) v1(7.19,119.24) v1(7.31,118.61) v1(9.85,121.64) v1(10.09,118.09) v1(11.39,106.88) v1(23.65,114.36) v1(24.29,114.35) v1(25.68,115.54) v4(7.59,109.16)
+3.3V_ALW_PCH_JTAG: length 22
  TOP w0.508: v1(9.45,96.6) 10.11,96.6 10.46,96.24 12.11,96.24 13.55,94.81 v1(13.92,94.81) v2(13.92,96.15) 13.92,96.58 13.21,97.3 13.21,98.77 13.77,99.33 v1(14.69,99.33) ; v1(15.92,98.46) 16.15,98.69 16.15,98.74 16.61,99.2 16.61,99.61 16.74,99.73 16.74,99.76 17.12,100.14 RH43.2
  IN4 w0.508: v1(15.92,98.46) 15.95,98.49 15.95,98.5 16.61,99.16 16.61,99.86 16.34,100.13 15.19,100.13 14.69,99.63 v1(14.69,99.33)
  BOTTOM w0.508: v1(13.92,94.81) 13.84,94.81 13.05,95.59 RH45.2 ; RH44.2 15.09,100.17 14.69,99.77 v1(14.69,99.33) ; RH288.2 10.06,95.4 9.45,96.01 v1(9.45,96.6)
+3.3V_ALW_U46: length 61.4
  TOP w0.508: v1(237.84,64.45) 237.77,64.45 237.44,64.79 237.44,66.21 v2(238.27,67.05) 238.83,67.6 v1(238.83,68.31) ; v1(239.11,79.67) 239.84,80.39 242.45,80.39 243.6,81.53 245.97,81.53 v1(246.62,80.89)
  IN2 w0.508: v1(238.83,68.31) 238.13,67.62 232.83,67.62 231.81,68.63 230.87,68.63 230.64,68.41 v1(230.64,68.32)
  IN3 w0.508: v1(239.11,79.67) 239.12,79.66 241.24,79.66 241.97,78.93 243.36,78.93 244.74,77.55 244.74,74.2 244.52,73.98 243.57,73.98 v1(243.04,73.45) 242.11,72.52 242.11,67.95 241.47,67.31 239.76,67.31 238.83,68.25 v1(238.83,68.31)
  IN4 w0.508: v1(232.93,74.2) 232.25,73.52 232.25,69.93 v1(230.64,68.32)
  BOTTOM w0.279: U46.A43 238.08,78.07 238.57,78.56 238.57,79.85 238.56,79.86 239.06,80.36 C710.1 ; v1(230.64,68.32) 230.77,68.45 U46.A17 ; v1(243.04,73.45) U46.A54
  BOTTOM w0.33: v1(238.83,68.31) U46.B5 ; v1(232.93,74.2) U46.B30
  BOTTOM w0.508: C710.1 v1(239.11,79.67) ; v1(237.84,64.45) C709.1 ; C718.1 C717.1 C719.1 C708.1
+3.3V_ALW_U54: length 74.7
  TOP w0.254: v1(163.65,150) 163.54,150 163.13,150.41 162.75,150.41 162.47,150.13 U54.B3
  TOP w0.279: v1(167.64,140.9) 167.47,141.07 U54.A26 ; U54.A41 173.41,147.38 v1(173.48,147.45) ; U54.A22 165.47,141.3 164.95,140.77 164.95,140.76 v1(164.95,140.75) ; v1(165.9,153.38) 165.97,153.3 U54.A58 ; v1(160.54,145.62) 160.8,145.88 U54.A11
  TOP w0.305: v1(169.38,153.61) 169.38,153.38 168.97,152.97 U54.A52
  TOP w0.33: U54.B35 171.5,143.13 171.82,142.81 v1(171.82,142.48)
  TOP w0.508: C728.1 173.33,137.38 173.02,137.07 v1(172.31,137.07) C729.1 ; C738.1 177.39,137.4 177.08,137.09 v1(176.59,137.09) 176.38,137.31 C739.1 ; v1(179.54,137.74) 179.07,137.27 C730.1 ; C731.1 174.34,137.22 v1(174.22,137.1) 174.27,137.05 175.12,137.05 175.36,137.29 C726.1
  IN1 w0.457: v1(163.65,150) 163.46,150 163.05,150.41 162.39,150.41 162.06,150.74 162.06,151.71 164.44,154.09 165.62,154.09 165.9,153.81 v1(165.9,153.38)
  IN1 w0.508: v1(163.65,150) 164.44,149.21 164.44,144.88 164.78,144.54 164.78,140.92 v1(164.95,140.75)
  IN2 w0.508: v1(169.38,153.61) 169.19,153.42 168.62,153.42 168.03,154 166.11,154 165.9,153.78 v1(165.9,153.38)
  IN4 w0.508: 171.09,141.76 170.97,141.63 168.37,141.63 v1(167.64,140.9) 166.92,141.62 166.27,141.62 165.4,140.75 v1(164.95,140.75) 164.95,141.14 163.14,142.94 162.6,142.94 162.23,143.31 162.23,144.13 160.74,145.62 v1(160.54,145.62) ; 171.09,141.76 171.09,141.36 171.31,141.15 v1(171.31,140.02) ; 171.09,141.76 v1(171.82,142.48) 171.82,145.03 173.48,146.7 v1(173.48,147.45) ; v1(172.31,137.07) 172.34,137.1 v1(174.22,137.1) 174.22,137.09 v1(176.59,137.09) 178.89,137.09 v1(179.54,137.74)
  BOTTOM w0.508: v1(171.33,139.36) v2(172.31,138.38) v1(172.31,137.07) ; v1(171.82,142.48) 171.33,142.97 C732.1 ; C727.1 164.39,149.14 163.65,149.87 v1(163.65,150)
+3.3V_ALWP: length 84.9
  IN1 w0.254: v1(290.93,33.97) 291.18,34.23 291.18,53.57 290.63,54.13 289.56,54.13 288.97,54.71 286.04,54.71 284.8,55.96 284.8,62.76 284.25,63.31 279.63,63.31 279.12,62.8 v1(279.12,61.91) ; v1(291.69,33.97) 291.69,53.82 290.99,54.52 289.83,54.52 289.15,55.19 286.41,55.19 285.22,56.39 285.22,62.97 284.49,63.69 v1(278.2,63.69)
  BOTTOM w0.254: v1(279.12,61.91) 278.72,61.51 PU101.7
  BOTTOM w0.508: v1(278.2,63.69) PR101.1 PC120.2
  vias: v2(293.66,31.45)
+3.3V_ALWPCH_CHG: length 2.6
  BOTTOM w0.102: R928.2 8.09,134.32 v2(8.42,134.65)
  BOTTOM w0.508: Q66.1 8.46,133.92 R928.2
+3.3V_LAN: length 204.7
  TOP w0.254: v1(121.03,146.04) 121.13,146.04 121.3,145.87 U32.14 ; v1(126.3,145.95) U32.4 ; C474.1 118.29,141.27 118.62,141.59 118.62,142.38 118.81,142.57 U32.21 ; U32.8 v1(124.3,145.95) ; U32.30 123.8,141.01 123.89,140.92 123.89,140.27 123.67,140.06 123.67,139.73 123.77,139.63 C473.1 ; C472.1 128.83,142.57 U32.39 ; v1(127.8,145.96) U32.1
  TOP w0.381: U15.5 132.1,156.16 v1(132.17,156.1)
  TOP w0.508: v1(131.04,162.46) 130.44,161.86 R545.1 ; R554.1 R553.1 v1(116.84,167.2) ; RH305.2 13.18,103.19 11.95,104.42 v1(11.95,105.37) ; v1(122.64,138.38) 123.11,138.38 123.77,139.03 C473.1 ; R546.1 131,163.13 v1(131.04,163.09) ; JLOM1.12 82.45,164.85 80.99,163.39 C1167.1 ; C472.1 130.01,141.62 v1(130.01,142.62) ; v1(132.17,156.1) 132.8,156.1 C478.1 ; R549.1 v1(116.95,164.15) ; v1(117.41,141.9) 117.66,141.9 117.93,141.63 C474.1
  IN1 w0.508: v1(130.01,142.62) 130.21,142.82 130.96,142.82 130.99,142.85 v1(131.09,142.85) 131.09,146 v1(131,146.09) 127.93,146.09 v1(127.8,145.96)
  IN2 w0.508: v1(11.95,105.37) 10.54,103.96 8.49,103.96 8.13,104.33 8.13,104.78 7.42,105.48 6.7,105.48 5.19,106.99 5.19,109.38 4.47,110.11 4.47,112.23 3.72,112.98 3.72,113.01 3.71,113.02 3.71,120.22 3.15,120.78 3.15,121.31 3.95,122.11 3.95,128.54 4.2,128.79 4.2,134.07 v1(4.33,134.2) ; v1(122.64,138.38) 121.27,138.38 120.56,137.67 119.42,137.67 118.31,138.77 118.31,141 v1(117.41,141.9)
  IN3 w0.508: v3(5.48,167.63) 7.52,165.6 7.52,161.56 1.28,155.32 1.28,134.32 1.65,133.95 4.08,133.95 v1(4.33,134.2)
  IN4 w0.508: JLOM1.12 82.62,164.85 81.51,163.74 80.19,163.74 79.34,164.59 58.04,164.59 55.8,166.83 50.24,166.83 49.43,166.01 36.46,166.01 35.84,165.39 19.68,165.39 17.45,167.63 v3(5.48,167.63)
  BOTTOM w0.508: v1(11.95,105.37) 13.19,105.37 RH306.2
  vias: v1(93.75,162.32) v1(94.42,162.31) v1(118.01,161.99) v1(118.01,161.35) v1(132.14,156.76)
+3.3V_LAN_OUT: length 22.9
  TOP w0.102: v1(124.26,156.96) v2(124.26,156.34)
  TOP w0.203: U31.15 v1(122.65,156.95) ; U31.4 120.55,161.85 120.13,162.27 v1(119.96,162.27) ; C464.1 129.44,158.89 128.08,160.25 U31.29 ; U31.19 124.25,156.96 v1(124.26,156.96)
  TOP w0.508: C464.1 130.06,157.94 v1(130.15,157.94)
  IN1 w0.508: v1(130.15,157.94) 129.12,156.91 127.48,156.91 126.86,157.53 124.83,157.53 v1(124.26,156.96) 124.24,156.95 v1(122.65,156.95) 121.46,158.14 121.46,160.71 119.96,162.2 v1(119.96,162.27)
+3.3V_M: length 311.5
  TOP w0.508: C768.1 133.4,148.74 134.21,147.93 R563.1 ; C768.1 135.72,149.67 Q58.4 ; C768.1 133.4,150.19 133.16,150.43 R919.1 134.09,150.94 v1(134.34,151.19) ; v1(154.1,119.94) 153.53,119.37 153.53,117.55 154,117.08 154,102.36 153.91,102.27 v1(153.91,100.2) ; R403.1 148.37,155.77 v1(148.86,156.25) ; R395.1 v1(151.66,160.85) ; R398.1 v1(148.83,163.89) ; R389.1 v1(148.82,158.81) ; v1(148.86,156.25) 149.13,156.53 R916.1 ; v1(148.86,156.25) 148.32,156.78 R404.2 ; v1(146.15,167.08) R397.1 ; R396.1 v1(150.94,162.56) ; v1(178.7,152.08) 178.23,152.54 178.23,152.83 R893.1 ; v1(30.95,100.39) 30.95,99.99 30.64,99.68 RH202.1 ; v1(145.08,153.07) 145.08,153.16 144.99,153.26 R385.2 R289.2 142.09,152.62 140.84,151.37 140.84,142.27 140.97,142.14 140.97,140.7 149.34,132.33 v1(149.34,131.81)
  IN2 w0.508: 151.66,161.58 151.66,161.84 v1(150.94,162.56) 149.61,163.89 v1(148.83,163.89) ; 151.66,161.58 153.69,163.61 156.93,163.61 157.69,164.37 174.22,164.37 174.68,163.91 176.49,163.91 177.81,162.58 v1(177.81,161.94) ; 151.66,161.58 v1(151.66,160.85) ; v1(60.43,101.31) 60.26,101.47 46.78,101.47 46.05,100.74 43.03,100.74 42.63,101.13 36.81,101.13 36.64,100.96 33.03,100.96 32.68,100.61 31.16,100.61 v1(30.95,100.39) ; v1(53.99,108.95) 53.99,108.22 53.85,108.09 53.85,107.55 54.37,107.04 60.81,107.04 70.01,97.83 73.13,97.83 73.48,98.18 73.48,98.84 74.72,100.08 78.52,100.08 79.25,99.35 81.98,99.35 82.68,100.05 108.77,100.05 109.57,99.25 122.74,99.25 123.16,98.83 128.67,98.83 131.43,101.59 149.33,101.59 150.71,100.2 v1(153.91,100.2) ; v1(134.34,151.19) 137.98,151.19 138.63,151.84 142.23,151.84 142.48,152.1 144.56,152.1 144.79,152.32 144.79,152.74 145.08,153.04 v1(145.08,153.07)
  IN3 w0.508: v1(151.66,160.85) 150.85,160.85 v1(148.82,158.81) 148.04,158.04 148.04,157.06 v1(148.86,156.25) 147.85,156.25 145.17,153.57 145.17,153.16 v1(145.08,153.07) ; v1(177.81,161.94) 177.81,160.72 178.37,160.16 178.37,155.03 179.31,154.09 179.31,152.63 178.76,152.08 v1(178.7,152.08) ; v1(154.1,119.94) 154.1,120.69 153,121.79 153,129.87 151.66,131.2 149.93,131.2 149.4,131.74 149.4,131.75 v1(149.34,131.81) ; v1(148.83,163.89) 148.64,163.89 146.15,166.38 v1(146.15,167.08) ; v1(53.99,108.95) 53.98,108.95 53.82,108.79 53.82,107.25 54.58,106.49 55.1,106.49 56.49,105.1 56.49,104.18 59.66,101 60.04,101 60.35,101.31 v1(60.43,101.31)
  BOTTOM w0.102: v1(134.34,151.19) 134.34,151.79 v4(134.39,151.84)
  BOTTOM w0.305: JSPI1.12 50.52,109.76 RH350.1
  BOTTOM w0.508: v1(53.99,108.95) 53.99,109.04 52.35,110.68 51.1,110.68 50.68,110.26 RH350.1
+3.3V_M_CHG: length 2.7
  TOP w0.508: R916.2 151.43,155.84 151.66,155.61 v2(151.66,155.08) 151.65,155.08 151.16,154.6 Q60.1
+3.3V_MXM: length 442.3
  TOP w0.381: v1(196.28,88.09) 196.54,87.82 196.54,87.53 196.37,87.35 U27.5 ; v1(167.45,173.32) 167.73,173.32 167.78,173.37 167.78,173.76 167.64,173.9 U59.3 ; PC17.2 159.35,175.47 U60.4
  TOP w0.508: R2185.2 151.38,175.15 151.15,174.92 151.15,173.46 151.47,173.14 v1(151.73,173.14) 151.75,173.11 R2184.2 ; R8.1 R10.1 209.87,156.6 210.05,156.42 Q4.2 210.05,155.18 210.63,154.6 211.61,154.6 212.07,154.13 212.07,148.96 211.78,148.68 210.86,148.68 v1(210.3,148.12) 209.81,148.12 209.5,148.44 Q5.2 209.5,149.85 209.87,150.22 R4.1 ; R38.1 R7.1 ; R7.1 210.38,130.18 209.79,129.59 208.57,129.59 208.09,130.07 207.61,130.07 206.41,131.27 201.51,131.27 201.36,131.42 196.8,131.42 196.18,130.8 v1(196.18,130.32) ; R7.1 210.95,130.37 211.68,131.1 v1(211.73,131.1) ; v1(199.39,84.94) 198.9,85.43 C94.1 ; v1(161.41,171.02) 160.67,171.76 160.67,174.98 160.15,175.49 PC17.2 ; R1121.1 64.96,134.43 v1(64.34,135.05) ; v1(72.5,141.33) 72.48,141.3 72.48,141.17 71.73,140.42 R1122.1 ; v1(148.64,172.02) R268.1 148.64,169.96 148.44,169.76 R401.1 R400.1
  IN2 w0.508: v1(210.11,104.37) 210.11,114.67 v1(209.52,115.27) ; 72.52,126.7 72.52,119.84 75.39,116.97 79.69,116.97 81.04,118.31 91.88,118.31 95.27,114.92 99.85,114.92 103.07,111.7 103.07,110.66 103.05,110.63 v1(103.05,110.59) ; 72.52,126.7 v1(72.52,126.82) ; 72.52,126.7 72.29,126.92 71.79,126.92 70.61,128.11 70.61,130.21 68.31,132.51 68.31,133.42 67,134.74 66.99,134.74 66.98,134.75 66.27,134.75 66.13,134.61 64.78,134.61 v1(64.34,135.05) ; v1(204.39,158.61) 202.13,158.61 196.79,163.94 193.09,163.94 192.06,164.97 175.12,164.97 174.65,165.44 165.23,165.44 161.41,169.26 v1(161.41,171.02) ; v1(148.64,172.02) 149.76,173.14 v1(151.73,173.14) 157.45,173.14 159.57,171.02 v1(161.41,171.02) ; v1(161.41,171.02) 162.22,171.02 164.51,173.32 v1(167.45,173.32) ; v1(200.22,149.65) 200.22,151.17 201.51,152.46 203.41,152.46 204.2,151.68 v1(204.2,150.56)
  IN3 w0.508: v1(210.11,104.37) 210.11,101.96 208.24,100.09 208.24,93.02 206.75,91.53 v1(206.75,91.5) ; v1(148.64,172.02) 146.28,172.02 143.05,175.25 134.29,175.25 130.17,171.13 130.17,165.27 127.1,162.19 127.1,155.54 123.94,152.38 119.87,152.38 119.77,152.48 v1(119.62,152.48)
  IN4 w0.508: v1(204.2,150.56) 204.57,150.56 207.59,153.58 208.84,153.58 209.59,152.83 209.59,148.84 v1(210.3,148.12) 210.73,147.69 210.73,136.64 210.36,136.27 210.36,132.13 211.39,131.1 v1(211.73,131.1) ; v1(199.39,84.94) 198.96,84.94 196.28,87.62 v1(196.28,88.09)
  BOTTOM w0.381: Q295.5 201.13,150.56 v1(200.22,149.65) ; C96.1 214.13,106.2 213.59,105.67 213.59,105.26 213.41,105.08 U14.5 212.4,105.08 211.69,104.37 v1(210.11,104.37) ; v1(204.2,150.56) Q295.2 ; C95.1 210.26,111.65 210.26,109.56 210.07,109.38 U25.5
  BOTTOM w0.508: R1.1 199.9,149.33 v1(200.22,149.65) ; R1.1 199.35,148.53 199.12,148.76 199.12,151.47 199.48,151.83 200.25,151.83 200.54,152.12 R37.1 200.29,152.34 199.78,152.85 199.78,154.29 200.98,155.49 201.85,155.49 204.39,158.03 v1(204.39,158.61) ; R1.1 199.9,147.64 R2.1 ; R9.1 R6.1 209.31,103.57 v1(210.11,104.37) ; v1(196.18,130.32) 195.55,130.32 194.92,129.68 R3.1 R5.1 ; v1(72.5,141.33) 72.26,141.57 70.85,141.57 70.32,141.03 69.81,141.03 69.11,140.34 69.11,139.4 71.05,137.45 72.08,137.45 73.77,135.76 73.77,130.38 73.1,129.71 73.1,127.51 72.52,126.92 v1(72.52,126.82) ; C95.1 209.31,112.6 209.31,115.06 v1(209.52,115.27) 210.21,115.27 211.31,116.37 211.31,130.68 v1(211.73,131.1) ; v1(119.62,152.48) 119.62,149.11 119.3,148.79 119.3,145.33 119.57,145.06 119.57,140.06 121.03,138.6 121.03,136.94 128.4,129.58 128.4,121.25 126.16,119.01 126.16,117.98 117.84,109.67 103.97,109.67 v1(103.05,110.59)
  vias: v1(203.55,83.76) v1(204.32,83.76) v4(203.24,84.63)
+3.3V_PCIE_FLASH: length 10.1
  BOTTOM w0.508: C634.1 203.01,158.84 202.7,158.53 v2(200.32,158.53) 193.62,158.53 193.58,158.57
  vias: v1(170.34,159.36) v1(171.44,162.4) v1(171.97,161.85) v1(186.54,161.99) v1(187.2,161.87) v1(187.83,161.87) v1(188.57,161.94)
+3.3V_PCIE_NVM: length 15.5
  TOP w0.457: v1(33.12,152.01) 33.12,152.09 32.97,152.24 C623.1
  TOP w0.508: R740.1 36.27,146.66 v1(36.78,146.15) ; C621.1 22.96,151.96 v1(22.04,151.04) ; v1(27.76,155.32) 28.03,155.05 C618.1 ; C617.1 27.9,156.1 v1(27.76,155.96)
  BOTTOM w0.508: v1(33.12,152.01) 33.24,151.89 JMINI4.52 33.24,148.58 32.99,148.33 32.99,147.42 33.18,147.23 35.75,147.23 36.78,146.2 v1(36.78,146.15) ; JMINI4.24 v1(22.04,151.04)
  vias: v1(11.9,152.65) v1(11.91,151.97) v1(15.17,153.35) v1(15.19,152.65) v1(20.66,151.16) v2(21.22,150.25)
+3.3V_PCIE_WWAN: length 24.5
  TOP w0.508: v1(109.32,165.33) 109.32,164.66 108.81,164.15 C610.1 ; v1(109.61,153.35) 109.23,152.97 C611.1 R1159.1 ; v1(105.79,155.8) 106.01,156.02 R1160.1 ; v1(109.51,140.17) 108.9,140.78 C614.1 ; R719.2 108.53,160.92 107.92,161.53 106.27,161.53 v1(105.05,162.75) ; C612.1 101.28,161.02 v1(101.73,161.47)
  IN2 w0.508: v1(109.51,140.17) 109.05,140.17 107.8,141.43 v1(105.56,141.43) ; v1(109.61,153.35) 106.21,153.35 105.79,153.77 v1(105.79,154.53)
  BOTTOM w0.508: JMINI1.2 109.04,140.65 v1(109.51,140.17)
  vias: v1(105.15,155.8) v1(105.15,155.17) v1(105.15,154.53) v1(105.79,155.17) v2(94.79,142.3)
+3.3V_RTC_LDO: length 298.5
  TOP w0.508: v1(183.17,83.03) 183.3,83.03 183.74,83.48 195.76,83.48 198.25,80.99 201.61,80.99 202.43,80.18 208.54,80.18 210.94,82.58 213.92,82.58 216.67,85.33 216.67,88.63 218.46,90.42 221.87,90.42 v1(222.2,90.09)
  IN1 w0.508: v1(222.2,90.09) 222.2,88.41 224.5,86.11 230.73,86.11 231.77,85.07 233.42,85.07 234.33,84.16 238.29,84.16 238.84,83.61 240.67,83.61 240.94,83.34 242.48,83.34 242.96,82.86 245.59,82.86 247.32,81.13 247.32,79.5 248.04,78.78 248.04,76.68 250.46,74.27 250.46,69.15 252.03,67.58 269.78,67.58 272.69,64.68 273.49,64.68 275.51,62.65 276.73,62.65 277.33,63.25 277.33,64.03 278.5,65.2 282.15,65.2 v1(282.77,64.59)
  IN2 w0.508: v1(53.83,83.3) 54.43,83.9 54.43,89.71 56.81,92.09 63.12,92.09 63.66,91.54 64.74,91.54 65.19,91.99 66.47,91.99 67.19,91.26 73.39,91.26 74.03,91.9 74.03,92.33 74.56,92.86 74.88,92.86 74.98,92.97 75.77,92.97 76.88,94.08 84.95,94.08 86.88,96.01 108.04,96.01 110.73,93.32 132.98,93.32 134.19,92.11 138.49,92.11 143.53,97.16 148.7,97.16 149.55,96.3 v1(149.55,95.96)
  IN3 w0.508: v1(50.7,94.45) 51.24,94.45 52.44,93.24 53.53,93.24 54.77,92.01 54.77,91.17 53.76,90.16 53.76,83.38 v1(53.83,83.3)
  IN4 w0.508: v1(183.17,83.03) 182.27,83.03 180.8,84.51 174.38,84.51 169.06,89.83 162.43,89.83 159.89,92.37 157.05,92.37 153.12,96.29 151.04,96.29 150.65,96.69 150.28,96.69 v1(149.55,95.96)
  BOTTOM w0.508: PR105.1 v1(282.77,64.59) ; PD1.3 47.08,98.32 47.76,97.64 v4(47.76,97.37) 48.75,96.38 49.4,96.38 50.7,95.09 v1(50.7,94.45)
+3.3V_RUN: length 1125.8
  TOP w0.178: v1(30.62,121.72) 30.67,121.67 30.96,121.67 31.01,121.72 31.59,121.72 31.93,121.38 UH4.AK36
  TOP w0.203: C405.1 37.61,143.37 38.07,143.37 38.62,143.91 U9.41 ; v1(47.23,148.91) 46.97,148.91 46.77,148.71 U9.14 ; C402.1 46.4,140.98 45.93,141.44 45.93,141.69 45.37,142.26 U9.56 ; UH4.T34 UH4.V34 UH4.V33 26.39,119.69 26.45,119.69 v1(26.48,119.66)
  TOP w0.229: C410.1 40.09,151.85 40.09,150.27 40.17,150.19 U9.28
  TOP w0.254: C243.1 75.35,140.84 75.35,141.78 74.74,142.39 JLVDS1.16 ; v1(28.07,112.34) 27.69,111.97 UH4.AA16 UH4.W16 ; v1(8.71,106.91) 8.71,106.91 8.71,106.93 8.39,107.25 QH5.5 7.88,107.23 6.03,107.23 QH5.2 ; U13.35 62.25,136.69 62.56,136.39 62.56,136.02 62.86,135.71 63.87,135.71 C1159.1 ; U11.35 75.59,135.42 C1146.1 ; 42.14,118.68 42.02,118.68 41.67,118.33 UH4.BH29 ; v1(32.13,101.93) 32.29,102.1 32.29,103.7 31.65,104.34 UH4.AJ2
  TOP w0.305: C392.1 128.95,103.05 128.24,103.05 ; 128.24,103.05 127.74,102.55 U88.7 ; 128.24,103.05 U88.8 ; C391.1 122.93,103.05 U88.14 ; U88.1 124.83,100.33 v1(124.99,100.17)
  TOP w0.356: RH138.1 19.26,97.17 UC3.5 ; JDIMM1.199 144.86,82.3 v1(144.94,82.22) ; JDIMM3.199 v1(158.91,82.3) ; C93.1 43.18,167.28 42.75,167.71 U627.5
  TOP w0.381: C91.1 212.53,156.77 212.33,156.97 U8.5 ; U20.14 112.96,152.79 112.88,152.87 C359.1 ; v1(15.59,135.22) 16.37,135.22 16.73,134.86 18.5,134.86 v1(18.65,134.71) ; UH3.5 6.18,103.3 5.94,103.06 5.94,102.5 6.27,102.17 CH102.1 ; U3.5 79.71,135.13 79.98,135.4 v1(80.29,135.4)
  TOP w0.508: v1(63.57,148.64) 63.57,149.15 61.2,151.52 61.2,152.03 61.05,152.18 C244.1 ; v1(46.56,141.75) 46.58,141.72 C402.1 ; R64.1 37.34,140.17 36.92,140.59 v1(36.92,141.15) ; v1(32.13,101.93) 32.61,101.45 CH76.1 ; RH179.2 RH331.1 12.89,126.56 v1(12.62,126.29) ; v1(22.36,99.33) 22.2,99.49 RH137.1 ; R405.1 v1(148.82,157.8) ; RH138.1 18.13,97.06 CH99.1 18.1,97.39 18.32,97.61 v1(18.32,98.11) ; v1(125.83,107.99) R503.1 ; R408.1 151.6,157.8 v1(151.64,157.84) ; v1(151.88,84.15) 151.88,84.16 150.32,85.73 147.43,85.73 146.43,86.72 v1(146.43,91.12) ; v1(65.1,140.92) 65.07,140.89 65.07,139.37 63.89,138.18 C1149.1 63.88,136.72 63.88,135.7 C1159.1 63.68,135.49 63.68,134.53 64.01,134.19 R1123.1 ; R513.1 184.79,54.17 v1(185.01,53.95) ; v1(122.08,96.33) 122.08,102.79 122.32,103.03 C391.1 122.91,103.67 123.54,104.31 v1(123.54,105.07) ; v1(113.52,138.69) 113.51,138.69 113.51,138.67 113.26,138.67 112.57,137.99 R1530.1 ; JUSH1.13 116.82,30.8 116.4,31.23 C52.1 115.9,31.03 115.39,30.52 113.93,30.52 113.51,30.94 v1(113.51,31.47) ; RH268.1 22.71,95.64 22.49,95.43 v1(22.49,95.01) ; v1(21.14,99.38) 21.18,99.42 RH267.2 ; v1(50.32,26.1) 49.17,24.96 49.17,24.87 47.19,22.89 47.19,8.62 47.2,8.61 ; R340.1 45.8,164.28 R341.1 45.22,164.7 44.51,164 43.23,164 v1(43.18,163.94) C93.1 ; v1(6.44,113.81) 6.44,113.83 6.28,113.98 C301.1 ; C410.1 39.51,151.99 v1(39.23,152.27) 38.91,151.94 R72.1 ; v1(26.06,99.33) 26.2,99.47 26.2,99.64 26.26,99.71 RH266.2 RH272.1 ; v1(74.65,141.12) 74.73,141.05 R159.1 74.84,140.23 C243.1 ; v1(49.35,141.14) 49.35,141.19 49.38,141.16 49.38,140.54 48.82,139.99 R68.1 ; R1197.2 160.88,139.42 v1(161.44,139.98) ; v1(124.99,100.17) 125.18,99.97 125.18,99.3 124.97,99.09 R502.1 ; v1(71.23,140.93) 71.23,140.82 70.71,140.3 R1124.1 ; RH256.2 12.74,124.52 12.66,124.6 v1(12.66,124.63) ; RD27.2 v1(165.42,77.88) ; R547.1 v1(120.75,167.92) ; 42.14,118.68 42.26,118.81 43.46,118.81 v1(44.25,119.6) 44.33,119.69 44.55,119.69 44.89,120.03 44.89,121.06 CH51.1 ; v1(15.59,135.22) 14.82,135.22 14.22,135.81 v1(12.57,135.81) ; CH102.1 6.48,102.34 6.96,102.82 7.3,102.82 v1(7.3,102.82) ; JCAM1.4 2.59,126.2 2.75,126.04 v1(2.77,126.04) ; C392.1 129.13,103.04 129.61,102.56 R501.1 129.61,100.98 v1(129.22,100.59) ; v1(147.38,93.64) 147.97,93.05 148.77,93.05 149.39,93.68 v1(149.39,93.76) ; RH52.2 23.33,100.06 v1(23.33,99.47) ; PR736.1 31.54,73.49 v1(32,73.03) ; RH164.1 13.34,128.17 12.93,128.59 v1(12.67,128.59) ; R407.1 v1(148.82,159.83) ; JCAM1.2 2.56,125.2 2.65,125.11 v1(2.77,125.11) ; v1(126.21,89.5) 126.29,89.5 126.3,89.51 126.84,89.51 RD9.2 RD8.2 126.88,84.16 127.83,83.21 CD21.1 127.81,82.34 CD22.1 127.81,80.31 v1(127.59,80.09) ; R1539.1 115.43,143.79 115.64,144.01 v1(115.64,144.26) ; v1(159.1,140.27) 158.48,140.89 158.48,144.13 159.22,144.87 159.22,145.62 v1(159.23,145.63) ; C405.1 37.15,143.98 36.49,144.64 v1(36.49,144.63) ; v1(211.37,156.33) 212,156.33 212.25,156.08 C91.1 ; v1(12.7,120.21) 13.05,120.21 13.4,120.56 RH355.2 ; C359.1 114.08,153.51 114.48,153.91 v1(114.48,154.15) ; v1(81.75,129.34) 81.73,129.32 C248.1 ; C1146.1 C1145.1 v1(76.59,136.16) ; v1(294.49,108.01) 294.56,107.94 JBT1.9 ; v1(160.87,79.02) CD65.1 161.99,79.02 162.47,78.55 CD66.1 v1(162.96,77.74) ; R339.1 47.92,152.15 47.51,151.74 C766.1 46.25,151.33 46.25,150.06 47.23,149.09 v1(47.23,148.91) ; RD26.2 v1(166.1,80.07) ; v1(208.16,136.49) 208.9,136.49 R36.1 ; v1(27.43,99) 27.65,99 28.33,99.68 RH204.1
  TOP w2.032: 38.25,8.61 78.12,8.61 82.17,12.66 82.17,21.02 78.95,24.23 78.95,29.46
  IN1 w0.508: v1(81.75,129.34) 81.23,129.34 80.78,129.78 80.78,133.17 79.64,134.32 79.64,135.15 79.88,135.4 v1(80.29,135.4) ; v1(166.29,107.18) 166.29,105.04 161.5,100.25 161.5,84.18 161.97,83.71 164.96,83.71 166.1,82.56 v1(166.1,80.07) ; v1(160.87,79.02) 160.87,79.33 158.91,81.3 v1(158.91,82.3) ; v1(2.77,126.04) 2.77,126.02 2.79,126 2.79,125.13 v1(2.77,125.11) ; v1(159.19,151.63) 158.93,151.36 158.93,145.99 159.23,145.68 v1(159.23,145.63) ; v1(236.83,81.99) 236.87,81.95 238.21,81.95 238.49,81.67 240.56,81.67 240.92,81.32 243.29,81.32 243.49,81.52 244.42,81.52 245.31,80.63 245.31,76.81 v1(246.59,75.53) ; v1(6.44,113.81) 6.41,113.78 6.27,113.78 5.57,113.08 5.57,108.12 6.51,107.18 8.33,107.18 8.6,106.91 v1(8.71,106.91) ; v1(147.38,93.64) 146.43,92.69 v1(146.43,91.12) ; v1(58.6,81.43) 58.55,81.38 58.55,78.59 58.09,78.13 58.09,77.19 58.55,76.73 58.55,70.7 56.98,69.14 56.98,67.65 56.21,66.88 56.21,49.21 57.31,48.11 57.31,45.26 58.27,44.31 58.27,43.27 61.91,39.62 61.91,36.72 v1(63.38,35.24)
  IN2 w0.254: v1(44.25,119.6) 44.14,119.7 44.14,120.7 43.65,121.2 41.07,121.2 40.69,120.82 35.46,120.82 34.56,121.72 v1(30.62,121.72)
  IN2 w0.381: 22.05,133.78 22.05,133.67 22.19,133.54 22.19,133.06 21.76,132.64 19.94,132.64 19.48,133.1 19.48,133.85 18.67,134.66 18.67,134.7 v1(18.65,134.71) ; v1(26.48,119.66) 26.48,119.69 26.41,119.75 26.41,120.46 26.99,121.03 29.12,121.03 29.84,121.76 30.58,121.76 v1(30.62,121.72) ; 21.88,133.95 22.16,134.23 22.16,137.27 22.13,137.29 22.13,137.78 22.67,138.32 24.84,138.32 v1(24.89,138.37)
  IN2 w0.508: v1(58.6,81.43) 62.53,85.37 67.37,85.37 67.73,85.72 v1(67.73,86.4) 67.73,86.45 67.26,86.92 67.26,87.67 68.03,88.44 69.37,88.44 69.89,88.96 73.53,88.96 76.27,86.22 v1(77.23,86.22) ; v1(21.64,133.95) 21.88,133.95 22.05,133.78 ; v1(159.19,151.63) 159.85,151.63 160.58,150.9 160.96,150.9 161.63,151.58 161.94,151.58 162.47,152.11 170.88,152.11 171.45,151.54 172.9,151.54 173.34,151.98 175.35,151.98 175.87,151.46 177.29,151.46 v1(177.44,151.31) ; v1(196.44,52.64) 195.69,53.39 193.63,53.39 192.86,54.17 185.23,54.17 v1(185.01,53.95) ; v1(185.06,108.04) 183.59,109.51 183.59,114.35 183.1,114.84 180.23,114.84 177.42,117.65 v1(177.42,118.54)
  IN3 w0.508: v1(10.22,127.28) 10.22,126.94 9.97,126.68 6.73,126.68 6.02,127.39 4.76,127.39 3.34,125.97 2.83,125.97 v1(2.77,126.04) ; v1(39.23,152.27) 39.75,151.74 42.82,151.74 42.91,151.65 44.49,151.65 v1(47.23,148.91) 48.35,147.79 48.35,146.55 48.26,146.46 48.26,145.71 ; v1(39.23,152.27) 39.23,152.24 36.14,149.15 36.14,145.09 36.49,144.74 v1(36.49,144.63) ; v1(39.23,152.27) 39.23,152.97 41.54,155.28 44.79,155.28 v1(46.62,157.11) ; 48.26,145.71 48.26,144.12 49.35,143.03 v1(49.35,141.14) ; 48.26,145.71 51.07,145.71 v1(51.8,144.97) ; v1(63.38,35.24) 62.81,34.67 62.81,29.53 61.96,28.68 56.01,28.68 54.84,27.51 53.07,27.51 51.66,26.1 v1(50.32,26.1) 49.17,24.96 49.17,23.46 50.44,22.19 58.32,22.19 v1(58.72,21.78) ; v1(30.62,121.72) 30.54,121.8 30.32,121.8 29.97,122.16 29.97,122.51 29.93,122.54 29.93,126.24 31.63,127.94 35.04,127.94 35.51,128.41 35.51,130.65 v1(35.83,130.96)
  IN3 w1.016: 289.41,100.65 288.92,100.17 288.92,95.7 287.21,93.98 287.21,83.03 v1(288.14,82.11) 288.14,76.65 v1(288.26,76.52) ; 289.03,134.18 289.03,132.53 290.17,131.38 290.17,110.94 289.03,109.79 289.03,103.7
  IN4 w0.508: v1(158.91,82.3) 158.52,82.69 153.81,82.69 152.35,84.15 v1(151.88,84.15) 151.82,84.09 151.82,83.66 150.38,82.22 v1(144.94,82.22) 143.72,83.44 136.24,83.44 135.21,82.4 132.99,82.4 v1(132.97,82.37) 132.95,82.37 130.66,80.09 v1(127.59,80.09) ; v1(103.63,24.02) 102.34,24.02 96.32,30.04 89.64,30.04 87.6,28 82.05,28 v1(80.45,29.6) ; v1(211.37,156.33) 210.22,156.33 210.03,156.13 210.03,155.75 209.71,155.44 209.13,155.44 208.27,156.3 208.27,156.85 207.68,157.43 206.45,157.43 205.36,158.52 205.36,162.09 205.01,162.43 201.45,162.43 197.55,158.53 193.86,158.53 193.37,158.04 190.88,158.04 v1(190.02,158.9) ; v1(162.96,77.74) 162.96,78.18 163.44,78.65 164.66,78.65 v1(165.42,77.88) ; v1(36.92,141.15) 36.92,132.56 35.83,131.47 v1(35.83,130.96)
  BOTTOM w0.203: C1181.1 63.57,150.13 63.37,150.33 U19.11
  BOTTOM w0.254: v1(289.15,73.34) 289.09,73.41 288.19,73.41 288.05,73.54 U22.32 ; U22.36 287.7,71.54 v1(288.03,71.21) ; U22.25 287.74,77.04 v1(288.26,76.52) ; U22.1 279.48,71.54 279.09,71.16 279.09,70.47 279.25,70.32 C497.1 ; U22.12 279.21,77.04 278.8,76.63 277.94,76.63 ; v1(279.39,74.04) U22.6
  BOTTOM w0.356: JDIMM2.199 133.04,82.3 v1(132.97,82.37) ; v1(151.88,84.15) 150.75,83.02 150.75,82.76 150.29,82.3 JDIMM4.199
  BOTTOM w0.457: v1(74.65,141.12) 74.92,141.12 75.22,141.43 75.22,142.04 74.86,142.39 74.06,142.39 R160.1
  BOTTOM w0.508: 21.55,103.06 21.55,100.54 RH267.2 21.18,99.42 v1(21.14,99.38) ; 21.55,103.06 21.46,102.97 RH275.1 ; 21.55,103.06 21.55,104.54 RH203.2 ; C722.1 35.9,11.83 36.55,11.18 40.07,11.18 v1(40.61,11.72) ; v1(278.56,67.11) 278.56,67.98 279.06,68.48 C497.1 ; v1(226.46,70.92) 226.46,70.6 226.82,70.24 R782.2 R780.2 R777.2 ; v1(161.44,139.98) 160.23,139.98 159.94,140.27 v1(159.1,140.27) R799.1 ; PR301.1 v1(103.63,24.02) 103.63,26.44 105,27.81 112.06,27.81 113.51,29.26 v1(113.51,31.47) ; RH173.2 18.13,99.96 17.88,99.71 v1(17.88,98.64) ; v1(208.94,81.47) 208.65,81.19 R92.2 208.29,80.24 C420.1 208.36,80.28 209.19,80.28 209.39,80.48 R83.2 R42.1 ; v1(214.21,87.92) 214.61,88.32 C419.1 214.9,87.35 R93.2 ; R457.1 238.86,58.27 v1(238.95,58.18) ; C1181.1 v1(63.57,148.64) ; v1(286.04,66.78) 286.36,67.09 R78.1 ; Q24.3 4.65,135.12 6.49,136.96 v1(7.16,136.96) ; R1118.2 158.74,145.35 159.02,145.63 v1(159.23,145.63) ; RH35.2 24.23,100.04 23.66,99.47 v1(23.33,99.47) ; R85.2 218.94,84.07 218.51,83.64 217.56,83.64 v1(217.38,83.82) 217.07,84.14 R46.1 ; v1(124.99,100.17) 125.59,100.76 125.59,103.42 ; v1(208.16,136.49) 209.84,136.49 212.27,138.91 212.27,155.88 211.82,156.33 v1(211.37,156.33) ; RH325.1 RH326.1 ; RH326.1 RH178.2 RH163.1 ; RH326.1 12.69,124.6 v1(12.66,124.63) ; R421.1 66.87,156.45 66.14,157.18 66.14,157.43 65.35,158.22 v1(64.48,158.22) ; v1(2.77,126.04) 2.4,126.04 2.17,126.27 C310.1 ; R787.1 245.71,75.53 v1(246.59,75.53) 246.8,75.73 R772.1 ; 277.94,76.63 C496.1 277.94,76.89 278.28,77.23 v1(278.59,77.23) ; 125.59,103.42 124.76,103.42 123.54,104.64 v1(123.54,105.07) 123.54,105.27 125.83,107.56 v1(125.83,107.99) ; 125.59,103.42 128.38,103.42 129.22,102.58 v1(129.22,100.59) ; v1(26.06,99.33) 26.26,99.53 RH266.2 ; v1(288.14,82.11) 287.79,81.76 R56.1 ; R70.1 49.85,146.1 50.24,145.71 51.1,145.71 51.8,145.01 v1(51.8,144.97) ; v1(162.96,77.74) CD88.1 162.96,78.92 163.25,79.2 165.23,79.2 v1(166.1,80.07) ; v1(122.08,96.33) 122.15,96.33 126.21,92.27 v1(126.21,89.5) ; v1(15.59,135.22) 15.56,135.18 15.56,134.31 15.56,133.74 15.72,133.57 RH332.1 RH340.1 RH327.1 ; RH215.1 35.23,129.38 35.83,129.97 v1(35.83,130.96) ; v1(21.64,133.95) 21.89,133.95 22.29,133.55 22.29,133.29 22.71,132.87 RH317.1 ; CH75.1 25.17,120.29 CH43.1 26.01,120.28 26.48,119.81 v1(26.48,119.66) ; v1(177.42,118.54) 177.42,116.93 175.11,114.62 175.11,110.02 v1(174.75,109.67) 174.34,110.07 174.34,111.02 173.66,111.71 168.53,111.71 166.17,109.35 166.17,107.32 166.29,107.19 v1(166.29,107.18) ; C404.1 C403.1 196.79,52.29 v1(196.44,52.64) ; R1165.2 34.01,163.67 34.71,162.98 34.71,159.26 v1(34.48,159.03) ; R415.1 v1(290.42,66.61) ; v1(115.64,144.26) 116.41,145.02 116.41,147.84 115.94,148.31 114.62,148.31 114.18,148.74 114.18,149.45 113.97,149.67 113.97,151.32 114.48,151.83 v1(114.48,154.15) 114.48,155.14 114.77,155.44 116.5,155.44 116.74,155.19 117.24,155.19 117.82,155.77 117.82,158.03 116.11,159.73 115.63,159.73 113.63,161.74 113.63,164.44 115,165.81 115,168.11 115.96,169.08 119.59,169.08 v1(120.75,167.92) ; RH324.1 v1(12.67,128.59) ; v1(28.07,112.34) 27.99,112.42 CH72.1 ; v1(236.83,81.99) 236.83,81.94 236.57,81.69 R788.1 ; R829.2 R822.2 176.97,151.31 v1(177.44,151.31) ; PR501.1 v1(58.72,21.78) ; R65.1 46.21,150.06 R71.1 46.36,150.04 47.23,149.17 v1(47.23,148.91) ; R76.1 R80.1 v1(275.96,70.55) ; R39.1 205.46,83.67 205.61,83.82 v1(205.61,83.87) 205.88,84.14 R41.1 R40.1 ; v1(39.23,152.27) 40.95,153.99 42.48,153.99 43.06,154.57 43.06,155.66 43.56,156.16 R2157.1 ; v1(294.49,108.01) C748.1 294.2,109.06 293.72,109.54 293.72,110.94 293.85,111.06 293.85,111.07 294.28,111.5 301.32,111.5 301.82,111 R1134.1 R1133.1 ; RD35.2 146.91,93.32 147.2,93.61 147.36,93.61 v1(147.38,93.64) ; RH316.2 RH330.1 19.66,134.25 19.21,134.7 18.67,134.7 v1(18.65,134.71) ; v1(22.36,99.33) 22.2,99.49 RH137.1 ; RH28.2 RH181.2 RH263.1 24.65,95.31 25.72,94.25 29.65,94.25 30.01,94.6 RH276.1 30.75,94.44 31.88,94.44 32.26,94.82 32.26,95.19 32.15,95.29 v1(32.15,95.33) ; v1(43.18,163.94) 43.18,160.92 46.62,157.48 v1(46.62,157.11) R2151.1 47.5,156.01 47.91,156.43 48.58,156.43 49.19,155.82 R2154.1 50.07,154.54 v4(50.81,153.8) 51.41,153.2 R2161.1 ; R518.1 40.75,137.26 36.92,141.08 v1(36.92,141.15) 36.92,144.2 v1(36.49,144.63) ; RD36.2 149.71,93.45 v1(149.39,93.76) ; v1(77.23,86.22) 77.18,86.27 RC30.2 ; R409.1 v1(219.71,88.66) ; PR514.2 52.03,26.96 51.17,26.1 v1(50.32,26.1) 49.37,26.1 PR602.1 ; RH87.1 27.24,100.13 27.24,99.19 v1(27.43,99) ; R84.2 v1(209.59,88.13) ; v1(160.87,79.02) 160.91,78.99 CD87.1 ; v1(232.26,62.17) R766.1 ; RH329.1 RH328.1 10.29,127.21 v1(10.22,127.28) ; v1(159.19,151.63) R1177.2 ; v1(32.13,101.93) 32.13,101.66 31.59,101.12 RH30.2 ; CD44.1 CD43.1 130.88,80.25 130.67,80.46 129.36,80.46 128.99,80.09 v1(127.59,80.09) 127.51,80.01 RD18.2 126.19,78.8 125.82,78.44 125.82,76.59 126.4,76.01 RD17.2 ; v1(292.03,67.7) 292.95,67.7 293.63,67.02 R2190.1 ; v1(24.89,138.37) 24.89,138.35 25.73,137.52 26.31,137.52 26.8,137.03 LH1.1 ; RH331.1 12.89,126.56 v1(12.62,126.29) ; R2191.1 292.62,61.86 292.62,61.23 v1(292.62,61.23) ; C437.1 45.74,142.75 46.53,141.96 46.53,141.77 v1(46.56,141.75) 46.58,141.72 46.58,141.47 46.95,141.1 49.31,141.1 v1(49.35,141.14) 49.35,141.19 49.38,141.21 49.38,141.25 49.09,141.54 R58.1
  vias: v1(10.41,122.37) v1(22.43,69.25) v1(22.45,68.56) v1(23.06,69.25) v1(23.09,68.56) v1(41.32,11.86) v1(41.97,11.86) v1(42.61,11.88) v1(237.13,58.24) v1(238.21,58.2) v1(253.1,68.43) v1(263.32,66.32) v1(286.1,52.9) v1(286.1,51.88) v1(287.25,52.9) v1(287.25,51.88) v1(287.88,134.94) v1(287.88,134.24) v1(288.26,52.9) v1(288.26,51.88) v1(289.15,73.98)
