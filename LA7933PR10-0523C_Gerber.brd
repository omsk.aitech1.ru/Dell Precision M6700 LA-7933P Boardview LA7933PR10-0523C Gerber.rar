# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.75VSP on BOTTOM (solid shape): 229.89,54.36 230.53,54.36 230.53,54.86 230.72,54.86 230.72,54.36 231.29,54.36 231.29,54.86 231.67,54.86 231.74,54.8 231.74,53.28 231.61,53.15 230.21,53.15 229.83,52.77 229.83,48.64 229.64,48.45 229.64,47.12 230.28,46.48 230.28,46.25 230.25,46.23 229.32,46.23 228.5,47.05 228.5,54.74 228.62,54.86 229.89,54.86
+0.75VSP on IN2 (solid shape): outline of 164 points within 228.69,46.42 231.61,54.29
+1.0V_LAN on TOP (solid shape): 122.06,166.48 122.06,165.93 121.88,165.75 121.88,165.06 122.58,164.36 122.71,164.36 122.77,164.3 122.77,163.34 122.72,163.28 122.17,163.28 122.12,163.34 122.12,164.31 121.09,165.34 121.09,165.61 121.39,165.9 121.39,166.48 121.42,166.52 122.02,166.52
+1.5V_CPU_VDDQ on TOP (solid shape): outline of 106 points within 99.59,51.88 124.46,71.43
+1.5V_CPU_VDDQ on BOTTOM (solid shape): outline of 3472 points within 92.78,53.28 118.69,67.54
+1.05V_M on TOP (solid shape): 49.45,138.28 52.17,138.28 52.41,138.04 52.41,135.51 51.89,134.99 49.3,134.99 48.89,135.4 48.89,136.07 48.19,136.77 47.99,136.77 47.83,136.93 47.17,136.93 47.06,137.03 47.06,138.16 47.13,138.23 47.13,138.23 47.18,138.29 49.44,138.29
+1.05V_M on TOP (solid shape): outline of 91 points within 16.1,140.4 21.18,144.84
+1.05V_M on TOP (solid shape): outline of 111 points within 26.18,113.37 30.07,120.14
+1.05V_M on VCC (solid shape): 41.02,145.61 44.19,145.61 52.42,137.37 52.42,135.68 51.94,135.19 32,135.19 30.86,134.05 29.8,134.05 28.65,135.19 27.68,135.19 26.52,134.03 26.52,131.53 29.82,128.23 29.82,121.62 30.71,120.74 30.71,119.42 29.82,118.53 29.82,116.76 29.79,116.73 29.78,116.72 29.59,116.7 29.45,116.61 29.39,116.53 29.35,116.43 29.34,116.42 29.32,116.4 28.44,116.4 27.79,115.74 27.79,113.78 27.77,113.74 27.74,113.73 27.05,113.73 26.73,113.41 26.71,113.4 26.68,113.4 26.66,113.41 26.15,113.37 26.13,112.87 26.14,112.84 26.12,112.81 24.67,111.35 24.61,111.34 24.57,111.33 24.53,111.32 14.43,111.32 13.56,112.18 13.56,144.48 14.68,145.61 34.37,145.61 36.27,147.51 39.11,147.51
+1.05V_M on IN2 (solid shape): 29.01,118.2 29.22,118.2 29.34,118.09 29.33,118.03 29.52,117.65 29.94,117.67 29.98,117.67 30.12,117.53 30.12,116.74 30.02,116.64 29.99,116.62 29.95,116.64 29.68,116.72 29.42,116.58 29.4,116.56 29.13,116.56 28.03,115.46 28.03,114.72 28.36,114.39 28.36,113.65 28.07,113.37 27.54,113.37 27.22,113.49 26.93,113.31 26.84,113.25 26.75,113.3 26.43,113.49 26.1,113.31 26.03,113.26 25.94,113.29 25.48,113.37 25.29,112.95 25.27,112.87 25.19,112.83 23.53,112.83 23.44,112.92 23.44,113.61 23.66,113.83 24.33,113.83 24.74,114.24 24.74,114.68 25.23,115.18 25.56,115.18 25.56,115.17 25.95,115.26 26.05,115.65 26.05,115.68 26.06,115.7 26.86,116.5 26.86,117.08 27.06,117.29 27.06,118.03 27.2,118.16 27.2,118.16 27.24,118.2 29.01,118.2
+1.5V_MEM on TOP (solid shape): outline of 1746 points within 120.7,41.24 168.34,64.45
+1.5V_MEM on BOTTOM (solid shape): outline of 3517 points within 120.79,41.26 209.9,69.33
+1.5V_MEM on VCC (solid shape): outline of 161 points within 89.51,38.93 166.22,73.47
+1.5V_MEM on IN2 (solid shape): outline of 12921 points within 89.51,35.12 166.98,72.33
+1.05V_MP on TOP (solid shape): outline of 333 points within 3.91,139.09 16.36,145.35
+1.05V_RUN on TOP (solid shape): 48.97,134.44 51.08,134.44 51.23,134.29 51.23,133.4 51.14,133.31 50.68,133.31 50.37,132.99 50.37,131.62 49.95,131.2 47.33,131.2 47.12,131.42 47.12,132.4 46.79,132.73 43.23,132.73 43.05,132.91 43.05,134.46 43.56,134.96 48.45,134.96
+1.05V_RUN on TOP (solid shape): 24.41,118.57 24.48,118.57 24.55,118.5 24.89,118.5 24.97,118.58 25.46,118.58 25.56,118.48 25.56,116.82 25.21,116.46 23.85,116.46 23.81,116.5 23.81,116.88 24.06,117.13 24.06,117.45 24.27,117.65 24.27,118.02 24.09,118.2 24.09,118.5 24.17,118.58 24.41,118.58
+1.5V_RUN on TOP (solid shape): 112.22,149.8 112.22,145.35 110.48,143.61 110.48,143.15 110.48,143.15 110.48,141.59 110.3,141.42 108.69,141.42 108.25,141.85 108.25,144.68 109.13,144.68 109.13,144.62 109.14,144.57 109.16,144.52 109.19,144.47 109.23,144.42 109.27,144.39 109.31,144.35 109.36,144.33 109.41,144.31 109.47,144.3 109.52,144.3 109.58,144.3 109.63,144.32 109.69,144.34 109.73,144.37 109.78,144.4 109.81,144.45 109.84,144.49 109.87,144.54 109.88,144.6 109.89,144.65 109.89,144.71 109.88,144.76 109.87,144.82 109.84,144.87 109.81,144.91 109.78,144.95 109.73,144.99 109.69,145.02 109.63,145.04 109.58,145.05 109.52,145.06 109.47,145.06 109.41,145.05 109.36,145.03 109.31,145 109.27,144.97 109.23,144.93 109.19,144.89 109.16,144.84 109.14,144.79 109.13,144.73 109.13,144.68 108.25,144.68 108.25,145.21 109.18,146.14 109.18,148.06 110.09,148.97 110.09,149.61 110.45,149.97 111.19,149.97 111.21,149.95 111.23,149.96 111.68,149.96 111.75,150.03 111.99,150.03
+1.05V_RUN on TOP (solid shape): outline of 135 points within 27.51,113.68 32.02,119.46
+1.5V_RUN on BOTTOM (solid shape): 110.44,142.45 110.44,141.3 110.27,141.14 109.41,141.14 109.26,141.29 109.26,141.67 108.99,141.94 107.19,141.94 107,142.13 107,142.36 107.2,142.56 109.04,142.56 109.17,142.69 110.2,142.69
+1.5V_RUN on BOTTOM (solid shape): 199.71,75.15 199.71,74.67 199.16,74.67 199.16,74.11 199.71,74.11 199.71,73.87 199.16,73.87 199.16,73.32 199.71,73.32 199.71,72.8 199.5,72.58 197.9,72.58 195.81,74.67 195.81,76.36 196.22,76.77 198.09,76.77
+1.5V_RUN on BOTTOM (solid shape): 111.69,165.51 111.69,160.9 112.18,160.41 112.18,155.57 113,154.75 113,151.45 112.1,150.55 112.1,148.98 111.77,148.64 110.6,148.64 110.32,148.93 110.32,149.94 110.51,150.14 111.23,150.85 111.23,152.34 111.48,152.59 111.48,154.88 110.84,155.51 110.84,157 109.75,158.09 109.75,161.49 109.32,161.93 107.2,161.93 107.06,162.07 107.06,162.41 107.24,162.59 108.96,162.59 108.98,162.6 109.09,162.6 109.27,162.78 109.27,163.08 109.83,163.64 109.83,165.67 109.93,165.77 111.43,165.77
+1.5V_RUN on BOTTOM (solid shape): outline of 295 points within 171.51,150.46 192.82,161.52
+1.05V_RUN on IN1 (solid shape): outline of 103 points within 28.38,112.45 34.8,117.45
+1.05V_RUN on VCC (solid shape): outline of 90 points within 27.02,99.12 51.54,134.68
+1.5V_RUN on IN2 (solid shape): 111.33,149.68 111.33,148.24 110.96,147.87 109.96,147.87 109.61,148.21 109.61,149.59 110.01,149.99 111.02,149.99
+1.5V_RUN on IN2 (solid shape): outline of 1416 points within 190.66,103.95 201.81,153.33
+1.5V_RUN on IN3 (solid shape): outline of 201 points within 11.68,148.12 34.76,151.93
+1.5V_RUN on IN3 (solid shape): outline of 579 points within 194,74.99 200.3,106.24
+1.05V_RUN on IN3 (solid shape): outline of 659 points within 28.68,112.41 34.58,120.79
+1.05V_RUN on IN4 (solid shape): outline of 104 points within 28.55,110.05 33.37,115.89
+1.5V_RUN on IN4 (solid shape): outline of 1602 points within 109.24,160.98 175.16,170.33
+1.05V_RUN_VTT on TOP (solid shape): outline of 710 points within 86.21,40.2 91.29,68.77
+1.05V_RUN_VTT on BOTTOM (solid shape): outline of 2997 points within 75.86,18.99 92.3,59.88
+1.05V_RUN_VTT on VCC (solid shape): outline of 104 points within 73.51,18.73 91.54,67.12
+1.05V_RUN_VTT on IN2 (solid shape): outline of 4344 points within 76.3,19.11 91.03,67.63
+1.05V_RUN_VTT on IN3 (solid shape): outline of 2425 points within 76.3,19.11 91.03,67.63
+1.5V_RUNP on BOTTOM (solid shape): 205.39,76.6 205.39,72.85 205.25,72.71 200.08,72.71 199.86,72.92 199.86,76.58 199.94,76.65 205.33,76.65
+1.5VP on BOTTOM (solid shape): 225.28,50.09 225.28,49.72 225.31,49.7 225.83,49.7 225.84,49.69 225.84,49.53 225.83,49.52 225.29,49.52 225.28,49.51 225.28,48.9 224.01,48.9 223.73,49.17 223.73,50.09 223.75,50.11 225.27,50.11
+1.5VP on BOTTOM (solid shape): outline of 143 points within 209.4,44.96 217.4,66.23
+1.05VTTP on BOTTOM (solid shape): 76.17,27.37 76.17,26.81 75.7,26.81 75.65,26.76 75.65,26.07 75.7,26.02 76.17,26.02 76.17,25.58 75.67,25.58 75.67,24.84 76.15,24.84 76.17,24.82 76.17,22.42 76.55,22.04 76.55,19.5 76.3,19.24 71.86,19.24 71.73,19.37 71.73,22.67 69.82,24.58 69.82,27.37 70.08,27.62 75.92,27.62
+1.8V_RUN on TOP (solid shape): 112.63,86.64 112.63,85.9 112.23,85.5 108.93,85.5 108.38,86.04 108.38,87.35 108.51,87.48 111.8,87.48
+1.8V_RUN on TOP (solid shape): 86.05,106.08 86.82,106.08 87.82,105.08 87.82,104.34 87.45,103.98 84.8,103.98 83.67,105.11 83.67,106.34 83.95,106.62 85.51,106.62
+1.8V_RUN on TOP (solid shape): 101.32,42.48 101.32,41.34 101.07,41.09 98.78,41.09 98.65,41.21 98.65,41.59 98.78,41.72 99.92,41.72 100.81,42.61 101.19,42.61
+1.8V_RUN on BOTTOM (solid shape): 48.23,130.87 48.23,130.58 47.45,129.79 47.45,129.34 47.39,129.28 47.39,128.25 46.83,127.69 46.83,127.58 46.54,127.29 46.05,127.29 45.9,127.45 45.9,130.48 46.42,131 48.11,131
+1.8V_RUN on BOTTOM (solid shape): 28.38,96.25 28.38,95.77 28.43,95.72 29.2,95.72 29.23,95.69 29.58,95.69 29.75,95.52 29.75,95.01 29.44,94.69 27.77,94.69 27.62,94.84 27.62,95.56 27.79,95.72 28.17,95.72 28.21,95.76 28.21,96.24 28.24,96.28 28.36,96.28
+1.8V_RUN on BOTTOM (solid shape): outline of 990 points within 93.06,20.38 102.08,46.04
+1.8V_RUN on IN1 (solid shape): 43.13,37.53 43.13,36.03 42.79,35.69 40.42,35.69 40.17,35.94 40.17,37.34 40.56,37.73 42.93,37.73
+1.8V_RUN on IN1 (solid shape): outline of 408 points within 12.45,92.23 29.75,95.99
+1.8V_RUN on IN2 (solid shape): outline of 188 points within 45.78,118 67.32,133.18
+1.8V_RUN on IN3 (solid shape): outline of 83 points within 90.6,22.89 95.08,38.41
+1.8V_RUN on IN3 (solid shape): outline of 346 points within 66.46,104.92 86.92,121.88
+1.8V_RUN on IN4 (solid shape): 95.11,23.76 95.11,23.11 94.84,22.84 92.27,22.84 92.11,23 92.11,23.91 92.24,24.04 94.84,24.04
+1.8V_RUN on IN4 (solid shape): 112.01,85.92 112.01,84.35 110.04,82.39 109.73,82.39 108.94,83.17 108.94,86.02 109.22,86.3 111.63,86.3
+1.8V_RUN on IN4 (solid shape): 43.62,37.54 43.62,36.52 43.4,36.3 41.5,36.3 41.31,36.49 41.31,37.49 41.55,37.73 43.43,37.73
+1.8V_RUN on IN4 (solid shape): outline of 2580 points within 90.52,35.75 105.51,48.71
+1.8V_RUN_LVDS on BOTTOM (solid shape): 45.39,128.26 45.39,125.6 45.02,125.24 44.66,125.24 44.64,125.24 44.62,125.26 44.4,125.45 44.12,125.43 44.09,125.42 44.06,125.44 43.64,125.86 43.64,127.64 44.46,128.46 45.19,128.46
+1.8V_RUN_LVDS on IN2 (solid shape): outline of 575 points within 33.36,122.1 44.68,127.5
+1.8V_RUNP on BOTTOM (solid shape): 101.8,24.54 101.8,21.78 101.1,21.08 101.1,14.83 100.81,14.54 97.51,14.54 96.92,15.13 96.92,20.11 99.24,22.42 99.24,23.15 99.24,23.15 99.24,24.72 99.32,24.8 101.54,24.8
+3.3V_ALW on TOP (solid shape): 138.97,148.73 138.97,146.09 138.67,145.78 135.39,145.78 135.06,146.11 135.06,148.78 135.19,148.91 138.8,148.91
+3.3V_ALW on TOP (solid shape): 179,13.56 179,12.56 178.64,12.19 177.8,12.19 176.91,13.08 176.91,14.36 177.21,14.67 177.9,14.67
+3.3V_ALW on TOP (solid shape): 135.76,142.19 135.76,140.75 135.62,140.61 130.78,140.61 130.74,140.65 130.74,142.3 130.86,142.42 135.53,142.42
+3.3V_ALW on TOP (solid shape): 101.92,132.65 101.92,131.33 102.3,130.95 103.08,130.95 103.12,130.91 103.12,130.25 103.03,130.16 97.76,130.16 97.43,130.49 97.43,132.69 97.69,132.94 101.62,132.94
+3.3V_ALW on TOP (solid shape): 13.83,155.21 13.83,149.94 13.64,149.75 12.44,149.75 12.24,149.95 12.24,150.46 12.36,150.57 12.36,153.77 12.24,153.89 12.24,155.08 12.48,155.32 13.71,155.32
+3.3V_ALW on TOP (solid shape): 37.31,46.17 37.31,44.55 36.93,44.17 35.37,44.17 35.03,43.83 35.03,43.63 34.9,43.5 34.14,43.5 33.76,43.88 33.76,45.15 34.9,46.29 35.15,46.29 35.15,46.3 35.27,46.42 37.06,46.42
+3.3V_ALW on TOP (solid shape): 170.29,138.15 170.29,137.68 170.34,137.63 170.74,137.63 170.78,137.67 170.78,138.16 170.8,138.19 171.45,138.19 171.91,137.73 171.91,136.79 171.42,136.31 171.42,136.23 171.21,136.02 170.14,136.02 169.98,136.18 169.98,138.14 170.03,138.19 170.25,138.19
+3.3V_ALW on TOP (solid shape): 156.08,164.15 156.08,158.06 155.9,157.89 155.62,157.89 155.5,157.76 155.5,156.87 155.45,156.78 155.44,156.69 155.44,156.67 155.03,156.26 154.53,156.26 154.45,156.18 154.45,156.06 154.42,156.03 154.42,155.21 154.45,155.18 154.45,154.65 154.28,154.48 153.8,154.48 153.69,154.58 153.69,156.88 154.28,157.47 154.28,164.35 154.43,164.5 155.73,164.5
+3.3V_ALW on TOP (solid shape): 77.01,152.78 77.32,152.17 77.62,152.78 79.2,152.78 79.35,152.63 79.35,151.56 78.13,150.33 75.92,150.33 74.05,148.46 72.58,148.46 71.92,149.12 71.92,149.77 73.11,150.97 73.44,150.97 74.55,152.07 75.59,152.07 76.29,152.78
+3.3V_ALW on TOP (solid shape): 127.53,29.11 127.53,27.55 126.74,26.76 125.94,26.76 125.78,26.59 125.78,23.94 125.88,23.84 125.88,22.71 125.68,22.5 124.83,22.5 123.32,24.02 123.32,25.62 123.33,25.63 124.9,25.63 124.91,25.57 124.92,25.52 124.94,25.47 124.97,25.42 125,25.37 125.04,25.34 125.08,25.3 125.13,25.28 125.19,25.26 125.24,25.25 125.3,25.25 125.35,25.25 125.41,25.27 125.46,25.29 125.51,25.32 125.55,25.35 125.59,25.4 125.62,25.44 125.64,25.49 125.66,25.55 125.66,25.6 125.66,25.66 125.66,25.71 125.64,25.77 125.62,25.82 125.59,25.86 125.55,25.9 125.51,25.94 125.46,25.97 125.41,25.99 125.35,26 125.3,26.01 125.24,26.01 125.19,26 125.13,25.98 125.08,25.96 125.04,25.92 125,25.88 124.97,25.84 124.94,25.79 124.92,25.74 124.91,25.68 124.9,25.63 123.33,25.63 123.57,25.87 123.57,26.54 123.58,26.55 123.58,26.99 123.63,27.04 123.63,29.15 123.85,29.36 127.28,29.36
+3.3V_ALW on TOP (solid shape): outline of 323 points within 177.57,139.14 183.6,151.37
+3.3V_ALW on BOTTOM (solid shape): 298.52,45.61 298.52,41.39 298.21,41.09 289.03,41.09 288.77,41.34 288.77,45.53 289.03,45.78 298.34,45.78
+3.3V_ALW on BOTTOM (solid shape): 219.28,69.16 219.28,65.74 219.12,65.57 218.05,65.57 217.32,66.31 217.32,67.83 215.75,69.41 214.22,69.41 213.97,69.66 213.97,70.68 214.1,70.8 217.64,70.8
+3.3V_ALW on BOTTOM (solid shape): 259.29,66.7 259.29,64.37 260.79,62.87 260.79,61.62 260.59,61.42 257.78,61.42 257.64,61.57 257.64,62.89 257.3,63.23 257.3,65.08 257.56,65.34 257.56,66.74 257.61,66.79 259.19,66.79
+3.3V_ALW on BOTTOM (solid shape): 196.7,85.54 196.7,81.34 196.49,81.14 191.56,81.14 191.36,81.34 191.36,84.65 191.87,85.15 193.52,85.15 194.1,85.74 194.13,85.74 194.23,85.75 194.32,85.79 196.44,85.79
+3.3V_ALW on BOTTOM (solid shape): 227.58,78.55 227.58,75.81 227.4,75.63 226.86,75.63 226.86,77.03 226.66,77.23 225.63,77.23 225.55,77.31 225.55,78.6 225.59,78.64 227.49,78.64
+3.3V_ALW on BOTTOM (solid shape): 248.58,68.31 248.67,68.28 248.77,68.26 248.87,68.26 249.25,67.88 249.25,67.52 249.81,66.95 249.81,63.47 249.68,63.34 247.09,63.34 246.89,63.54 246.89,67.32 246.76,67.45 246.29,67.45 246.11,67.63 246.11,68.26 246.16,68.31
+3.3V_ALW on BOTTOM (solid shape): 74.57,149.66 74.57,149.24 74.17,148.83 74.13,148.83 73.77,148.48 73.77,144.86 73.66,144.74 73.39,144.74 73.01,145.07 72.63,144.74 71.25,144.74 70.97,145.02 70.97,145.8 71.11,145.94 72.05,145.94 72.27,146.16 72.27,149.4 72.66,149.78 74.45,149.78
+3.3V_ALW on BOTTOM (solid shape): 98.7,151.21 98.7,148.32 98.53,148.15 98.53,135.95 101.07,133.41 101.07,130.49 100.68,130.11 98.27,130.11 97.13,131.26 97.13,134.68 96.75,135.07 96.75,136.34 96.43,136.65 96.43,140.54 96.56,140.98 96.43,141.43 96.43,144.84 96.52,144.93 96.76,145.5 96.52,146.07 96.43,146.17 96.43,150.48 97.31,151.36 98.55,151.36
+3.3V_ALW on BOTTOM (solid shape): 175.22,105.13 175.22,105.12 175.39,104.95 175.39,101.47 175.18,101.27 172.4,101.27 171.91,101.77 171.91,102.88 173.06,102.88 173.06,102.83 173.08,102.77 173.1,102.72 173.12,102.67 173.16,102.63 173.2,102.59 173.24,102.56 173.29,102.53 173.35,102.51 173.4,102.5 173.46,102.5 173.51,102.51 173.57,102.52 173.62,102.54 173.66,102.57 173.71,102.61 173.74,102.65 173.78,102.7 173.8,102.75 173.82,102.8 173.82,102.86 173.82,102.91 173.82,102.97 173.8,103.02 173.78,103.07 173.74,103.12 173.71,103.16 173.66,103.19 173.62,103.22 173.57,103.24 173.51,103.26 173.46,103.26 173.4,103.26 173.35,103.25 173.29,103.23 173.24,103.21 173.2,103.18 173.16,103.14 173.12,103.09 173.1,103.05 173.08,102.99 173.06,102.94 173.06,102.88 171.91,102.88 171.91,104.93 172.17,105.19 175.16,105.19
+3.3V_ALW on BOTTOM (solid shape): 284.02,27.62 284.06,27.61 284.07,27.57 284.07,27.12 284.96,27.12 284.96,27.57 284.98,27.61 285.01,27.62 285.16,27.62 285.2,27.61 285.22,27.57 285.22,27.12 286.1,27.12 286.1,27.57 286.12,27.61 286.15,27.62 290.88,27.62 290.92,27.61 290.93,27.57 290.93,27.12 291.82,27.12 291.82,27.57 291.83,27.61 291.87,27.62 292.02,27.62 292.06,27.61 292.07,27.57 292.07,27.12 292.96,27.12 292.96,27.57 292.98,27.61 293.01,27.62 293.6,27.62 293.72,27.5 293.72,23.94 293.6,23.81 282.42,23.81 282.17,24.07 282.17,27.37 282.42,27.62
+3.3V_ALW on BOTTOM (solid shape): 245.41,82.25 245.41,81.64 245.39,81.61 244.88,81.61 244.84,81.57 244.84,81.12 244.87,81.09 245.34,81.09 245.37,81.08 245.39,81.04 245.39,80.68 245.65,80.42 246.76,80.42 247.09,80.09 247.09,78 246.98,77.89 246.98,77.67 246.92,77.58 246.81,77.59 246.19,77.33 246.75,76.96 246.76,76.96 246.92,76.96 246.96,76.95 246.98,76.91 246.98,76.44 246.96,76.41 246.92,76.39 246.54,76.01 246.23,76.01 246.1,76.14 245.36,76.14 245.24,76.26 245.24,77.89 245.36,78.02 246.61,78.02 246.86,78.27 246.86,78.75 246.48,79.13 245.36,79.13 245.24,79.26 245.24,80.02 244.24,81.01 243.99,81.01 243.98,81.02 243.85,81.04 243.72,81.02 243.71,81.01 242.92,81.01 242.81,81.13 242.81,81.6 242.64,81.76 242.49,81.76 242.33,81.93 242.33,82.3 242.44,82.41 245.25,82.41
+3.3V_ALW on BOTTOM (solid shape): outline of 304 points within 149.38,148.82 155.03,164.07
+3.3V_ALW on BOTTOM (solid shape): outline of 549 points within 1.12,92.27 12.29,132.27
+3.3V_ALW on BOTTOM (solid shape): outline of 606 points within 10.32,43.41 35.02,80.68
+3.3V_ALW on VCC (solid shape): outline of 447 points within 87.22,22.16 292.96,150.43
+3.3V_ALW on IN2 (solid shape): 212.57,56.71 212.57,55.58 212.41,55.41 209.79,55.41 209.59,55.61 209.59,56.63 209.87,56.91 212.37,56.91
+3.3V_ALW on IN2 (solid shape): 178.51,14.68 178.51,13.78 179.06,13.23 179.06,12.71 178.56,12.22 178.19,12.22 177.14,13.27 177.14,14.52 177.75,15.13 178.07,15.13
+3.3V_ALW on IN3 (solid shape): outline of 3599 points within 1.12,130.01 98.94,163.6
+3.3V_ALW on IN4 (solid shape): outline of 229 points within 6.97,79.46 17.67,95.26
+3.3V_ALW2 on BOTTOM (solid shape): 282.2,63.66 281.91,60.9 277.79,60.9 277.72,60.96 277.72,61.09 277.79,61.15 278.99,61.15 279.37,61.53 280.14,61.53 280.96,62.36 280.96,63.56 281.09,63.69 282.17,63.69
+3.3V_ALW_PCH on TOP (solid shape): 10.12,121.87 10.12,121.85 10.12,121.83 10.11,121.72 10.13,121.61 10.13,121.6 10.13,121.48 10.01,121.35 10.01,121.29 10,121.28 9.98,121.15 10,121.03 10.01,121.02 10.01,120.97 9.5,120.46 9.5,118.68 9.37,118.56 8.99,118.56 8.8,118.37 7.12,118.37 7.12,118.37 7.01,118.37 6.97,118.39 6.96,118.42 6.96,119.44 7.06,119.54 7.09,119.56 7.12,119.55 7.57,119.62 7.64,120.07 7.63,120.1 7.64,120.13 7.72,120.21 7.72,121.35 7.85,121.48 9.24,121.48 9.75,121.98 10.01,121.98
+3.3V_ALW_PCH on TOP (solid shape): 25.36,116.15 25.38,116.15 25.4,116.13 25.7,115.98 26,116.13 26.01,116.14 26.05,116.15 26.08,116.12 26.1,116.1 26.14,116.08 26.22,115.94 26.14,115.81 26.1,115.79 26.05,115.7 26.05,115.37 26.1,115.29 26.14,115.26 26.22,115.14 26.16,115.01 25.93,115.01 25.91,115.02 25.89,115.03 25.63,115.13 25.37,115.03 25.35,115.02 25.33,115.01 25.26,115.01 24.97,114.72 24.97,113.87 24.81,113.72 23.92,113.72 23.87,113.74 23.81,113.77 23.38,114.2 23.38,114.38 23.38,114.53 23.66,114.81 23.67,114.81 24.03,115.16 24.03,115.52 24.66,116.15
+3.3V_ALW_PCH on TOP (solid shape): outline of 119 points within 1.12,103.82 13.69,112.97
+3.3V_ALW_PCH on BOTTOM (solid shape): 9.24,129.22 11.53,129.22 11.78,128.97 11.78,127.95 11.53,127.7 9.37,127.7 9.12,127.45 9.12,126.56 8.99,126.43 8.36,126.43 8.23,126.56 8.23,128.46 7.85,128.84 6.58,128.84 6.2,129.22 5.94,129.22 5.82,129.35 5.82,129.86 6.07,130.11 8.36,130.11
+3.3V_ALW_PCH on BOTTOM (solid shape): 25.35,116.21 25.35,116.2 25.66,115.99 26.01,116.14 26.03,116.16 26.05,116.16 26.62,116.16 26.77,116.02 26.77,115.25 26.65,115.14 26.05,115.14 26.05,115.13 25.7,115.13 25.63,115.13 25.37,115.13 25.25,115 25.25,114.75 25.12,114.62 24.74,114.62 24.62,114.5 24.59,114.5 24.59,114.22 24.48,114.11 24.18,114.11 23.47,114.11 23.36,114.21 23.36,114.24 23.36,114.26 23.38,114.4 23.35,114.55 23.34,114.56 23.34,114.92 23.39,115 23.48,115.01 23.89,115.09 23.98,115.5 23.99,115.59 24.07,115.63 24.23,115.63 24.31,115.71 24.34,115.71 24.34,115.74 24.48,115.89 24.48,116.14 24.61,116.27 25.29,116.27
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 483 points within 5.31,96.08 14.71,119.44
+3.3V_ALW_PCH on IN4 (solid shape): 29.41,117.04 29.41,117.03 29.72,116.88 30.02,117.03 30.03,117.04 30.07,117.06 30.17,117.06 30.19,117.04 30.2,117.03 30.54,116.81 30.89,117.03 30.91,117.05 30.93,117.06 30.96,117.06 31,117.03 31.01,117.02 31.34,116.83 31.67,117.02 31.68,117.03 31.72,117.06 31.79,117.06 31.82,117.04 31.83,117.03 32.17,116.81 32.51,117.03 32.53,117.05 32.56,117.06 32.93,117.06 33.29,116.7 33.29,116.18 33.12,116.02 32.87,116.02 32.74,116.14 30.19,116.14 30.11,116.18 30.09,116.26 29.72,116.72 29.34,116.26 29.32,116.18 29.24,116.14 28.8,116.14 28.42,115.76 27.55,115.76 27.29,115.86 27.03,115.76 26.9,115.76 26.39,115.25 25.5,115.25 25.12,114.87 25.12,113.96 24.99,113.83 23.77,113.83 23.4,114.2 23.4,114.57 23.67,114.83 23.68,114.83 24.01,115.16 24.01,115.48 24.03,115.52 24.06,115.53 24.88,115.53 25.31,115.96 25.97,115.96 25.98,115.97 26.05,115.97 26.81,116.73 28.05,116.73 28.08,116.76 28.1,116.76 28.27,116.8 28.41,116.92 28.49,116.96 28.57,116.92 28.94,116.76 29.26,117.05 29.29,117.06 29.37,117.06
+3.3V_ALW_PCH on IN4 (solid shape): outline of 753 points within 6.92,117.83 13.46,129.03
+3.3V_ALW_U46 on BOTTOM (solid shape): 247.85,81.83 247.85,78.27 247.8,78.22 247.31,78.22 247.23,78.3 247.23,80.28 246.89,80.62 245.79,80.62 245.58,80.84 245.58,81.26 245.57,81.27 245.02,81.27 245.01,81.28 245.01,81.41 245.02,81.42 245.55,81.42 245.58,81.45 245.58,81.88 245.57,81.89 247.79,81.89
+3.3V_ALW_U54 on TOP (solid shape): 171.77,140.09 171.77,139.34 171.4,138.98 171.4,138.46 171.27,138.33 170.81,138.33 170.8,138.34 170.66,138.34 170.62,138.3 170.62,137.82 170.58,137.78 170.48,137.78 170.45,137.82 170.45,138.25 170.36,138.34 170.01,138.34 169.94,138.42 169.94,138.79 170.31,139.15 170.31,140.16 170.51,140.36 171.5,140.36
+3.3V_ALWP on BOTTOM (solid shape): 287.88,41.97 287.88,36.64 289.15,35.37 294.61,35.37 294.99,34.99 294.99,28.13 294.74,27.88 292.71,27.88 292.71,27.42 292.69,27.38 292.66,27.37 292.38,27.37 292.34,27.38 292.33,27.42 292.33,27.88 291.57,27.88 291.57,27.42 291.55,27.38 291.51,27.37 291.23,27.37 291.2,27.38 291.18,27.42 291.18,27.88 285.85,27.88 285.85,27.42 285.84,27.38 285.8,27.37 285.52,27.37 285.48,27.38 285.47,27.42 285.47,27.88 284.71,27.88 284.71,27.42 284.69,27.38 284.66,27.37 284.38,27.37 284.34,27.38 284.33,27.42 284.33,27.88 282.42,27.88 281.02,29.27 281.02,37.15 279.75,38.42 279.75,42.23 280.26,42.74 287.12,42.74
+3.3V_LAN on TOP (solid shape): 133.37,148.11 133.37,142.94 133.15,142.71 131.8,142.71 131.49,143.02 131.49,143.48 130.51,144.46 130.51,148.24 130.97,148.69 132.79,148.69
+3.3V_LAN on TOP (solid shape): 94.57,163.91 94.57,162.49 94.79,162.27 96.2,162.27 96.35,162.13 96.35,161.18 96.19,161.02 93.99,161.02 93.37,161.65 93.37,162.99 93.05,163.32 93.05,164.17 93.39,164.51 93.96,164.51
+3.3V_LAN on TOP (solid shape): 119.62,161.96 119.73,161.96 119.75,161.95 119.92,161.89 120.1,161.91 120.11,161.92 120.14,161.91 120.46,161.6 121.51,161.6 121.61,161.49 121.61,161.33 121.59,161.3 120.46,161.3 120.39,161.24 120.38,161.23 119.47,161.23 119.04,160.8 117.82,160.8 117.69,160.92 117.69,162.22 117.84,162.37 119.21,162.37
+3.3V_LAN on BOTTOM (solid shape): 118.74,167.59 118.74,161.43 118.32,161.01 117.45,161.01 117.21,161.25 117.21,163.24 116.09,164.36 116.09,165.16 116.67,165.16 116.68,165.11 116.69,165.05 116.71,165 116.74,164.95 116.77,164.91 116.81,164.87 116.86,164.84 116.9,164.81 116.96,164.79 117.01,164.78 117.07,164.78 117.12,164.79 117.18,164.8 117.23,164.82 117.28,164.85 117.32,164.89 117.36,164.93 117.39,164.98 117.41,165.03 117.43,165.08 117.44,165.14 117.44,165.19 117.43,165.25 117.41,165.3 117.39,165.35 117.36,165.4 117.32,165.44 117.28,165.47 117.23,165.5 117.18,165.53 117.12,165.54 117.07,165.55 117.01,165.54 116.96,165.53 116.9,165.52 116.86,165.49 116.81,165.46 116.77,165.42 116.74,165.37 116.71,165.33 116.69,165.27 116.68,165.22 116.67,165.16 116.09,165.16 116.09,167.63 116.58,168.12 118.21,168.12
+3.3V_LAN on BOTTOM (solid shape): outline of 870 points within 120.72,137.77 132.31,157.29
+3.3V_LAN on IN2 (solid shape): 131.77,163.39 131.77,162.33 131.44,162 128.05,162 127.4,162.65 119.1,162.65 118.5,162.05 118.5,161.19 118.13,160.82 117.61,160.82 117.13,161.3 117.13,162.78 117.96,163.6 131.56,163.6
+3.3V_LAN on IN3 (solid shape): outline of 293 points within 129.74,155.35 132.59,163.49
+3.3V_LAN on IN4 (solid shape): outline of 288 points within 82.27,160.86 119.34,164.95
+3.3V_MXM on TOP (solid shape): outline of 314 points within 203.17,83.49 210.03,94.18
+3.3V_MXM on BOTTOM (solid shape): 204.87,85.19 204.87,82.53 204.64,82.3 199.1,82.3 198.98,82.41 198.98,83.85 201.66,83.85 201.66,83.79 201.68,83.74 201.7,83.68 201.72,83.64 201.76,83.59 201.8,83.55 201.84,83.52 201.89,83.49 201.95,83.48 202,83.47 202.06,83.46 202.11,83.47 202.17,83.48 202.22,83.51 202.27,83.54 202.31,83.57 202.35,83.61 202.38,83.66 202.4,83.71 202.42,83.76 202.42,83.82 202.42,83.87 202.42,83.93 202.4,83.98 202.38,84.03 202.35,84.08 202.31,84.12 202.27,84.16 202.22,84.19 202.17,84.21 202.11,84.22 202.06,84.23 202,84.23 201.95,84.22 201.89,84.2 201.84,84.17 201.8,84.14 201.76,84.1 201.72,84.06 201.7,84.01 201.68,83.96 201.66,83.9 201.66,83.85 198.98,83.85 198.98,85.36 199.39,85.77 204.28,85.77
+3.3V_PCIE_FLASH on TOP (solid shape): 172.22,163.41 172.22,161.72 171.73,161.23 171.73,160.93 171.42,160.63 170.64,160.63 170.34,160.93 170.34,161.47 169.67,162.14 168.02,162.14 166.69,160.81 165.87,160.81 165.71,160.96 162.81,160.96 162.67,160.82 162.66,160.82 162.41,160.91 162.16,160.81 161.77,160.81 161.5,160.91 161.24,160.81 160.97,160.81 160.92,160.76 160.32,160.76 160.19,160.63 158.97,160.63 158.82,160.78 157.47,160.78 157.03,160.34 156.63,160.34 156.5,160.47 156.5,162.32 157.55,163.37 165.25,163.37 166.18,164.3 171.33,164.3
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 172.3,162.14 172.3,161.84 171.39,160.93 171.39,160.04 170.78,159.42 170.78,159.36 170.56,159.14 170.56,156.05 170.46,155.94 169.87,155.94 169.8,155.97 169.77,156.04 169.6,156.34 169.25,156.37 169.23,156.37 169.2,156.37 168.84,156.73 168.84,158.49 168.88,158.56 168.96,158.59 169.39,158.97 168.96,159.34 168.88,159.37 168.84,159.45 168.84,159.83 168.96,159.94 169.53,159.94 169.57,159.91 169.71,159.91 170.2,160.4 170.2,162.12 170.24,162.15 170.24,162.48 170.43,162.67 171.77,162.67
+3.3V_PCIE_FLASH on BOTTOM (solid shape): outline of 159 points within 181.37,153.61 193.79,166.15
+3.3V_PCIE_FLASH on IN4 (solid shape): outline of 264 points within 169.87,156.99 189.03,162.55
+3.3V_PCIE_NVM on TOP (solid shape): 16.18,154.66 16.18,153.25 15.31,152.39 14.65,152.39 14.26,152.78 14.26,154.65 14.48,154.86 15.98,154.86
+3.3V_PCIE_NVM on TOP (solid shape): 12.1,152.9 12.1,152.73 12.12,152.71 12.11,152.71 12.11,151.66 12.03,151.58 11.72,151.58 11.28,151.13 10.6,151.13 10.26,151.47 10.26,152.86 10.41,153.01 11.99,153.01
+3.3V_PCIE_NVM on TOP (solid shape): 21.12,151.58 21.15,151.56 21.17,151.52 21.17,151.39 21.16,151.36 21.15,151.35 21.36,150.65 21.57,151.35 21.56,151.36 21.55,151.39 21.55,151.52 21.57,151.56 21.6,151.58 22.53,151.58 22.89,151.21 22.9,151.18 22.9,151.15 22.87,150.77 23.18,150.56 23.25,150.53 23.28,150.46 23.28,147.48 23.26,147.38 23.28,147.28 23.28,145.87 23.09,145.68 20.29,145.68 20.01,145.96 20.01,151.09 20.5,151.58
+3.3V_PCIE_NVM on BOTTOM (solid shape): 29.14,158.59 29.14,155 28.76,154.62 27.68,154.62 27.42,154.89 27.42,156.17 27.74,156.49 27.74,158.59 27.93,158.78 28.95,158.78
+3.3V_PCIE_NVM on BOTTOM (solid shape): 12.13,152.65 12.13,151.73 12.03,151.63 10.91,151.63 10.35,151.07 10.35,148.72 10.15,148.51 9.27,148.51 8.71,149.07 8.71,149.85 8.76,149.93 8.85,149.94 9.38,150.29 8.85,150.64 8.76,150.65 8.71,150.74 8.71,151.63 10.08,153 11.78,153
+3.3V_PCIE_NVM on IN3 (solid shape): outline of 573 points within 11.64,150.58 34.06,156.27
+3.3V_PCIE_WWAN on TOP (solid shape): outline of 549 points within 91.82,131.99 107.45,159.13
+3.3V_PCIE_WWAN on BOTTOM (solid shape): outline of 186 points within 98.74,152.31 110.54,166.76
+3.3V_RUN on TOP (solid shape): 175.18,109.62 175.18,108.08 175.14,108.04 174.87,108.04 174.87,108.61 174.37,108.61 174.37,108.04 174.13,108.04 174.07,108.1 174.07,109.6 174.33,109.86 174.94,109.86
+3.3V_RUN on TOP (solid shape): 81.13,35.34 81.13,34.87 80.94,34.68 80.94,30.85 80.91,30.82 80.91,29.59 80.03,28.72 77.87,28.72 77.18,29.41 77.18,34.49 78.17,35.48 80.99,35.48
+3.3V_RUN on TOP (solid shape): 288.32,137.42 288.32,137.41 288.35,137.32 288.39,137.25 288.39,134.3 288.01,133.92 287.37,133.92 287.12,134.18 287.12,137.35 287.25,137.48 288.26,137.48
+3.3V_RUN on TOP (solid shape): 42.91,12.02 42.91,8.23 42.25,7.57 35.32,7.57 35.13,7.76 35.13,10.15 35.33,10.35 37.07,10.35 37.31,10.59 39.15,10.59 40.11,11.55 40.11,12.03 40.25,12.17 42.76,12.17
+3.3V_RUN on TOP (solid shape): 68.04,86.5 68.04,86.37 68.01,86.34 68.01,85.71 68.21,85.51 68.68,85.51 68.72,85.47 68.72,84.94 68.63,84.85 67.16,84.85 67.08,84.93 67.08,85.7 67.11,85.77 67.18,85.8 67.48,85.98 67.51,86.33 67.51,86.36 67.52,86.38 67.54,86.4 67.54,86.59 67.57,86.63 67.59,86.68 67.87,86.68
+3.3V_RUN on TOP (solid shape): outline of 1504 points within 195.93,48.3 239.16,62.41
+3.3V_RUN on BOTTOM (solid shape): 254,67.98 254,66.3 253.85,66.15 252.94,66.15 252.71,66.38 252.71,68.64 252.82,68.76 253.22,68.76
+3.3V_RUN on BOTTOM (solid shape): 263.83,67.46 263.83,66.39 263.78,66.34 263.78,66.34 263.48,66.04 262.88,66.04 262.66,66.26 262.66,67.61 262.76,67.72 263.57,67.72
+3.3V_RUN on BOTTOM (solid shape): 288.83,54.23 288.83,52.71 289.41,52.13 291.21,52.13 293.09,50.25 293.09,48.71 292.84,48.45 289.41,48.45 288.77,49.09 287.63,49.09 287.12,49.59 285.85,49.59 285.72,49.72 285.72,54.29 285.98,54.55 288.52,54.55
+3.3V_RUN on BOTTOM (solid shape): 10.77,122.75 10.77,122.24 10.65,122.12 10.62,122.1 10.39,122.1 10.21,122 10.2,121.99 10.18,121.98 10.02,121.98 10.01,121.99 9.85,122.02 9.7,121.99 9.69,121.98 9.63,121.98 9.5,122.11 9.5,122.75 9.63,122.87 10.64,122.87
+3.3V_RUN on VCC (solid shape): outline of 1494 points within 6.7,51.37 292.96,162.62
+3.3V_RUN on IN2 (solid shape): outline of 2514 points within 21.82,11.43 48.65,69.91
+3.3V_RUN on IN3 (solid shape): 289.41,135.32 289.41,134.05 289.15,133.8 287.76,133.8 287.63,133.92 287.63,135.32 287.88,135.57 289.15,135.57
+3.3V_RUN on IN3 (solid shape): 290.04,76.9 290.04,73.88 289.95,73.79 289.95,73.67 289.37,73.1 289.06,73.1 288.78,73.37 288.78,73.38 288.77,73.39 288.77,74.11 287.63,75.25 287.63,77.03 287.76,77.15 289.79,77.15
+3.3V_RUN on IN3 (solid shape): outline of 128 points within 288.52,100.39 294.93,108.75
+3.3V_RUN_R1 on BOTTOM (solid shape): 210.42,83.99 210.42,83.82 210.35,83.76 209.41,83.76 209.19,83.54 209.19,82.36 208.67,81.84 207.06,81.84 207.06,82.4 207.08,82.42 208.46,82.42 208.66,82.62 208.66,83.52 209.18,84.04 210.37,84.04
+3.3V_RUN_R2 on BOTTOM (solid shape): 216.26,86.53 216.26,86.01 216.22,85.97 214.8,85.97 214.6,85.76 213.05,85.76 212.98,85.83 212.98,85.98 213.05,86.05 214.08,86.05 214.59,86.56 216.23,86.56
+3.3V_RUN_TPM on TOP (solid shape): 172.42,99.5 172.42,97.08 172.49,97 172.49,96.9 172.52,96.86 172.52,96.63 172.59,96.56 172.62,96.56 173.46,95.72 173.46,95.25 173.37,95.16 172.71,95.16 172.54,95.33 172.54,95.8 172.44,95.9 172.44,95.94 172.39,95.94 171.9,96.44 171.9,99.51 171.97,99.59 172.33,99.59
+3.3V_RUN_TPM on TOP (solid shape): 174.02,107.88 175.11,107.88 175.13,107.86 175.13,107.77 174.75,107.4 174.65,107.4 173.98,106.73 173.54,106.73 173.21,107.06 172.55,107.06 172.35,106.86 172.35,103.86 172.22,103.73 172.1,103.73 171.97,103.86 171.97,107.54 171.77,107.75 171.77,108.28 171.82,108.33 173.57,108.33
+3.3V_RUN_TPM on TOP (solid shape): 167.87,108.52 168.96,108.52 169.11,108.37 169.11,104.43 169.1,104.4 169.06,104.38 168.78,104.38 168.75,104.4 168.73,104.43 168.73,107.3 168.32,107.71 167.99,107.71 167.77,107.94 167.38,107.94 167.13,108.19 167.13,108.7 167.23,108.8 167.59,108.8
+3.3V_RUN_TPM on TOP (solid shape): 166.42,94.7 166.42,93.74 166.42,93.59 166.6,93.41 168.5,93.41 168.76,93.66 168.76,94.93 168.81,94.99 170.22,94.99 170.4,94.81 170.4,93.7 170.55,93.55 170.86,93.55 170.87,93.55 171.04,93.51 171.21,93.55 171.22,93.55 171.57,93.55 171.72,93.71 171.72,94.83 171.8,94.91 172.44,94.91 172.55,94.8 172.55,94.47 172.24,94.16 172.24,94.09 172.19,94.04 172.19,92.77 172.06,92.65 165.67,92.65 165.55,92.77 165.55,94.74 165.82,95.01 166.11,95.01
+3.3V_RUN_TPM on BOTTOM (solid shape): outline of 269 points within 167.23,93.33 170.42,109.79
+3.3V_RUN_TPM on IN4 (solid shape): 172.58,96.8 172.64,96.77 172.68,96.7 172.74,96.51 172.91,96.36 172.92,96.33 172.92,95.96 172.67,95.71 172.08,95.71 170.04,93.66 168.97,93.66 168.71,93.93 168.71,94.87 169.66,95.82 169.67,95.83 169.83,95.92 169.92,96.08 169.92,96.09 170.31,96.47 170.41,96.49 170.48,96.41 170.98,96.09 171.19,96.64 171.19,96.75 171.27,96.8
+3.3V_RUN_TPM on IN4 (solid shape): outline of 180 points within 167.61,106.14 175.14,108.66
+3.3V_SUS on TOP (solid shape): 122.32,32.92 122.32,31.99 122.39,31.93 123.07,31.93 123.58,32.43 126.13,32.43 126.88,31.68 127.6,31.68 127.98,31.31 128.59,31.31 128.67,31.23 128.67,30.83 128.51,30.66 127.46,30.66 127.18,30.38 126.31,30.38 126.28,30.35 126.26,30.34 126.08,30.25 125.97,30.08 125.96,30.02 125.65,29.71 123.78,29.71 123.39,30.1 122.54,30.1 122.32,30.31 122.32,31.22 121.64,31.9 120.22,31.9 119.79,31.47 119.79,31.06 119.59,30.87 119.29,30.87 119.12,31.04 119.12,31.83 118.5,32.44 117.16,32.44 117.05,32.56 117.05,33.06 117.14,33.15 118.63,33.15 118.74,33.03 119.83,33.03 120.43,33.63 121.61,33.63
+3.3V_WLAN on BOTTOM (solid shape): outline of 763 points within 175.79,87.44 202.4,102.68
+5V_ALW on TOP (solid shape): 261.85,40.83 261.85,19.37 261.47,18.99 249.66,18.99 249.15,19.5 249.15,40.96 249.66,41.47 261.21,41.47
+5V_ALW on TOP (solid shape): 191.64,62.23 191.64,60.11 191.49,59.96 187.64,59.96 187.45,60.15 187.45,61.34 187.43,61.37 187.43,62.14 187.81,62.52 191.35,62.52
+5V_ALW on TOP (solid shape): 4.35,152.02 4.35,151.13 4.16,150.94 4.16,150.62 3.47,149.92 2.13,149.92 2.01,150.05 2.01,150.81 2.2,151 3.78,151 4.04,151.26 4.04,152.02 4.1,152.08 4.29,152.08
+5V_ALW on TOP (solid shape): 34.11,88.85 34.11,87.02 33.83,86.74 32.99,86.74 32.24,87.49 30.62,87.49 30.54,87.57 30.54,87.68 30.61,87.74 31.49,87.74 31.52,87.77 31.52,87.78 31.99,88.25 32.35,88.25 33.11,89.01 33.95,89.01
+5V_ALW on TOP (solid shape): 176.45,29.4 176.49,29.39 176.5,29.35 176.5,28.26 176.63,28.13 176.88,28.13 177.12,27.89 177.12,27.87 177.14,27.86 177.14,27.64 177.12,27.63 177.12,27.48 176.88,27.24 176.88,26.73 176.76,26.61 176.12,26.61 176,26.73 176,28 176.25,28.26 176.25,29.35 176.26,29.39 176.3,29.4
+5V_ALW on TOP (solid shape): 13.35,164.48 13.35,163.18 13.4,163.13 13.4,162.6 13.38,162.59 13.38,162.1 14.02,161.47 14.02,160.54 13.98,160.5 13.51,160.5 13.46,160.45 13.46,160 13.5,159.96 13.97,159.96 14.02,159.91 14.02,159.74 13.98,159.7 13.47,159.7 13.42,159.65 13.42,159.21 13.47,159.16 13.94,159.16 14.02,159.08 14.02,158.81 13.57,158.37 11.7,158.37 11.38,158.69 11.38,162.74 11.71,163.07 11.71,164.52 11.97,164.78 13.04,164.78
+5V_ALW on TOP (solid shape): 29.06,22.8 29.06,21.02 29.18,20.89 29.33,20.89 29.58,20.79 29.84,20.88 29.85,20.89 29.95,20.89 30.07,21.02 30.07,21.65 30.2,21.78 32.21,21.78 32.24,21.77 32.49,21.53 32.49,16.19 32.16,15.86 30.15,15.86 30.1,15.81 29.69,15.81 29.44,15.56 29.06,15.56 28.93,15.69 28.93,16.43 29.4,16.9 29.4,19.27 28.29,20.38 28.29,22.92 28.42,23.05 28.8,23.05
+5V_ALW on BOTTOM (solid shape): 64.3,25.34 64.3,24.58 64.17,24.45 62.33,24.45 62.08,24.19 60.62,24.19 60.55,24.26 60.55,24.45 60.62,24.51 61.31,24.51 62.27,25.46 64.17,25.46
+5V_ALW on BOTTOM (solid shape): 204.32,50.74 204.32,48.07 204.06,47.82 197.41,47.82 197.4,47.83 197.07,47.83 196.82,48.07 196.82,49.02 197.66,49.86 197.66,50.72 198.05,51.12 203.94,51.12
+5V_ALW on BOTTOM (solid shape): 107.03,13.65 107.03,12 106.63,11.6 104.88,11.6 104.72,11.75 104.72,12.45 104.86,12.59 105.37,12.59 105.51,12.73 105.51,13.65 105.64,13.78 106.91,13.78
+5V_ALW on BOTTOM (solid shape): 191.11,175.73 191.11,172.66 191.62,172.15 191.62,171.8 191.6,171.78 191.6,167.43 191.34,167.17 189.58,167.17 189.3,167.44 189.3,171.4 187.63,173.07 187.63,175.86 187.75,175.97 190.87,175.97
+5V_ALW on BOTTOM (solid shape): 43.09,44.32 44.68,44.32 44.74,44.26 44.74,44.07 44.68,44.01 43.03,44.01 42.9,43.88 42.9,43.8 42.9,43.43 42.33,42.86 41.38,42.86 40.99,43.24 40.11,43.24 40,43.35 40,44.22 40.3,44.51 42.9,44.51
+5V_ALW on BOTTOM (solid shape): 51.28,22.86 51.28,20.83 50.71,20.26 50.71,19.42 50.69,19.38 50.66,19.37 50.57,19.37 50.53,19.38 50.52,19.42 50.52,21.59 50.27,21.84 50.27,22.8 50.46,22.99 51.15,22.99
+5V_ALW on BOTTOM (solid shape): 288.9,59.55 288.9,59.18 288.43,59.18 288.43,58.6 288.9,58.6 288.9,58.38 288.4,58.38 288.4,57.83 288.9,57.83 288.9,56.86 288.62,56.58 286.81,56.58 286.27,57.13 285.3,57.13 284.83,57.6 284.83,58.48 285.34,58.99 286.1,58.99 286.23,59.12 286.23,59.47 286.48,59.72 288.73,59.72
+5V_ALW on BOTTOM (solid shape): 55.42,14.16 55.46,14.15 55.47,14.11 55.47,13.65 56.36,13.65 56.36,14.11 56.38,14.15 56.41,14.16 56.56,14.16 56.6,14.15 56.62,14.11 56.62,13.65 57.5,13.65 57.5,14.11 57.52,14.15 57.55,14.16 58.27,14.16 58.52,13.91 58.52,11.32 58.13,10.92 54.68,10.92 54.33,11.28 54.33,13.91 54.58,14.16
+5V_ALW on BOTTOM (solid shape): 76.34,163.11 76.34,162.05 76.07,161.77 75.46,161.77 75.27,161.59 75.27,161.01 74.19,159.93 72.65,159.93 71.72,159 71.59,159 71.5,158.92 68.07,158.92 67.94,158.79 67.38,158.79 67.19,158.98 67.19,160.26 67.7,160.77 71.07,160.77 71.3,161 71.58,161 71.81,161.23 73.22,161.23 75.21,163.22 76.24,163.22
+5V_ALW on BOTTOM (solid shape): 252.27,41.34 252.31,41.32 252.32,41.29 252.32,40.83 253.21,40.83 253.21,41.29 253.23,41.32 253.26,41.34 253.54,41.34 253.57,41.33 253.59,41.29 253.59,40.89 253.59,40.89 253.59,40.83 254.35,40.83 254.35,41.29 254.37,41.32 254.4,41.34 256.59,41.34 256.63,41.32 256.64,41.29 256.64,40.83 257.53,40.83 257.53,41.29 257.54,41.32 257.58,41.34 257.73,41.34 257.77,41.32 257.78,41.29 257.78,40.83 258.67,40.83 258.67,41.29 258.69,41.32 258.72,41.34 260.32,41.34 261.85,39.82 261.85,19.62 261.34,19.11 249.15,19.11 248.64,19.62 248.64,38.29 251.69,41.34
+5V_ALW on BOTTOM (solid shape): outline of 230 points within 27.79,15.69 32.61,27.37
+5V_ALW on IN1 (solid shape): 13.07,161.06 13.07,159.11 12.88,158.92 11.45,158.92 11.15,159.22 11.15,161.05 11.29,161.19 12.94,161.19
+5V_ALW on VCC (solid shape): outline of 2358 points within 1.02,1.22 302.83,178.18
+5V_ALW on IN2 (solid shape): 261.19,39.38 261.19,20.57 260.07,19.46 248.8,19.46 248.39,19.88 248.39,39.41 250.3,41.33 259.24,41.33
+5V_ALW on IN3 (solid shape): 261.72,40.7 261.72,20.26 260.45,18.99 249.66,18.99 248.89,19.75 248.89,40.58 249.53,41.21 261.21,41.21
+5V_ALW on IN3 (solid shape): 291.66,60.06 291.66,57.76 291.91,57.51 293.3,57.51 294.01,56.8 294.78,56.8 294.85,56.73 294.85,54.87 294.68,54.7 292.61,54.7 291.81,55.5 288.84,55.5 287.22,57.12 289.79,57.12 289.8,57.06 289.81,57.01 289.83,56.96 289.86,56.91 289.89,56.86 289.93,56.82 289.98,56.79 290.02,56.77 290.08,56.75 290.13,56.74 290.19,56.74 290.24,56.74 290.3,56.76 290.35,56.78 290.4,56.81 290.44,56.84 290.48,56.89 290.51,56.93 290.53,56.98 290.55,57.04 290.56,57.09 290.56,57.15 290.55,57.2 290.53,57.26 290.51,57.31 290.48,57.35 290.44,57.39 290.4,57.43 290.35,57.46 290.3,57.48 290.24,57.49 290.19,57.5 290.13,57.5 290.08,57.49 290.02,57.47 289.98,57.45 289.93,57.41 289.89,57.37 289.86,57.33 289.83,57.28 289.81,57.23 289.8,57.17 289.79,57.12 287.22,57.12 286.61,57.72 286.61,58.69 288.58,60.66 291.06,60.66
+5V_ALW on IN4 (solid shape): 261.19,39.38 261.19,20.57 260.07,19.46 250.54,19.46 248.88,21.12 248.88,39.9 250.3,41.33 259.24,41.33
+5V_ALW2 on BOTTOM (solid shape): 275.56,57.28 274.48,56.2 274.48,55.18 274.23,54.93 273.47,54.93 273.28,55.12 273.28,56.58 273.59,56.9 274.36,56.9 275.31,57.85 275.31,58.8 275.56,58.8
+5V_ALW_ESATA on TOP (solid shape): 15.47,160.76 15.59,160.76 15.62,160.73 16.47,160.73 16.48,160.72 16.78,160.72 16.81,160.68 16.81,160.03 16.72,159.94 15.9,159.94 15.54,159.59 15.54,158.45 15.47,158.37 14.39,158.37 14.16,158.6 14.16,159.26 14.11,159.31 13.66,159.31 13.61,159.36 13.61,159.53 13.64,159.55 14.12,159.55 14.17,159.6 14.17,160.06 14.12,160.11 13.65,160.11 13.61,160.15 13.61,160.33 13.64,160.35 14.13,160.35 14.17,160.39 14.17,160.86 14.3,160.99 15.24,160.99
+5V_ALW_FUSE on BOTTOM (solid shape): 290.54,59.04 291.64,59.04 291.71,58.97 291.71,58.32 291.63,58.24 290.75,58.24 290.01,57.5 289.11,57.5 289.11,59.49 289.13,59.51 290.07,59.51
+5V_ALWP on BOTTOM (solid shape): 259.43,53.42 259.43,41.72 259.31,41.59 258.42,41.59 258.42,41.09 258.04,41.09 258.04,41.59 257.28,41.59 257.28,41.09 256.89,41.09 256.89,41.59 254.1,41.59 254.1,41.09 253.72,41.09 253.72,41.59 252.96,41.59 252.96,41.09 252.58,41.09 252.58,41.59 251.56,41.59 251.56,46.79 250.42,47.93 248.12,47.93 247.88,48.17 247.88,52.79 248.89,53.81 259.05,53.81
+5V_ESATA_PWR on TOP (solid shape): 18.18,169.93 18.18,168.62 19.45,167.34 20.77,167.34 22.53,165.58 22.53,161.75 22.35,161.57 22.35,160.8 21.58,160.03 19.82,160.03 19.72,159.93 19.04,159.93 18.92,160.05 18.92,160.63 19.01,160.72 19.84,160.72 19.85,160.71 20.2,161.06 20.2,162.13 19.18,163.16 16.84,163.16 16.67,163.32 16.67,169.11 15.32,170.46 13.86,170.46 13.64,170.68 13.64,171.77 13.82,171.95 16.17,171.95
+5V_HDD on TOP (solid shape): 88.54,35.4 88.54,27.74 88.22,27.42 85.29,27.42 85.03,27.68 85.03,34 85.39,34.37 86.54,34.37 86.69,34.52 86.69,35.41 86.76,35.47 88.47,35.47
+5V_HDD on TOP (solid shape): 194.74,60.66 196.99,60.66 197.13,60.52 201.06,60.52 201.48,60.1 201.48,57.32 201.18,57.01 197.84,57.01 197.51,57.34 196.19,57.34 196.19,56.83 195.93,56.83 195.93,57.33 195.43,57.33 195.43,56.83 195.17,56.83 195.17,57.33 193.77,57.33 192.78,56.34 191.6,56.34 191.59,56.34 190.03,56.34 189.58,56.78 189.58,59.27 189.95,59.64 191.62,59.64 192.78,60.81 194.59,60.81
+5V_HDD on IN4 (solid shape): 193.25,59.69 193.25,58.88 191.86,57.48 189.56,57.48 189.38,57.66 189.38,59.4 189.94,59.96 192.99,59.96
+5V_HDD on IN4 (solid shape): 91.35,32.16 91.35,31.15 90.61,30.42 88.86,30.42 87.03,28.58 85.92,28.58 85.3,29.2 85.3,31.98 85.81,32.49 91.02,32.49
+5V_HDD on IN4 (solid shape): outline of 312 points within 162.28,42.99 171.3,50.74
+5V_HDD on IN4 (solid shape): outline of 1446 points within 123.07,21.12 158.58,28.96
+5V_MOD on TOP (solid shape): 27.53,29.15 27.53,28.39 26.9,27.75 26.9,26.1 26.82,26.02 26.82,26.02 26.17,25.38 26.17,25.37 26.01,25.21 25.37,25.21 25.28,25.25 25.19,25.28 25.18,25.28 24.87,25.59 23.21,25.59 23.09,25.72 23.09,27.12 23.29,27.31 23.31,27.33 23.33,27.33 23.38,27.32 23.43,27.32 25.11,27.32 25.35,27.38 25.54,27.57 25.57,27.57 25.65,27.57 25.87,27.79 25.87,28.12 25.5,28.48 25.5,29.27 25.63,29.4 27.28,29.4
+5V_MOD on BOTTOM (solid shape): 26.49,30.21 26.49,29.73 26.53,29.69 27,29.69 27.05,29.74 27.05,30.21 27.07,30.24 27.27,30.24 27.29,30.21 27.29,29.73 27.33,29.69 27.75,29.69 27.79,29.66 27.79,28.5 27.34,28.05 27.34,25.4 27.19,25.25 24.89,25.25 24,26.14 24,27.32 24.62,27.94 24.62,27.97 25.47,28.82 25.47,29.57 25.6,29.69 26.19,29.69 26.24,29.74 26.24,30.21 26.26,30.24 26.47,30.24
+5V_MXM on TOP (solid shape): 194.08,164.02 194.08,163.35 194.18,163.25 196.78,163.25 196.97,163.44 198.35,163.44 198.44,163.35 198.44,161.14 198.39,161.1 197.08,161.1 196.62,161.57 195.42,161.57 195.41,161.56 194.93,161.56 194.45,162.05 193.27,162.05 193.15,162.17 193.15,164.12 193.31,164.28 193.82,164.28
+5V_MXM on BOTTOM (solid shape): outline of 536 points within 192.91,159.83 202.03,175.83
+5V_RUN on TOP (solid shape): 25.69,162.32 25.69,160.86 25.5,160.67 25.5,160.41 25.18,160.1 24.75,160.1 24.43,160.41 24.43,162.29 24.59,162.45 25.56,162.45
+5V_RUN on TOP (solid shape): 219.16,87.58 219.16,86.55 220.09,85.62 220.09,84.99 219.94,84.84 218.68,84.84 218.17,85.34 218.17,87.52 218.4,87.74 219,87.74
+5V_RUN on TOP (solid shape): 194.92,56.58 195.55,56.58 195.55,57.09 195.81,57.09 195.81,56.58 196.44,56.58 196.44,57.09 197.48,57.09 197.75,56.82 197.75,55.75 197.6,55.6 194.28,55.6 194.03,55.86 194.03,56.96 194.16,57.09 194.92,57.09
+5V_RUN on TOP (solid shape): outline of 108 points within 66.01,162.12 73.13,164.53
+5V_RUN on BOTTOM (solid shape): 27.79,32.45 27.79,29.83 27.49,29.83 27.44,29.88 27.44,30.34 27.39,30.39 26.95,30.39 26.9,30.34 26.9,29.87 26.86,29.83 26.68,29.83 26.64,29.87 26.64,30.33 26.59,30.38 26.14,30.38 26.1,30.34 26.1,29.88 26.05,29.83 25.58,29.83 25.5,29.91 25.5,32.2 26.01,32.7 27.53,32.7
+5V_RUN on BOTTOM (solid shape): 216.35,89.09 216.35,88.57 217.53,87.39 219.06,87.39 219.2,87.25 219.2,86.44 220.04,85.6 220.04,85.13 219.81,84.9 218.79,84.9 217.76,85.93 217.27,85.93 216.44,86.76 216.44,87.72 215.54,88.62 215.54,89.16 215.57,89.2 216.24,89.2
+5V_RUN on BOTTOM (solid shape): 5.18,89.79 5.45,89.13 5.71,89.79 6.5,89.79 6.6,89.69 6.6,86.01 7.11,85.5 9.48,85.5 10.39,86.4 10.39,88.4 10.68,88.69 11.79,88.69 11.98,88.5 11.98,87.47 12.11,87.35 12.11,84.9 11.66,84.44 10.44,84.44 10,84.01 4.03,84.01 3.46,84.57 3.46,89.47 3.78,89.79
+5V_RUN on BOTTOM (solid shape): outline of 104 points within 194.09,53.21 202.86,57.09
+5V_RUN on IN1 (solid shape): outline of 855 points within 185.65,55.66 200.13,87.58
+5V_RUN on VCC (solid shape): outline of 1184 points within 1.02,1.02 207.62,172.02
+5V_RUN on IN3 (solid shape): outline of 351 points within 198.16,84.49 220.16,88.86
+5V_RUN_CRT on TOP (solid shape): 73.54,170.05 73.54,166.84 74.05,166.33 74.05,165.2 73.73,164.88 72.38,164.88 71,166.26 71,170.31 71.36,170.66 72.93,170.66
+5V_RUN_CRT on IN1 (solid shape): outline of 158 points within 52.65,162.78 72.76,167.96
+5V_RUN_HDMI on TOP (solid shape): 29.14,160.38 29.14,157.91 28.5,157.26 23.86,157.26 23.32,157.81 23.32,159.35 23.66,159.69 25.33,159.69 26.2,160.55 28.97,160.55
+5V_USB_PWR1 on TOP (solid shape): 294.17,116.77 294.17,115.67 292.57,114.06 292.57,113.74 291.86,113.03 291.44,113.03 289.7,111.3 289.6,111.27 289.53,111.36 288.88,111.59 289.11,110.94 289.2,110.87 289.17,110.76 289.15,110.74 289.15,107.63 289.41,107.38 289.91,107.38 290.3,107 290.3,103.57 290.1,103.38 287.31,103.38 286.87,103.82 286.87,113.27 288.59,115 292.14,115 292.52,115.38 292.52,115.68 292.54,115.84 292.52,116 292.52,116.97 292.64,117.09 293.85,117.09
+5V_USB_PWR1 on BOTTOM (solid shape): 290.3,106.24 290.3,103.82 290.04,103.57 287.25,103.57 286.74,104.08 286.74,106.3 286.87,106.43 289.03,106.43 289.08,106.48 289.09,106.49 289.11,106.49 290.04,106.49
+5V_USB_PWR1 on BOTTOM (solid shape): 294.2,116.81 294.2,115.7 292.56,114.06 292.56,113.49 292.1,113.03 291.06,113.03 290.8,113.28 290.8,114.72 291.15,115.06 292.14,115.06 292.58,115.51 292.58,116.9 292.84,117.16 293.85,117.16
+5V_USB_PWR1 on BOTTOM (solid shape): 297.25,59.94 297.25,58.92 297.07,58.73 293.88,58.73 293.81,58.81 293.81,58.96 293.89,59.05 294.57,59.05 294.58,59.05 294.72,59.05 295.08,59.41 295.08,59.89 295.22,60.03 297.17,60.03
+5V_USB_PWR1 on IN1 (solid shape): outline of 374 points within 289.74,58.71 304.73,107.25
+5V_USB_PWR1 on IN2 (solid shape): outline of 209 points within 289.62,58.71 304.73,107.25
+5V_USB_PWR1 on IN4 (solid shape): outline of 277 points within 289.62,58.71 304.73,107.25
+5V_USB_PWR2 on BOTTOM (solid shape): 297.28,58.31 297.28,57.51 297.08,57.31 295.15,57.31 294.89,57.57 294.89,58.06 294.75,58.21 293.9,58.21 293.83,58.28 293.83,58.47 293.9,58.54 297.06,58.54
+5V_USB_PWR2 on BOTTOM (solid shape): 294.06,93.76 294.06,91.96 293.06,90.96 293.06,89.31 294.57,87.8 294.57,85.79 293.81,85.03 290.42,85.03 290.04,85.41 290.04,88.41 291.31,89.68 291.31,91.5 291.57,91.76 292.01,91.76 292.56,92.3 292.56,93.89 292.87,94.21 293.61,94.21
+5V_USB_PWR2 on IN3 (solid shape): 302.49,87.19 302.49,59.51 299.38,56.4 296.15,56.4 296.04,56.52 296.04,58.54 296.13,58.63 298.43,58.63 300.33,60.52 300.33,82.87 298.42,84.77 290.3,84.77 289.91,85.15 289.91,87.19 290.3,87.57 302.11,87.57
+V1.05S_VCCPP_B+ on BOTTOM (solid shape): 65.63,16.96 67.03,16.96 67.66,16.32 68.55,16.32 68.81,16.07 68.81,13.65 68.68,13.53 64.87,13.53 64.49,13.91 63.9,13.91 63.87,13.92 63.85,13.96 63.85,14.42 62.97,14.42 62.97,13.96 62.95,13.92 62.91,13.91 62.76,13.91 62.73,13.92 62.71,13.96 62.71,14.42 61.82,14.42 61.82,13.96 61.81,13.92 61.77,13.91 60.04,13.91 59.92,14.03 59.92,17.08 60.04,17.21 61.87,17.21 61.88,17.21 65.38,17.21
+V1.05SP_B+ on BOTTOM (solid shape): outline of 244 points within 5.56,143.49 16.57,147.51
+VCC_CORE on TOP (solid shape): outline of 4567 points within 48.49,45.15 82.14,78.04
+VCC_CORE on BOTTOM (solid shape): outline of 4019 points within 48.49,45.73 85.44,78.04
+VCC_CORE on VCC (solid shape): outline of 92 points within 44.04,42.61 85.19,77.92
+VCC_CORE on IN2 (solid shape): outline of 4806 points within 48.74,46.04 85.32,77.92
+VCC_CORE on IN4 (solid shape): outline of 1186 points within 48.74,44.77 59.12,77.92
+VCC_GFXCORE on TOP (solid shape): 52.73,89.42 52.73,83.2 52.57,83.03 52.57,81.33 53.44,80.46 53.44,78.8 53.31,78.68 48.36,78.68 48.23,78.8 48.23,80.2 48.66,80.63 51.03,80.63 51.15,80.76 51.15,81.14 51.03,81.27 48.95,81.27 48.36,81.85 48.36,87.44 48.66,87.74 50.9,87.74 51.15,88 51.15,88.5 51.03,88.63 49.12,88.63 48.87,88.89 48.87,89.47 49.06,89.66 52.49,89.66
+VCC_GFXCORE on TOP (solid shape): outline of 1534 points within 76.1,67.91 88.48,91.25
+VCC_GFXCORE on BOTTOM (solid shape): outline of 2916 points within 75.79,65.52 88.95,90.74
