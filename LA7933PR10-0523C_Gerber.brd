# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
EMC4002-HZH-C_QFN48_7X7
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,6.95) 26(5,6.95) 27(4.5,6.95) 28(4,6.95) 29(3.5,6.95) 30(3,6.95) 31(2.5,6.95) 32(2,6.95) 33(1.5,6.95) 34(1,6.95) 35(0.5,6.95) 36(0,6.95)
  oval 1.041x0.254 smd: 13(6.225,0.725) 14(6.225,1.225) 15(6.225,1.725) 16(6.225,2.225) 17(6.225,2.725) 18(6.225,3.225) 19(6.225,3.725) 20(6.225,4.225) 21(6.225,4.725) 22(6.225,5.225) 23(6.225,5.725) 24(6.225,6.225) 37(-0.725,6.225) 38(-0.725,5.725) 39(-0.725,5.225) 40(-0.725,4.725) 41(-0.725,4.225) 42(-0.725,3.725) 43(-0.725,3.225) 44(-0.725,2.725) 45(-0.725,2.225) 46(-0.725,1.725) 47(-0.725,1.225) 48(-0.725,0.725)
  rect 4.089x4.089 smd: 49(2.75,3.475)
F_1206L150PR
  rect 0.991x1.803 smd: 1(0,0) 2(2.8,0)
F_SMD1812P200TF
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
FDC654P-G_SSOT-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
FDC655BN_NL_SSOT6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.39) 5(0.95,2.39) 6(0,2.39)
FDMS0309S_POWER56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,2.67)
FDMS7696A_POWER56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,2.67)
FDN338P_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_3Q38111-C35C5B-7H_11P-T
  round 1.702 hole 1.702 unplated: (-3.7,-0.63) (10.7,-0.63)
  oval 1.524x1.016 hole 0.914: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0)
  round 1.067 hole 0.762: 5(7.31,1.25) 6(6.04,1.25) 7(4.77,1.25) 8(3.5,1.25) 9(2.23,1.25) 10(0.96,1.25) 11(-0.31,1.25)
  oval 1.372x2.667 hole 0.61x1.905: 12(-5.7,0.97) 13(-5.7,-6.23) 14(12.7,-6.23) 15(12.7,0.97)
FOX_3V1121C-N1YD7-7H_20P-T
  round 1.397 hole 1.397 unplated: (-5.5,-9.24)
  round 0.762 hole 0.508: 1(0,0) 2(-0.5,-1) 3(-1,0) 4(-1.5,-1) 5(-2,0) 6(-2.5,-1) 7(-3,0) 8(-3.5,-1) 9(-4,0) 10(-4.5,-1) 11(-5,0) 12(-5.5,-1) 13(-6,0) 14(-6.5,-1) 15(-7,0) 16(-7.5,-1) 17(-8,0) 18(-8.5,-1) 19(-9,0) 20(-9.5,-1)
  oval 1.194x2.489 hole 0.61x1.905: 21(-13.7,-1.5) 22(2.7,-1.5)
  oval 1.194x2.21 hole 0.61x1.6: 23(-13.55,-8.44) 24(2.55,-8.44)
FOX_LN21131-D008-9H_13P-T
  oval 0.787x2.388 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0)
  oval 0.711x2.388 smd: 8(13.83,0) 9(14.83,0) 10(15.83,0) 11(16.83,0) 12(17.83,0) 13(18.83,0)
  oval 1.803x3.251 hole 0.991x2.438: 14(-1.82,0.35) 15(20.58,0.35)
FOX_QJ1119L-BT11-7H_19P-T
  round 0.762 hole 0.508: 1(0,0) 2(-0.5,-1) 3(-1,0) 4(-1.5,-1) 5(-2,0) 6(-2.5,-1) 7(-3,0) 8(-3.5,-1) 9(-4,0) 10(-4.5,-1) 11(-5,0) 12(-5.5,-1) 13(-6,0) 14(-6.5,-1) 15(-7,0) 16(-7.5,-1) 17(-8,0) 18(-8.5,-1) 19(-9,0)
  oval 1.499x3.302 hole 0.889x2.388: 20(-11.75,-1.41) 21(2.75,-1.41)
  oval 1.499x2.692 hole 0.889x1.397: 22(-11.75,-7.37) 23(2.75,-7.37)
FOX_QTS01401-A021-9H_140P-T
  round 1.6 hole 1.6 unplated: (-43,-2.6)
  round 0.889 hole 0.889 unplated: (1.6,-2.6)
  oval 0.356x1.803 smd: 1(0,0) 2(0,-5.2) 3(-0.6,0) 4(-0.6,-5.2) 5(-1.2,0) 6(-1.2,-5.2) 7(-1.8,0) 8(-1.8,-5.2) 9(-2.4,0) 10(-2.4,-5.2) 11(-3,0) 12(-3,-5.2) 13(-3.6,0) 14(-3.6,-5.2) 15(-4.2,0) 16(-4.2,-5.2) 17(-4.8,0) 18(-4.8,-5.2) 19(-5.4,0) 20(-5.4,-5.2) 21(-6,0) 22(-6,-5.2) 23(-6.6,0) 24(-6.6,-5.2) 25(-7.2,0) 26(-7.2,-5.2) 27(-7.8,0) 28(-7.8,-5.2) 29(-8.4,0) 30(-8.4,-5.2) 31(-9,0) 32(-9,-5.2) 33(-9.6,0) 34(-9.6,-5.2) 35(-10.2,0) 36(-10.2,-5.2) 37(-10.8,0) 38(-10.8,-5.2) 39(-11.4,0) 40(-11.4,-5.2) 41(-12,0) 42(-12,-5.2) 43(-12.6,0) 44(-12.6,-5.2) 45(-13.2,0) 46(-13.2,-5.2) 47(-13.8,0) 48(-13.8,-5.2) 49(-14.4,0) 50(-14.4,-5.2) 51(-15,0) 52(-15,-5.2) 53(-15.6,0) 54(-15.6,-5.2) 55(-16.2,0) 56(-16.2,-5.2) 57(-16.8,0) 58(-16.8,-5.2) 59(-17.4,0) 60(-17.4,-5.2) 61(-18,0) 62(-18,-5.2) 63(-18.6,0) 64(-18.6,-5.2) 65(-19.2,0) 66(-19.2,-5.2) 67(-19.8,0) 68(-19.8,-5.2) 69(-20.4,0) 70(-20.4,-5.2) 71(-21,0) 72(-21,-5.2) 73(-21.6,0) 74(-21.6,-5.2) 75(-22.2,0) 76(-22.2,-5.2) 77(-22.8,0) 78(-22.8,-5.2) 79(-23.4,0) 80(-23.4,-5.2) 81(-24,0) 82(-24,-5.2) 83(-24.6,0) 84(-24.6,-5.2) 85(-25.2,0) 86(-25.2,-5.2) 87(-25.8,0) 88(-25.8,-5.2) 89(-26.4,0) 90(-26.4,-5.2) 91(-27,0) 92(-27,-5.2) 93(-27.6,0) 94(-27.6,-5.2) 95(-28.2,0) 96(-28.2,-5.2) 97(-28.8,0) 98(-28.8,-5.2) 99(-29.4,0) 100(-29.4,-5.2) 101(-30,0) 102(-30,-5.2) 103(-30.6,0) 104(-30.6,-5.2) 105(-31.2,0) 106(-31.2,-5.2) 107(-31.8,0) 108(-31.8,-5.2) 109(-32.4,0) 110(-32.4,-5.2) 111(-33,0) 112(-33,-5.2) 113(-33.6,0) 114(-33.6,-5.2) 115(-34.2,0) 116(-34.2,-5.2) 117(-34.8,0) 118(-34.8,-5.2) 119(-35.4,0) 120(-35.4,-5.2) 121(-36,0) 122(-36,-5.2) 123(-36.6,0) 124(-36.6,-5.2) 125(-37.2,0) 126(-37.2,-5.2) 127(-37.8,0) 128(-37.8,-5.2) 129(-38.4,0) 130(-38.4,-5.2) 131(-39,0) 132(-39,-5.2) 133(-39.6,0) 134(-39.6,-5.2) 135(-40.2,0) 136(-40.2,-5.2) 137(-40.8,0) 138(-40.8,-5.2) 139(-41.4,0) 140(-41.4,-5.2)
  custom 0.413x0.413 smd: 141(3.025,-2.6) 142(-44.425,-2.6)
H_1P2
  round 1.702 hole 1.194: 1(0,0)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P0X3P6
  oval 3.505x4.115 hole 2.997x3.607: 1(0,0)
H_3P6
  round 4.115 hole 3.607: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_4P2
  round 4.699 hole 4.191: 1(0,0)
H_4P2N
  round 4.191 hole 4.191 unplated: (0,0)
H_5P2
  round 5.715 hole 5.207: 1(0,0)
INA211AIDCKRG4_SC70-6
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0.65,1.74) 6(0,1.74)
INA219AIDCNRG4_SOT23-8
  oval 0.381x0.965 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.35) 6(1.3,2.35) 7(0.65,2.35) 8(0,2.35)
IP4292CZ10-TBR_XSON10_2P5X1
  oval 0.254x0.889 smd: 1(0,0)
  oval 0.254x0.838 smd: 2(0.5,-0.025) 3(1,-0.025) 4(1.5,-0.025) 5(2,-0.025) 6(2,1.125) 7(1.5,1.125) 8(1,1.125) 9(0.5,1.125) 10(0,1.125)
ISL6208BCRZ-T_QFN8_2X2
  oval 0.254x0.914 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.075) 6(1,2.075) 7(0.5,2.075) 8(0,2.075)
  rect 1.549x0.889 smd: 9(0.75,1.038)
ISL95835HRTZ-T_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,5.001) 22(3.2,5.001) 23(2.8,5.001) 24(2.4,5.001) 25(2,5.001) 26(1.6,5.001) 27(1.2,5.001) 28(0.8,5.001) 29(0.4,5.001) 30(0,5.001)
  oval 0.991x0.203 smd: 11(4.3,0.7) 12(4.3,1.1) 13(4.3,1.5) 14(4.3,1.9) 15(4.3,2.3) 16(4.3,2.7) 17(4.3,3.1) 18(4.3,3.5) 19(4.3,3.9) 20(4.3,4.3) 31(-0.7,4.3) 32(-0.7,3.9) 33(-0.7,3.5) 34(-0.7,3.1) 35(-0.7,2.7) 36(-0.7,2.3) 37(-0.7,1.9) 38(-0.7,1.5) 39(-0.7,1.1) 40(-0.7,0.7)
  rect 3.607x3.607 smd: 41(1.8,2.5)
JAE_MM70-314-310B1-1-_310P-S
  round 1.092 hole 1.092 unplated: (-1,5.2)
  round 1.6 hole 1.6 unplated: (81,5.2)
  oval 0.305x1.499 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(5.5,0) 20(5.75,8.2) 21(6,0) 22(6.25,8.2) 23(6.5,0) 24(6.75,8.2) 25(7,0) 26(7.25,8.2) 27(7.5,0) 28(7.75,8.2) 29(8,0) 30(8.25,8.2) 31(8.5,0) 32(8.75,8.2) 33(9,0) 34(9.25,8.2) 35(9.5,0) 36(9.75,8.2) 37(10,0) 38(10.25,8.2) 39(10.5,0) 40(10.75,8.2) 41(11,0) 42(11.25,8.2) 43(11.5,0) 44(11.75,8.2) 45(12,0) 46(12.25,8.2) 47(12.5,0) 48(12.75,8.2) 49(13,0) 50(13.25,8.2) 51(13.5,0) 52(13.75,8.2) 53(14,0) 54(14.25,8.2) 55(14.5,0) 56(14.75,8.2) 57(15,0) 58(15.25,8.2) 59(15.5,0) 60(15.75,8.2) 61(16,0) 62(16.25,8.2) 63(16.5,0) 64(16.75,8.2) 65(17,0) 66(17.25,8.2) 67(17.5,0) 68(17.75,8.2) 69(18,0) 70(18.25,8.2) 71(18.5,0) 72(18.75,8.2) 73(19,0) 74(19.25,8.2) 75(19.5,0) 76(19.75,8.2) 77(20,0) 78(20.25,8.2) 79(20.5,0) 80(20.75,8.2) 81(21,0) 82(21.25,8.2) 83(21.5,0) 84(21.75,8.2) 85(22,0) 86(22.25,8.2) 87(22.5,0) 88(22.75,8.2) 89(23,0) 90(23.25,8.2) 91(23.5,0) 92(23.75,8.2) 93(24,0) 94(24.25,8.2) 95(24.5,0) 96(24.75,8.2) 97(25,0) 98(25.25,8.2) 99(25.5,0) 100(25.75,8.2) 101(26,0) 102(26.25,8.2) 103(26.5,0) 104(26.75,8.2) 105(27,0) 106(27.25,8.2) 107(27.5,0) 108(27.75,8.2) 109(28,0) 110(28.25,8.2) 111(28.5,0) 112(28.75,8.2) 113(29,0) 114(29.25,8.2) 115(29.5,0) 116(29.75,8.2) 117(30,0) 118(30.25,8.2) 119(30.5,0) 120(30.75,8.2) 121(31,0) 122(31.25,8.2) 123(31.5,0) 124(31.75,8.2) 125(32,0) 126(32.25,8.2) 127(32.5,0) 128(32.75,8.2) 129(33,0) 130(33.25,8.2) 131(33.5,0) 132(33.75,8.2) 133(34,0) 134(34.25,8.2) 135(34.5,0) 136(34.75,8.2) 137(35,0) 138(35.25,8.2) 139(35.5,0) 140(35.75,8.2) 141(36,0) 142(36.25,8.2) 143(36.5,0) 144(36.75,8.2) 145(37,0) 146(37.25,8.2) 147(37.5,0) 148(37.75,8.2) 149(38,0) 150(38.25,8.2) 151(38.5,0) 152(38.75,8.2) 153(39,0) 154(39.25,8.2) 155(39.5,0) 156(39.75,8.2) 157(40,0) 158(40.25,8.2) 159(40.5,0) 160(40.75,8.2) 161(41,0) 162(43.25,8.2) 163(43,0) 164(43.75,8.2) 165(43.5,0) 166(44.25,8.2) 167(44,0) 168(44.75,8.2) 169(44.5,0) 170(45.25,8.2) 171(45,0) 172(45.75,8.2) 173(45.5,0) 174(46.25,8.2) 175(46,0) 176(46.75,8.2) 177(46.5,0) 178(47.25,8.2) 179(47,0) 180(47.75,8.2) 181(47.5,0) 182(48.25,8.2) 183(48,0) 184(48.75,8.2) 185(48.5,0) 186(49.25,8.2) 187(49,0) 188(49.75,8.2) 189(49.5,0) 190(50.25,8.2) 191(50,0) 192(50.75,8.2) 193(50.5,0) 194(51.25,8.2) 195(51,0) 196(51.75,8.2) 197(51.5,0) 198(52.25,8.2) 199(52,0) 200(52.75,8.2) 201(52.5,0) 202(53.25,8.2) 203(53,0) 204(53.75,8.2) 205(53.5,0) 206(54.25,8.2) 207(54,0) 208(54.75,8.2) 209(54.5,0) 210(55.25,8.2) 211(55,0) 212(55.75,8.2) 213(55.5,0) 214(56.25,8.2) 215(56,0) 216(56.75,8.2) 217(56.5,0) 218(57.25,8.2) 219(57,0) 220(57.75,8.2) 221(57.5,0) 222(58.25,8.2) 223(58,0) 224(58.75,8.2) 225(58.5,0) 226(59.25,8.2) 227(59,0) 228(59.75,8.2) 229(59.5,0) 230(60.25,8.2) 231(60,0) 232(60.75,8.2) 233(60.5,0) 234(61.25,8.2) 235(61,0) 236(61.75,8.2) 237(61.5,0) 238(62.25,8.2) 239(62,0) 240(62.75,8.2) 241(62.5,0) 242(63.25,8.2) 243(63,0) 244(63.75,8.2) 245(63.5,0) 246(64.25,8.2) 247(64,0) 248(64.75,8.2) 249(64.5,0) 250(65.25,8.2) 251(65,0) 252(65.75,8.2) 253(65.5,0) 254(66.25,8.2) 255(66,0) 256(66.75,8.2) 257(66.5,0) 258(67.25,8.2) 259(67,0) 260(67.75,8.2) 261(67.5,0) 262(68.25,8.2) 263(68,0) 264(68.75,8.2) 265(68.5,0) 266(69.25,8.2) 267(69,0) 268(69.75,8.2) 269(69.5,0) 270(70.25,8.2) 271(70,0) 272(70.75,8.2) 273(70.5,0) 274(71.25,8.2) 275(71,0) 276(71.75,8.2) 277(71.5,0) 278(72.25,8.2) 279(72,0) 280(72.75,8.2) 281(72.5,0) 282(73.25,8.2) 283(73,0) 284(73.75,8.2) 285(73.5,0) 286(74.25,8.2) 287(74,0) 288(74.75,8.2) 289(74.5,0) 290(75.25,8.2) 291(75,0) 292(75.75,8.2) 293(75.5,0) 294(76.25,8.2) 295(76,0) 296(76.75,8.2) 297(76.5,0) 298(77.25,8.2) 299(77,0) 300(77.75,8.2) 301(77.5,0) 302(78.25,8.2) 303(78,0) 304(78.75,8.2) 305(78.5,0) 306(79.25,8.2) 307(79,0) 308(79.75,8.2) 309(79.5,0) 310(80,0)
  rect 3.302x5.004 smd: 311(-3.95,4.1) 312(83.95,4.1)
JAE_WD2F144WB5R400_144P-T
  oval 1.702x1.092 hole 1.702x1.092 unplated: (3,-4) (34.5,-4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.753x3.607 hole 0.991x2.845: 145(-5.425,-4) 152(42.925,-4)
  oval 1.905x1.702 hole 1.143x0.94: 146(-1.55,-5.725) 148(-1.55,-2.275) 149(39.05,-5.725) 151(39.05,-2.275)
  oval 1.702x2.667 hole 0.94x1.905: 147(-2.475,-4) 150(39.975,-4)
  oval 3.759x1.6 hole 2.997x0.838: 153(-3.75,-7.925) 156(41.25,-7.925) 161(-3.75,-0.075) 164(41.25,-0.075)
  oval 1.753x1.6 hole 0.991x0.838: 154(12.75,-7.925) 155(24.75,-7.925) 162(12.75,-0.075) 163(24.75,-0.075)
  round 1.753 hole 0.991: 157(0.75,-4) 160(36.75,-4)
  round 2.159 hole 1.397: 158(12.75,-4) 159(24.75,-4)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KC_FBMA-L11-453215-121LMA90T_2
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
LCN_DAN08-52526-0100_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(26.45,0.6) 54(-2.85,0.6)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LOTES_AUSB0041-P001A_9P-T
  round 1.295 hole 0.787: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(-2.9,-2.1) 11(9.9,-2.1)
  oval 1.397x3.2 hole 0.787x1.499: 12(-2.9,-7.15) 13(9.9,-7.15)
MAX14885EETLLFT_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
MEC5055-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MOLEX_52435-2671_26P-T
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  custom 0.597x0.597 smd: 27(-2.45,-1.925) 28(14.95,-1.925)
MURAT_BLM18AG121SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD102SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG330SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLW21SN121SQ2L_4P
  rect 0.762x0.61 smd: 1(0,0) 2(1.55,0) 3(1.55,-0.8) 4(0,-0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
NEC_MPC0740LR42C_2P
  rect 2.692x2.591 smd: 1(0,0) 2(6.2,0)
NTGD4161PT1G_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
NTR4503NT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PDS5100H-13_POWERDI5-3
  rect 4.699x3.607 smd: 1(0,0)
  rect 0.787x1.397 smd: 2(3.85,-0.9) 3(3.85,0.9)
PDTA114EU_SC70-3
  rect 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
PDTC124EU_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI2DBS212ZHEX_TQFN28_5P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 15(4.5,3.45) 16(4,3.45) 17(3.5,3.45) 18(3,3.45) 19(2.5,3.45) 20(2,3.45) 21(1.5,3.45) 22(1,3.45) 23(0.5,3.45) 24(0,3.45)
  oval 1.041x0.254 smd: 11(4.975,0.975) 12(4.975,1.475) 13(4.975,1.975) 14(4.975,2.475) 25(-0.475,2.475) 26(-0.475,1.975) 27(-0.475,1.475) 28(-0.475,0.975)
  rect 3.988x2.007 smd: 29(2.25,1.725)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.007 smd: 43(4,1.725)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PMV65XP_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8330BQFN48GTR-A0_QFN48_7X7
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,6.95) 26(5,6.95) 27(4.5,6.95) 28(4,6.95) 29(3.5,6.95) 30(3,6.95) 31(2.5,6.95) 32(2,6.95) 33(1.5,6.95) 34(1,6.95) 35(0.5,6.95) 36(0,6.95)
  oval 1.041x0.254 smd: 13(6.225,0.725) 14(6.225,1.225) 15(6.225,1.725) 16(6.225,2.225) 17(6.225,2.725) 18(6.225,3.225) 19(6.225,3.725) 20(6.225,4.225) 21(6.225,4.725) 22(6.225,5.225) 23(6.225,5.725) 24(6.225,6.225) 37(-0.725,6.225) 38(-0.725,5.725) 39(-0.725,5.225) 40(-0.725,4.725) 41(-0.725,4.225) 42(-0.725,3.725) 43(-0.725,3.225) 44(-0.725,2.725) 45(-0.725,2.225) 46(-0.725,1.725) 47(-0.725,1.225) 48(-0.725,0.725)
  rect 3.708x3.708 smd: 49(2.75,3.475)
PS8336BQFN56GTR-A0_QFN56_7X7
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 29(5.2,6.95) 30(4.8,6.95) 31(4.4,6.95) 32(4,6.95) 33(3.6,6.95) 34(3.2,6.95) 35(2.8,6.95) 36(2.4,6.95) 37(2,6.95) 38(1.6,6.95) 39(1.2,6.95) 40(0.8,6.95) 41(0.4,6.95) 42(0,6.95)
  oval 1.041x0.203 smd: 15(6.075,0.875) 16(6.075,1.275) 17(6.075,1.675) 18(6.075,2.075) 19(6.075,2.475) 20(6.075,2.875) 21(6.075,3.275) 22(6.075,3.675) 23(6.075,4.075) 24(6.075,4.475) 25(6.075,4.875) 26(6.075,5.275) 27(6.075,5.675) 28(6.075,6.075) 43(-0.875,6.075) 44(-0.875,5.675) 45(-0.875,5.275) 46(-0.875,4.875) 47(-0.875,4.475) 48(-0.875,4.075) 49(-0.875,3.675) 50(-0.875,3.275) 51(-0.875,2.875) 52(-0.875,2.475) 53(-0.875,2.075) 54(-0.875,1.675) 55(-0.875,1.275) 56(-0.875,0.875)
  rect 3.912x4.699 smd: 57(2.6,3.475)
PS8520BTQFN20GTR2_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
PS8710BTQFN24GTR-A1_TQFN24_4X4
  oval 0.254x1.016 smd: 1(0,-0.013) 2(0.5,-0.013) 3(1,-0.013) 4(1.5,-0.013) 5(2,-0.013) 6(2.5,-0.013) 13(2.5,3.963) 14(2,3.963) 15(1.5,3.963) 16(1,3.963) 17(0.5,3.963) 18(0,3.963)
  oval 1.016x0.254 smd: 7(3.238,0.725) 8(3.238,1.225) 9(3.238,1.725) 10(3.238,2.225) 11(3.238,2.725) 12(3.238,3.225) 19(-0.738,3.225) 20(-0.738,2.725) 21(-0.738,2.225) 22(-0.738,1.725) 23(-0.738,1.225) 24(-0.738,0.725)
  rect 2.692x2.692 smd: 25(1.25,1.975)
R0402_0OHM
  rect 0.559x0.508 smd: 1(0,0) 2(0.95,0)
R0603_0OHM
  oval 0.864x1.219 smd: 1(0,0) 2(1.422,0)
R_0402
  rect 0.559x0.508 smd: 1(0,0) 2(0.95,0)
R_0603
  oval 0.864x1.219 smd: 1(0,0) 2(1.422,0)
R_0805
  oval 1.016x1.524 smd: 1(0,0) 2(1.93,0)
R_1206
  oval 1.016x1.778 smd: 1(0,0) 2(3.048,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
R_2512_4P
  custom 0.826x0.826 smd: 1(0,0) 4(0,-8.687)
  rect 0.508x3.2 smd: 2(0,-2.108) 3(0,-6.579)
RB715FGT106_UMD3
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
RB717F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
RB751S40T1_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RB751V-40GTE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RB751V_SOD323-2
  rect 1.092x0.66 smd: 1(-1.05,0) 2(1.05,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RP_1206_8P4R
  oval 0.406x1.194 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(2.4,1.9) 6(1.6,1.9) 7(0.8,1.9) 8(0,1.9)
RT8205EGQW_WQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.515x2.515 smd: 25(1.25,1.975)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.001) 12(1.2,3.001) 13(0.8,3.001) 14(0.4,3.001) 15(0,3.001)
  oval 0.991x0.203 smd: 6(2.3,0.7) 7(2.3,1.1) 8(2.3,1.5) 9(2.3,1.9) 10(2.3,2.3) 16(-0.7,2.3) 17(-0.7,1.9) 18(-0.7,1.5) 19(-0.7,1.1) 20(-0.7,0.7)
  rect 1.702x1.702 smd: 21(0.8,1.5)
RT9818A-44GU3_SC70-3
  oval 0.457x1.092 smd: 1(0,0) 2(-0.65,-2.1) 3(0.65,-2.1)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SBR3A40SA-13_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4164DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4800BDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835DDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835DDY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7326DN-T1-E3_PAK1212-8
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SI7447DP_SO8_5P
  oval 0.635x1.778 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.962)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SLGC55584AVTR_TDFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
SN74AHC1G02DCKR_SC70-5
  oval 0.381x1.372 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SRV05-4PTCT_SOT23-6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SSX44-B-D-T1_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,7.5) 16(7.8,7.5) 17(7.15,7.5) 18(6.5,7.5) 19(5.85,7.5) 20(5.2,7.5) 21(4.55,7.5) 22(3.9,7.5) 23(3.25,7.5) 24(2.6,7.5) 25(1.95,7.5) 26(1.3,7.5) 27(0.65,7.5) 28(0,7.5)
SUYIN_070449HR015M221ZR_15P-T
  round 1.651 hole 1.651 unplated: (-4.056,0.2) (11.924,0.2)
  round 1.016 hole 0.61: 1(0,0) 2(2.286,-1) 3(4.572,0) 4(6.858,-1) 5(9.144,0) 6(-1.524,0) 7(0.762,-1) 8(3.048,0) 9(5.334,-1) 10(7.62,0) 11(-0.762,-1) 12(1.524,0) 13(3.81,-1) 14(6.096,0) 15(8.382,-1)
  oval 3.81x1.753 hole 3.048x0.991: 16(-8.565,-0.6) 18(16.425,-0.6)
  oval 1.753x2.87 hole 0.991x2.108: 17(-7.536,-1.159) 19(17.454,-1.159)
SUYIN_127043HB022M26GZL_22P-T
  oval 0.889x2.896 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(13.97,0) 9(15.24,0) 10(16.51,0) 11(17.78,-0.5) 12(19.05,0) 13(20.32,0) 14(21.59,0) 15(22.86,0) 16(24.13,0) 17(25.4,0) 18(26.67,0) 19(27.94,-0.5) 20(29.21,0) 21(30.48,0) 22(31.75,0)
  oval 1.6x2.997 hole 0.991x2.388: 23(-2.835,-1.48) 24(34.585,-1.48)
SUYIN_200045GR009M28QL_9P-T
  round 1.397 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.753x3.607 hole 0.991x2.845: 10(-3.125,0) 11(19.125,0)
SUYIN_254070FB008S205ZL_8P
  round 1.397 hole 1.397 unplated: (-11.15,-21.47) (4.9,-11.67)
  oval 0.991x2.311 smd: 1(0,0) 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-1.27,0) 6(-3.81,0) 7(-6.35,0) 8(-8.89,0)
  rect 1.499x2.946 smd: 9(-13.26,-20.7) 10(7.29,-20.7)
SY8033BDBC_DFN10_3X3
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.7) 7(1.5,2.7) 8(1,2.7) 9(0.5,2.7) 10(0,2.7)
  rect 2.591x1.753 smd: 11(1,1.35)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_VMPI0703AR-1R0M-Z01_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_HK1608R10J-T_L0603_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
TAIYO_LB2012T1R0M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_LBR2012T100M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_NRS4018T1R0NDGJ_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
TC7SET04FU_SSOP5
  oval 0.381x1.321 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SH125FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TDK_GLFR1608T1R0M-LR_2P
  rect 0.711x0.711 smd: 1(0,0) 2(1.4,0)
TOKO_FDSD0630-H-2R2M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDV0630-3R3M-P3_2P
  rect 2.007x3.505 smd: 1(0,0) 2(6,0)
TOKO_FDVE1040-H-5R6M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.8,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2560DRCR-PG1P1_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51218DSCR_SON10_3X3
  oval 0.279x0.813 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.925) 7(1.5,2.925) 8(1,2.925) 9(0.5,2.925) 10(0,2.925)
  custom 0.412x0.412 smd: 11(1,1.463)
TPS51461RGER_QFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.54x2.54 smd: 25(1.25,1.975)
TS3DV20812RHHR_VQFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
TS5A63157DCKR_SC70-6
  oval 0.381x1.372 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0.65,1.74) 6(0,1.74)
TYCO_1-2041070-6_16P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 2.489x1.905 smd: 17(2.15,3.3) 18(-9.65,3.3)
TYCO_2-2013289-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(-64.45,-16.1) 206(1.15,-16.1)
TYCO_2-2013290-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
TYCO_2-2013311-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 4.699x6.807 smd: 205(5.7,7.2) 206(-69,7.2)
TYCO_2041333-1_13P
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  round 1.397 hole 0.991: 9(-9.48,-1.48) 10(-10.63,-2.58) 11(-8.34,-2.58) 12(1.2,-2.58) 13(3.49,-2.58)
  oval 1.372x3.15 hole 0.61x2.388: 14(-11.57,-7.9) 15(4.43,-7.9)
TYCO_2134146-3_989P
  round 0.508 smd: A2(0,1) A3(0,2) A33(0,32) A34(0,33) A35(0,34) AP1(33,0) AP35(33,34) AR1(34,0) AR2(34,1) AR34(34,33) AR35(34,34) AT1(35,0) AT2(35,1) AT3(35,2) AT33(35,32) AT34(35,33) AT35(35,34) B1(1,0) B2(1,1) B34(1,33) B35(1,34) C1(2,0) C35(2,34)
  oval 0.61x0.457 smd: A4(0,3) A5(0,4) A6(0,5) A7(0,6) A8(0,7) A9(0,8) A10(0,9) A11(0,10) A12(0,11) A13(0,12) A14(0,13) A15(0,14) A16(0,15) A17(0,16) A18(0,17) A19(0,18) A20(0,19) A21(0,20) A22(0,21) A23(0,22) A24(0,23) A25(0,24) A26(0,25) A27(0,26) A28(0,27) A29(0,28) A30(0,29) A31(0,30) A32(0,31) AT4(35,3) AT5(35,4) AT6(35,5) AT7(35,6) AT8(35,7) AT9(35,8) AT10(35,9) AT11(35,10) AT12(35,11) AT13(35,12) AT14(35,13) AT15(35,14) AT16(35,15) AT17(35,16) AT18(35,17) AT19(35,18) AT20(35,19) AT21(35,20) AT22(35,21) AT23(35,22) AT24(35,23) AT25(35,24) AT26(35,25) AT27(35,26) AT28(35,27) AT29(35,28) AT30(35,29) AT31(35,30) AT32(35,31)
  oval 0.457x0.61 smd: AA1(20,0) AA35(20,34) AB1(21,0) AB35(21,34) AC1(22,0) AC35(22,34) AD1(23,0) AD35(23,34) AE1(24,0) AE35(24,34) AF1(25,0) AF35(25,34) AG1(26,0) AG35(26,34) AH1(27,0) AH35(27,34) AJ1(28,0) AJ35(28,34) AK1(29,0) AK35(29,34) AL1(30,0) AL35(30,34) AM1(31,0) AM35(31,34) AN1(32,0) AN35(32,34) D1(3,0) D35(3,34) E1(4,0) E35(4,34) F1(5,0) F35(5,34) G1(6,0) G35(6,34) H1(7,0) H35(7,34) J1(8,0) J35(8,34) K1(9,0) K35(9,34) L1(10,0) L35(10,34) M1(11,0) M35(11,34) N1(12,0) N35(12,34) P1(13,0) P35(13,34) R1(14,0) R35(14,34) T1(15,0) T35(15,34) U1(16,0) U35(16,34) V1(17,0) V35(17,34) W1(18,0) W35(18,34) Y1(19,0) Y35(19,34)
  round 0.457 smd: AA2(20,1) AA3(20,2) AA4(20,3) AA5(20,4) AA6(20,5) AA7(20,6) AA8(20,7) AA9(20,8) AA10(20,9) AB2(21,1) AB3(21,2) AB4(21,3) AB5(21,4) AB6(21,5) AB7(21,6) AB8(21,7) AB9(21,8) AB10(21,9) AB26(21,25) AB27(21,26) AB28(21,27) AB29(21,28) AB30(21,29) AB31(21,30) AB32(21,31) AB33(21,32) AB34(21,33) AC2(22,1) AC3(22,2) AC5(22,4) AC6(22,5) AC8(22,7) AC9(22,8) AD2(23,1) AD3(23,2) AD4(23,3) AD5(23,4) AD6(23,5) AD7(23,6) AD8(23,7) AD9(23,8) AD10(23,9) AE2(24,1) AE3(24,2) AE4(24,3) AE5(24,4) AE6(24,5) AE7(24,6) AE8(24,7) AE9(24,8) AE10(24,9) AE26(24,25) AE27(24,26) AE28(24,27) AE29(24,28) AE30(24,29) AE31(24,30) AE32(24,31) AE33(24,32) AE34(24,33) AF2(25,1) AF3(25,2) AF5(25,4) AF6(25,5) AF8(25,7) AF9(25,8) AG2(26,1) AG3(26,2) AG4(26,3) AG5(26,4) AG6(26,5) AG7(26,6) AG8(26,7) AG9(26,8) AG10(26,9) AH2(27,1) AH3(27,2) AH4(27,3) AH5(27,4) AH6(27,5) AH7(27,6) AH8(27,7) AH9(27,8) AH10(27,9) AH11(27,10) AH12(27,11) AH13(27,12) AH14(27,13) AH15(27,14) AH16(27,15) AH19(27,18) AH22(27,21) AH25(27,24) AH26(27,25) AH27(27,26) AH28(27,27) AH29(27,28) AH30(27,29) AH31(27,30) AH32(27,31) AH33(27,32) AH34(27,33) AJ2(28,1) AJ3(28,2) AJ4(28,3) AJ5(28,4) AJ6(28,5) AJ7(28,6) AJ8(28,7) AJ9(28,8) AJ10(28,9) AJ11(28,10) AJ12(28,11) AJ13(28,12) AJ14(28,13) AJ15(28,14) AJ16(28,15) AJ19(28,18) AJ22(28,21) AJ25(28,24) AJ26(28,25) AJ27(28,26) AJ28(28,27) AJ29(28,28) AJ30(28,29) AJ31(28,30) AJ32(28,31) AJ33(28,32) AJ34(28,33) AK2(29,1) AK3(29,2) AK4(29,3) AK5(29,4) AK6(29,5) AK7(29,6) AK8(29,7) AK9(29,8) AK10(29,9) AK11(29,10) AK12(29,11) AK13(29,12) AK14(29,13) AK15(29,14) AK16(29,15) AK19(29,18) AK22(29,21) AK25(29,24) AK26(29,25) AK27(29,26) AK28(29,27) AK29(29,28) AK30(29,29) AK31(29,30) AK32(29,31) AK33(29,32) AK34(29,33) AL2(30,1) AL3(30,2) AL4(30,3) AL5(30,4) AL6(30,5) AL7(30,6) AL8(30,7) AL9(30,8) AL10(30,9) AL11(30,10) AL12(30,11) AL13(30,12) AL14(30,13) AL15(30,14) AL16(30,15) AL19(30,18) AL22(30,21) AL25(30,24) AL26(30,25) AL27(30,26) AL28(30,27) AL29(30,28) AL30(30,29) AL31(30,30) AL32(30,31) AL33(30,32) AL34(30,33) AM2(31,1) AM3(31,2) AM4(31,3) AM5(31,4) AM6(31,5) AM7(31,6) AM8(31,7) AM9(31,8) AM10(31,9) AM11(31,10) AM12(31,11) AM13(31,12) AM14(31,13) AM15(31,14) AM16(31,15) AM19(31,18) AM22(31,21) AM25(31,24) AM26(31,25) AM27(31,26) AM28(31,27) AM29(31,28) AM30(31,29) AM31(31,30) AM32(31,31) AM33(31,32) AM34(31,33) AN2(32,1) AN3(32,2) AN4(32,3) AN5(32,4) AN6(32,5) AN7(32,6) AN8(32,7) AN9(32,8) AN10(32,9) AN11(32,10) AN12(32,11) AN13(32,12) AN14(32,13) AN15(32,14) AN16(32,15) AN19(32,18) AN22(32,21) AN25(32,24) AN26(32,25) AN27(32,26) AN28(32,27) AN29(32,28) AN30(32,29) AN31(32,30) AN32(32,31) AN33(32,32) AN34(32,33) AP2(33,1) AP3(33,2) AP4(33,3) AP5(33,4) AP6(33,5) AP7(33,6) AP8(33,7) AP9(33,8) AP10(33,9) AP11(33,10) AP12(33,11) AP13(33,12) AP14(33,13) AP15(33,14) AP16(33,15) AP19(33,18) AP22(33,21) AP25(33,24) AP26(33,25) AP27(33,26) AP28(33,27) AP29(33,28) AP30(33,29) AP31(33,30) AP32(33,31) AP33(33,32) AP34(33,33) AR3(34,2) AR4(34,3) AR5(34,4) AR6(34,5) AR7(34,6) AR8(34,7) AR9(34,8) AR10(34,9) AR11(34,10) AR12(34,11) AR13(34,12) AR14(34,13) AR15(34,14) AR16(34,15) AR19(34,18) AR22(34,21) AR25(34,24) AR26(34,25) AR27(34,26) AR28(34,27) AR29(34,28) AR30(34,29) AR31(34,30) AR32(34,31) AR33(34,32) B3(1,2) B4(1,3) B5(1,4) B6(1,5) B7(1,6) B8(1,7) B9(1,8) B10(1,9) B11(1,10) B12(1,11) B13(1,12) B14(1,13) B15(1,14) B16(1,15) B17(1,16) B18(1,17) B19(1,18) B20(1,19) B21(1,20) B22(1,21) B23(1,22) B24(1,23) B25(1,24) B26(1,25) B27(1,26) B28(1,27) B29(1,28) B30(1,29) B31(1,30) B32(1,31) B33(1,32) C2(2,1) C3(2,2) C4(2,3) C5(2,4) C6(2,5) C7(2,6) C8(2,7) C9(2,8) C10(2,9) C11(2,10) C12(2,11) C13(2,12) C14(2,13) C15(2,14) C16(2,15) C17(2,16) C18(2,17) C19(2,18) C20(2,19) C21(2,20) C22(2,21) C23(2,22) C24(2,23) C25(2,24) C26(2,25) C27(2,26) C28(2,27) C29(2,28) C30(2,29) C31(2,30) C32(2,31) C33(2,32) C34(2,33) D2(3,1) D3(3,2) D4(3,3) D5(3,4) D6(3,5) D7(3,6) D8(3,7) D9(3,8) D10(3,9) D11(3,10) D12(3,11) D13(3,12) D14(3,13) D15(3,14) D16(3,15) D17(3,16) D18(3,17) D19(3,18) D20(3,19) D21(3,20) D22(3,21) D23(3,22) D24(3,23) D25(3,24) D26(3,25) D27(3,26) D28(3,27) D29(3,28) D30(3,29) D31(3,30) D32(3,31) D33(3,32) D34(3,33) E2(4,1) E3(4,2) E4(4,3) E5(4,4) E6(4,5) E7(4,6) E8(4,7) E9(4,8) E10(4,9) E11(4,10) E12(4,11) E13(4,12) E14(4,13) E15(4,14) E16(4,15) E17(4,16) E18(4,17) E19(4,18) E20(4,19) E21(4,20) E22(4,21) E23(4,22) E24(4,23) E25(4,24) E26(4,25) E27(4,26) E28(4,27) E29(4,28) E30(4,29) E31(4,30) E32(4,31) E33(4,32) E34(4,33) F2(5,1) F3(5,2) F4(5,3) F5(5,4) F6(5,5) F7(5,6) F8(5,7) F9(5,8) F10(5,9) F11(5,10) F12(5,11) F13(5,12) F14(5,13) F15(5,14) F16(5,15) F17(5,16) F18(5,17) F19(5,18) F20(5,19) F21(5,20) F22(5,21) F23(5,22) F24(5,23) F25(5,24) F26(5,25) F27(5,26) F28(5,27) F29(5,28) F30(5,29) F31(5,30) F32(5,31) F33(5,32) F34(5,33) G2(6,1) G3(6,2) G4(6,3) G5(6,4) G6(6,5) G7(6,6) G8(6,7) G9(6,8) G10(6,9) G11(6,10) G12(6,11) G13(6,12) G14(6,13) G15(6,14) G16(6,15) G17(6,16) G18(6,17) G19(6,18) G20(6,19) G21(6,20) G22(6,21) G23(6,22) G24(6,23) G25(6,24) G26(6,25) G27(6,26) G28(6,27) G29(6,28) G30(6,29) G31(6,30) G32(6,31) G33(6,32) G34(6,33) H2(7,1) H3(7,2) H4(7,3) H5(7,4) H6(7,5) H7(7,6) H8(7,7) H9(7,8) H10(7,9) H11(7,10) H12(7,11) H13(7,12) H14(7,13) H15(7,14) H16(7,15) H17(7,16) H18(7,17) H19(7,18) H20(7,19) H21(7,20) H22(7,21) H23(7,22) H24(7,23) H25(7,24) H26(7,25) H27(7,26) H28(7,27) H29(7,28) H30(7,29) H31(7,30) H32(7,31) H33(7,32) H34(7,33) J2(8,1) J3(8,2) J4(8,3) J5(8,4) J6(8,5) J7(8,6) J8(8,7) J9(8,8) J10(8,9) J11(8,10) J12(8,11) J13(8,12) J14(8,13) J15(8,14) J16(8,15) J17(8,16) J18(8,17) J19(8,18) J20(8,19) J21(8,20) J22(8,21) J23(8,22) J24(8,23) J25(8,24) J26(8,25) J27(8,26) J28(8,27) J29(8,28) J30(8,29) J31(8,30) J32(8,31) J33(8,32) J34(8,33) K2(9,1) K3(9,2) K4(9,3) K5(9,4) K6(9,5) K7(9,6) K8(9,7) K9(9,8) K10(9,9) K26(9,25) K27(9,26) K28(9,27) K29(9,28) K30(9,29) K31(9,30) K32(9,31) K33(9,32) K34(9,33) L2(10,1) L3(10,2) L4(10,3) L5(10,4) L6(10,5) L7(10,6) L8(10,7) L9(10,8) L10(10,9) L26(10,25) L27(10,26) L28(10,27) L29(10,28) L30(10,29) L31(10,30) L32(10,31) L33(10,32) L34(10,33) M2(11,1) M3(11,2) M4(11,3) M5(11,4) M6(11,5) M7(11,6) M8(11,7) M9(11,8) M10(11,9) M26(11,25) M27(11,26) M28(11,27) M29(11,28) M30(11,29) M31(11,30) M32(11,31) M33(11,32) M34(11,33) N2(12,1) N3(12,2) N4(12,3) N5(12,4) N6(12,5) N7(12,6) N8(12,7) N9(12,8) N10(12,9) N26(12,25) N27(12,26) N28(12,27) N29(12,28) N30(12,29) N31(12,30) N32(12,31) N33(12,32) N34(12,33) P2(13,1) P3(13,2) P5(13,4) P6(13,5) P8(13,7) P9(13,8) R2(14,1) R3(14,2) R4(14,3) R5(14,4) R6(14,5) R7(14,6) R8(14,7) R9(14,8) R10(14,9) T2(15,1) T3(15,2) T4(15,3) T5(15,4) T6(15,5) T7(15,6) T8(15,7) T9(15,8) T10(15,9) T26(15,25) T27(15,26) T28(15,27) T29(15,28) T30(15,29) T31(15,30) T32(15,31) T33(15,32) T34(15,33) U2(16,1) U3(16,2) U5(16,4) U6(16,5) U8(16,7) U9(16,8) V2(17,1) V3(17,2) V4(17,3) V5(17,4) V6(17,5) V7(17,6) V8(17,7) V9(17,8) V10(17,9) W2(18,1) W3(18,2) W4(18,3) W5(18,4) W6(18,5) W7(18,6) W8(18,7) W9(18,8) W10(18,9) W26(18,25) W27(18,26) W28(18,27) W29(18,28) W30(18,29) W31(18,30) W32(18,31) W33(18,32) W34(18,33) Y2(19,1) Y3(19,2) Y5(19,4) Y6(19,5) Y8(19,7) Y9(19,8)
  round 0.66 smd: AA26(20,25) AA27(20,26) AA28(20,27) AA29(20,28) AA30(20,29) AA31(20,30) AA32(20,31) AA33(20,32) AA34(20,33) AC4(22,3) AC7(22,6) AC10(22,9) AC26(22,25) AC27(22,26) AC28(22,27) AC29(22,28) AC30(22,29) AC31(22,30) AC32(22,31) AC33(22,32) AC34(22,33) AD26(23,25) AD27(23,26) AD28(23,27) AD29(23,28) AD30(23,29) AD31(23,30) AD32(23,31) AD33(23,32) AD34(23,33) AF4(25,3) AF7(25,6) AF10(25,9) AF26(25,25) AF27(25,26) AF28(25,27) AF29(25,28) AF30(25,29) AF31(25,30) AF32(25,31) AF33(25,32) AF34(25,33) AG26(26,25) AG27(26,26) AG28(26,27) AG29(26,28) AG30(26,29) AG31(26,30) AG32(26,31) AG33(26,32) AG34(26,33) AH17(27,16) AH18(27,17) AH20(27,19) AH21(27,20) AH23(27,22) AH24(27,23) AJ17(28,16) AJ18(28,17) AJ20(28,19) AJ21(28,20) AJ23(28,22) AJ24(28,23) AK17(29,16) AK18(29,17) AK20(29,19) AK21(29,20) AK23(29,22) AK24(29,23) AL17(30,16) AL18(30,17) AL20(30,19) AL21(30,20) AL23(30,22) AL24(30,23) AM17(31,16) AM18(31,17) AM20(31,19) AM21(31,20) AM23(31,22) AM24(31,23) AN17(32,16) AN18(32,17) AN20(32,19) AN21(32,20) AN23(32,22) AN24(32,23) AP17(33,16) AP18(33,17) AP20(33,19) AP21(33,20) AP23(33,22) AP24(33,23) AR17(34,16) AR18(34,17) AR20(34,19) AR21(34,20) AR23(34,22) AR24(34,23) P4(13,3) P7(13,6) P10(13,9) P26(13,25) P27(13,26) P28(13,27) P29(13,28) P30(13,29) P31(13,30) P32(13,31) P33(13,32) P34(13,33) R26(14,25) R27(14,26) R28(14,27) R29(14,28) R30(14,29) R31(14,30) R32(14,31) R33(14,32) R34(14,33) U4(16,3) U7(16,6) U10(16,9) U26(16,25) U27(16,26) U28(16,27) U29(16,28) U30(16,29) U31(16,30) U32(16,31) U33(16,32) U34(16,33) V26(17,25) V27(17,26) V28(17,27) V29(17,28) V30(17,29) V31(17,30) V32(17,31) V33(17,32) V34(17,33) Y4(19,3) Y7(19,6) Y10(19,9) Y26(19,25) Y27(19,26) Y28(19,27) Y29(19,28) Y30(19,29) Y31(19,30) Y32(19,31) Y33(19,32) Y34(19,33)
