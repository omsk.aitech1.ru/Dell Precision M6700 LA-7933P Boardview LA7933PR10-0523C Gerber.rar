# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CLK_DDR#1: length 67.4
  TOP w0.089: JCPU1.AB5 95.9,62.39 95.43,61.92 v3(95.4,61.92)
  IN1 w0.089: v3(95.4,61.92) 95.41,61.92 95.61,61.73 95.61,61.43 95.52,61.34 95.36,61.34 95.01,61.7 95.01,62.25 95.06,62.31 95.6,62.31 96.22,62.93 96.83,62.93 97.25,63.35 97.66,63.35 98.62,64.32 100.96,64.32 101.42,64.78 104.49,64.78
  IN1 w0.109: v1(139.79,52.42) 140.06,52.68 140.06,52.94 140.25,53.13 143.06,53.13 143.25,52.94 143.25,52.49 143.38,52.36 143.62,52.36 143.75,52.49 143.75,53.51 143.62,53.63 132.33,53.63 132.21,53.76 131.57,53.76 130.8,54.53 129.67,54.53 128.97,55.23 126.06,55.23 117.37,63.91 113.6,63.91 112.74,64.78 104.49,64.78
  BOTTOM w0.099: JDIMM2.104 141.94,53.8 141.75,53.61 141.5,53.61 141.26,53.37 140.3,53.37 140.09,53.16 140.09,52.6 139.91,52.42 v1(139.79,52.42)
M_CLK_DDR#2: length 84.1
  TOP w0.089: v1(99.4,63.92) 98.9,64.42 JCPU1.AD2
  IN3 w0.089: v1(99.4,63.92) 99.44,63.95 99.44,64.03 99.36,64.11 99.22,64.11 99.02,63.91 99.02,63.68 99.19,63.51 100.82,63.51 101.91,64.6 104.49,64.6
  IN3 w0.094: 104.49,64.6 109.91,64.6 115.95,58.56 116.28,58.56 116.39,58.45 116.39,58.43 116.64,58.18 116.65,58.18 117.69,57.14 120.86,57.14 121.68,56.32 121.68,55.35 122.27,54.75 122.86,54.75 123.04,54.57 123.04,54.28 123.16,54.15 123.77,54.15 123.9,54.28 123.9,54.45 124.08,54.62 124.39,54.62 124.44,54.67 124.44,54.85 124.67,55.09 125.05,55.09 125.29,54.85 125.29,54.65 125.38,54.56 125.66,54.56 125.76,54.65 125.76,54.95 125.96,55.16 126.4,55.16 126.61,54.95 126.61,54.65 126.7,54.56 126.98,54.56 127.08,54.65 127.08,54.95 127.28,55.16 127.72,55.16 127.93,54.95 127.93,54.65 128.02,54.56 128.3,54.56 128.4,54.65 128.4,54.95 128.6,55.16 129.04,55.16 129.25,54.95 129.25,54.65 129.34,54.56 129.62,54.56 129.72,54.65 129.72,54.95 129.92,55.16 130.36,55.16 130.57,54.95 130.57,54.65 130.66,54.56 130.95,54.56 131.04,54.65 131.04,54.95 131.25,55.16 131.69,55.16 131.89,54.95 131.89,54.65 131.98,54.56 132.27,54.56 132.36,54.65 132.36,54.95 132.57,55.16 133.01,55.16 133.21,54.95 133.21,54.65 133.31,54.56 133.7,54.56 133.8,54.65 133.8,55.46 134.04,55.7 134.41,55.7 134.65,55.46 134.65,54.49 134.78,54.36 134.99,54.36 135.12,54.49 135.12,55.46 135.36,55.7 135.73,55.7 135.97,55.46 135.97,54.57 136.1,54.45 136.41,54.45 136.53,54.57 136.53,54.74 136.77,54.98 141.31,54.98 142.17,54.13 143.27,54.13 143.46,53.93 143.46,53.49 143.59,53.36 143.81,53.36 143.93,53.49 143.93,53.94 144.14,54.15 149.53,54.15 149.77,53.91 149.77,53.33 149.9,53.2 150.11,53.2 150.24,53.33 150.24,53.82 150.48,54.06 154.32,54.06 154.6,53.78 154.6,53.31 154.78,53.14 v1(154.97,53.14)
  BOTTOM w0.099: JDIMM4.103 150.07,53.5 150.26,53.31 150.4,53.31 150.67,53.58 150.67,53.79 150.87,53.98 154.4,53.98 154.74,53.65 154.74,53.37 v1(154.97,53.14)
M_CLK_DDR#3: length 84.6
  TOP w0.089: JCPU1.AD1 99.9,64.42 v3(100.4,63.92)
  IN3 w0.089: 104.49,65.03 101.48,65.03 100.8,64.34 100.77,64.32 100.27,64.32 100.15,64.2 100.15,64.04 100.27,63.92 v3(100.4,63.92)
  IN3 w0.094: v1(160.22,54.22) 160.44,54.22 160.56,54.35 160.56,55.64 160.44,55.77 160.03,55.77 159.9,55.64 159.9,54.91 159.67,54.67 159.25,54.67 159.02,54.91 159.02,55.28 158.89,55.41 158.63,55.41 158.51,55.28 158.51,53.8 158.3,53.59 157.86,53.59 157.66,53.8 157.66,54.65 157.53,54.78 157.31,54.78 157.19,54.65 157.19,53.8 156.98,53.59 156.54,53.59 156.33,53.8 156.33,54.6 156.21,54.72 155.99,54.72 155.87,54.6 155.87,53.8 155.66,53.59 155.22,53.59 155.01,53.8 155.01,54.3 154.86,54.46 150.56,54.46 150.47,54.55 142.33,54.55 141.48,55.39 136.6,55.39 135.9,56.1 133.24,56.1 132.7,55.55 123.95,55.55 123.61,55.21 122.49,55.21 122.27,55.43 122.08,55.62 122.08,56.48 120.93,57.63 119.02,57.63 118.78,57.86 118.78,58.24 119.02,58.48 120.19,58.48 120.32,58.6 120.32,58.93 120.19,59.06 119.17,59.06 118.97,59.26 118.97,59.74 118.44,60.27 114.81,60.27 110.05,65.03 104.49,65.03
  BOTTOM w0.099: JDIMM4.104 158.44,53.8 158.63,53.61 160.4,53.61 160.48,53.68 160.48,53.97 v1(160.22,54.22)
M_CLK_DDR#4: length 66.7
  TOP w0.089: v3(96.4,60.92) 96.4,60.92 96.9,61.42 JCPU1.AA4
  TOP w0.099: v1(137.51,52.42) 137.74,52.65 137.74,52.74 137.61,52.87 137.61,53.2 137.84,53.43 138.17,53.43 138.51,53.1 141.55,53.1 141.76,53.31 141.91,53.31 142.11,53.5 JDIMM1.103
  IN1 w0.089: v3(96.4,60.92) 96.4,60.92 96.31,60.92 96.23,61 96.23,61.18 96.38,61.33 96.56,61.33 96.62,61.39 96.75,61.39 96.8,61.34 96.8,60.53 97,60.33 97.73,60.33 97.83,60.23 97.83,59.94 98.02,59.76 98.36,59.76 98.57,59.97 98.57,60.22 99,60.65 99,61.24 99.08,61.32 99.73,61.32
  IN1 w0.109: v1(137.51,52.42) 137.66,52.42 137.85,52.61 137.85,52.87 137.73,53 136.4,53 136.33,52.93 136.33,52.65 136.07,52.4 135.68,52.4 135.42,52.65 135.42,52.87 135.29,53 134.94,53 134.81,52.87 134.81,52.65 134.56,52.4 134.07,52.4 133.81,52.65 133.81,52.9 133.72,53 133.34,53 133.27,52.93 133.27,52.85 133.09,52.66 129.9,52.66 129.82,52.58 129.82,52.41 129.56,52.15 129.04,52.15 128.78,52.41 128.78,52.54 128.66,52.66 128.26,52.66 128.13,52.54 128.13,52.41 127.87,52.15 127.39,52.15 127.14,52.41 127.14,52.54 127.01,52.66 126.72,52.66 126.59,52.54 126.59,52.41 126.33,52.15 125.85,52.15 125.6,52.41 125.6,52.54 125.47,52.66 123.92,52.66 123.69,52.89 123.69,53.17 123.45,53.41 123.17,53.41 122.82,53.76 122.82,54.43 122.68,54.57 122.01,54.57 121.68,54.91 120.6,54.91 120.14,55.36 120.14,56.01 120.05,56.1 119.4,56.1 119.19,56.32 119.18,56.32 119,56.32 118.79,56.52 118.79,56.71 118.79,56.78 118.64,56.92 118.38,56.92 118.31,56.86 118.31,56.51 118.12,56.32 117.85,56.32 117.41,56.76 117.41,57.12 116.71,57.83 116.34,57.83 114.69,59.48 114.69,59.8 114.92,60.03 115.1,60.03 115.23,60.16 115.23,60.34 115.1,60.47 114.72,60.47 114.36,60.11 114.06,60.11 113.4,60.77 113.4,61.05 113.34,61.11 104.11,61.11 103.93,61.3 103.65,61.3 103.58,61.23 103.58,61.05 103.39,60.86 102.91,60.86 102.68,61.09 102.68,61.74 102.59,61.83 102.25,61.83 102.14,61.73 102.14,61.11 101.87,60.85 101.4,60.85 101.14,61.1 101.14,61.73 101.03,61.83 100.23,61.83 100.15,61.76 100.15,61.54 99.93,61.32 99.73,61.32
M_CLK_DDR#5: length 65.9
  TOP w0.089: v1(97.4,60.92) 97.4,61.12 97.73,61.45 JCPU1.AA3
  TOP w0.099: JDIMM1.104 133.73,53.8 133.6,53.67 132.88,53.67 132.54,54.01 129.23,54.01 129.03,53.81 129.03,53.65 v3(128.7,53.32)
  IN1 w0.089: v1(97.4,60.92) 97.31,61.02 97.31,61.3 97.38,61.38 97.8,61.38 97.99,61.57 97.99,62.08 98.23,62.32 99.22,62.32 99.23,62.33 99.56,62.33 99.57,62.32 100.79,62.32 100.85,62.26 102.9,62.26 102.96,62.19
  IN1 w0.109: v3(128.7,53.32) 128.7,53.63 128.38,53.95 127.89,53.95 127.59,53.66 127,53.66 126.7,53.95 125.05,53.95 124.86,53.76 124.05,53.76 123.84,53.97 123.84,54.38 124.09,54.63 124.3,54.63 124.46,54.79 124.46,55.02 124.27,55.21 122.31,55.21 121.97,55.54 121.03,55.54 120.78,55.8 120.78,56.16 121.03,56.41 121.71,56.41 121.84,56.54 121.84,56.75 121.71,56.87 121.02,56.87 120.81,57.09 120.81,57.64 120.68,57.77 120.45,57.77 120.32,57.64 120.32,57 120.06,56.74 119.66,56.74 119.41,57 119.41,57.41 119.3,57.52 119.07,57.52 118.84,57.75 118.84,58.54 119.08,58.77 119.57,58.77 119.73,58.62 120.15,58.62 120.28,58.75 120.28,59.03 120.15,59.16 119.78,59.16 119.58,59.35 119.58,59.7 119.51,59.78 118.93,59.78 118.71,59.99 118.71,60.72 118.61,60.82 118.27,60.82 118.2,60.75 118.2,60.37 117.94,60.11 117.54,60.11 117.28,60.37 117.28,60.64 117.15,60.77 116.96,60.77 116.83,60.64 116.83,60.55 116.58,60.29 116.11,60.29 115.85,60.55 115.85,61.82 116.11,62.08 116.84,62.08 116.97,62.2 116.97,62.51 116.84,62.64 115.05,62.64 114.92,62.51 114.92,61.36 114.67,61.11 114.24,61.11 113.99,61.36 113.99,62.51 113.86,62.64 113.51,62.64 113.38,62.51 113.38,62.01 113.12,61.75 112.59,61.75 112.34,62.01 112.34,63.38 112.21,63.51 111.86,63.51 111.73,63.38 111.73,62.01 111.47,61.75 104.05,61.75 103.61,62.19 102.96,62.19
M_CLK_DDR#6: length 83.2
  TOP w0.089: v3(98.39,60.92) 98.4,60.92 98.9,61.42 JCPU1.AA2
  TOP w0.099: JDIMM3.103 158.37,53.5 158.53,53.34 160.39,53.34 160.73,53 160.73,52.64 v1(160.95,52.43)
  IN3 w0.089: 104.49,62.53 103.04,62.53 100.84,60.33 99.07,60.33 99.06,60.32 99.04,60.32 98.81,60.55 98.81,61.2 98.7,61.32 98.47,61.32 98.39,61.24 v3(98.39,60.92)
  IN3 w0.094: 104.49,62.53 109.43,62.53 116.33,55.62 118.3,55.62 119.51,54.41 120.29,54.41 120.93,53.77 121.31,53.77 122.38,52.7 131.75,52.7 132.43,52.03 135.75,52.03 136.72,53 141.36,53 142.55,51.8 152.38,51.8 153.07,52.49 156.79,52.49 157,52.69 157,52.88 157.12,53.01 157.34,53.01 157.47,52.88 157.47,50.79 157.7,50.55 158.08,50.55 158.32,50.79 158.32,52.88 158.44,53.01 158.66,53.01 158.79,52.88 158.79,51.13 159.03,50.89 160.48,50.89 160.72,51.13 160.72,52.2 v1(160.95,52.43)
M_CLK_DDR#7: length 81.5
  TOP w0.089: v3(99.39,61.93) 99.39,61.93 99.9,62.44 JCPU1.AB1
  TOP w0.099: v1(151.92,53.14) 152.12,52.93 152.12,52.67 151.97,52.52 150.68,52.52 150.51,52.69 150.51,53.52 150.22,53.8 JDIMM3.104
  IN3 w0.089: 104.49,63.31 104.47,63.31 104.47,63.3 104.42,63.3 104.41,63.3 102.87,63.3 101.1,61.53 99.58,61.53 99.58,61.54 99.4,61.54 99.29,61.65 99.29,61.82 v3(99.39,61.93)
  IN3 w0.094: 104.49,63.31 105.64,63.31 105.77,63.43 105.77,63.77 106.01,64.01 106.38,64.01 106.62,63.77 106.62,63.4 106.71,63.31 106.99,63.31 107.09,63.4 107.09,63.77 107.33,64.01 107.7,64.01 107.94,63.77 107.94,63.43 108.07,63.31 108.28,63.31 108.41,63.43 108.41,63.77 108.65,64.01 109.1,64.01 109.34,63.77 109.34,63.51 109.41,63.44 110.24,63.44 110.44,63.24 110.44,62.97 110.36,62.89 110.36,62.71 110.58,62.5 110.76,62.5 110.8,62.54 111.14,62.54 111.4,62.27 111.4,61.94 111.35,61.89 111.35,61.71 111.5,61.55 111.68,61.55 111.73,61.6 112.07,61.6 112.34,61.34 112.34,61 112.31,60.97 112.26,60.93 112.26,60.8 112.46,60.6 112.59,60.6 112.67,60.67 113.01,60.67 113.27,60.41 113.27,60.07 113.22,60.02 113.22,59.84 113.37,59.69 113.55,59.69 113.6,59.74 113.94,59.74 114.2,59.47 114.2,59.13 114.13,59.06 114.13,58.93 114.33,58.73 114.46,58.73 114.51,58.77 114.54,58.8 114.87,58.8 115.14,58.54 115.14,58.2 115.06,58.13 115.06,57.99 115.26,57.79 115.4,57.79 115.57,57.97 115.91,57.97 116.17,57.7 116.17,57.36 116.04,57.24 116,57.19 116,57.06 116.2,56.86 116.33,56.86 116.57,57.09 116.9,57.09 117.17,56.83 117.17,56.57 117.34,56.4 119.43,56.4 119.71,56.12 119.71,55.32 119.83,55.19 120.05,55.19 120.18,55.32 120.18,55.95 120.42,56.19 120.85,56.19 121.09,55.95 121.09,54.72 121.26,54.55 121.64,54.55 122.12,54.07 122.41,54.07 122.57,53.91 122.57,53.68 122.7,53.56 124.01,53.56 124.42,53.96 132.45,53.96 132.68,53.73 132.68,52.94 132.8,52.81 133.04,52.81 133.17,52.94 133.17,53.73 133.41,53.97 133.81,53.97 134.05,53.73 134.05,52.94 134.17,52.81 134.39,52.81 134.52,52.94 134.52,53.54 134.75,53.77 135.13,53.77 135.37,53.54 135.37,53.22 135.49,53.09 135.71,53.09 135.84,53.22 135.84,53.57 136.04,53.77 141.69,53.77 141.97,53.49 142.66,53.49 142.86,53.29 142.86,52.71 142.98,52.59 146.87,52.59 146.99,52.72 146.99,53.06 147.23,53.3 147.61,53.3 147.85,53.06 147.85,52.71 147.97,52.58 148.19,52.58 148.31,52.71 148.31,53.32 148.55,53.56 148.93,53.56 149.17,53.32 149.17,52.77 149.35,52.59 152.07,52.59 152.28,52.81 152.28,52.95 152.1,53.14 v1(151.92,53.14)
M_ID2#: length 7.5
  TOP w0.102: v1(66.24,171.22) 66.29,171.17 66.29,169.32 67.66,167.95 C15.1
  BOTTOM w0.102: JCRT1.4 63.89,172.96 64.65,172.2 65.26,172.2 v2(65.71,171.76) v1(66.24,171.22)
M_ODT0: length 54.9
  TOP w0.089: v1(98.4,68.92) 97.93,68.45 JCPU1.AH3
  IN1 w0.089: 104.49,72.76 104.32,72.76 103.91,72.35 102.59,72.35 100.77,70.54 99.73,70.54 99.6,70.4 99.32,70.4 98.9,69.98 98.9,69.41 v1(98.4,68.92)
  IN1 w0.178: v1(140.05,60.79) 140.05,60.87 138.91,62.01 135.33,62.01 133.91,63.42 132.36,63.42 131.97,63.81 131.97,63.88 130.26,65.58 129.07,65.58 121.65,73.01 118.09,73.01 117.8,73.3 111.17,73.3 110.63,72.76 104.49,72.76
  BOTTOM w0.102: v1(140.05,60.79) 140.55,60.28 140.55,59.83 141.83,58.55 141.83,57.87 142.31,57.4 JDIMM2.116
M_ODT1: length 55
  TOP w0.089: JCPU1.AG3 97.93,67.45 v3(98.4,67.92)
  IN1 w0.089: 104.49,71.79 102.64,71.79 100.92,70.07 100.92,69.54 100.23,68.85 99.96,68.85 99.6,68.5 99.2,68.5 99.14,68.56 98.69,68.56 98.4,68.27 v3(98.4,67.92)
  IN1 w0.178: v1(141.32,60.79) 141.15,60.62 141.15,60.59 140.86,60.3 138.58,60.3 137.84,61.04 134.93,61.04 133.51,62.46 131.33,62.46 129.87,63.92 128.43,63.92 128.07,64.27 128.07,64.53 128.29,64.74 128.29,65 128.04,65.25 127.79,65.25 127.57,65.03 127.32,65.03 120.56,71.79 104.49,71.79
  BOTTOM w0.102: v1(141.32,60.79) 141.6,60.5 141.6,59.35 142.35,58.6 JDIMM2.120
M_ODT2: length 86.3
  TOP w0.089: v5(96.23,65.94) 96.72,65.45 JCPU1.AE4
  IN3 w0.089: 104.49,71.33 103.07,71.33 101.26,69.52 96.98,69.52 96.84,69.38 96.84,68.43 96.74,68.33 96.24,68.33 96,68.08 96,67.58 95.73,67.31 95.73,66.27 96.08,65.92 96.23,65.92 96.25,65.94 v5(96.23,65.94)
  IN3 w0.152: v1(161.93,59.77) 161.93,59.03 161.8,58.9 161.27,58.9 161.14,59.03 161.14,59.21 161.02,59.34 160.66,59.34 160.53,59.21 160.53,59.03 160.41,58.9 160.02,58.9 159.9,59.03 159.9,59.19 159.77,59.31 159.41,59.31 159.29,59.19 159.29,59.03 159.16,58.9 157.55,58.9 157.02,59.44 157.02,59.53 156.89,59.65 156.69,59.65 156.56,59.78 156.56,60.3 156.69,60.43 156.89,60.43 157.02,60.55 157.02,60.91 156.89,61.04 149.03,61.04 147.32,62.75 144.23,62.75 141.81,65.18 136.22,65.18 135.15,66.24 133.65,66.24 133.13,65.72 132.51,65.72 131.99,66.24 127.25,66.24 126.73,65.72 125.97,65.72 125.45,66.24 122.47,66.24 117.39,71.32 114.95,71.32 114.94,71.33 104.49,71.33
  BOTTOM w0.102: JDIMM4.116 158.38,57.4 160.28,59.3 161.38,59.3 161.85,59.77 v1(161.93,59.77)
M_ODT3: length 83.2
  TOP w0.089: JCPU1.AD4 96.9,64.43 v3(96.39,63.92)
  IN3 w0.089: 104.49,71.79 102.98,71.79 101.51,70.32 97.22,70.32 96,69.1 96,68.35 95.8,68.15 95.8,67.65 95,66.85 95,65.59 94.84,65.42 94.84,63.63 94.96,63.51 96.28,63.51 96.39,63.62 v3(96.39,63.92)
  IN3 w0.152: v1(158.88,59.77) 158.88,59.63 158.75,59.5 157.6,59.5 157.48,59.63 157.48,60.25 157.6,60.38 158.06,60.38 158.19,60.51 158.19,60.89 158.06,61.01 157.54,61.01 157.41,61.14 157.41,61.38 157.29,61.51 149.27,61.51 147.58,63.21 144.42,63.21 141.98,65.65 136.4,65.65 135.34,66.7 127.06,66.7 126.54,66.18 126.16,66.18 125.64,66.7 122.66,66.7 117.57,71.79 104.49,71.79
  BOTTOM w0.165: v1(158.88,59.77) 158.88,59.45 158.96,59.37 158.96,58.87 158.7,58.6 JDIMM4.120
M_ODT4: length 53
  TOP w0.089: JCPU1.AG2 98.9,67.4 99.38,66.92 v3(99.4,66.92)
  TOP w0.165: v1(136.28,58.35) 136.28,58.17 136.41,58.04 136.5,58.04 136.63,57.91 136.63,57.53 136.5,57.4 JDIMM1.116
  IN1 w0.089: v3(99.4,66.92) 99.4,66.88 99.53,66.75 99.72,66.75 99.84,66.88 99.84,67.43 99.97,67.55 100.14,67.55 100.27,67.43 100.27,66.91 100.39,66.78 100.58,66.78 100.7,66.91 100.7,66.96 100.83,67.09 100.91,67.09 101.04,67.21 101.04,67.33 100.91,67.45 100.87,67.45 100.75,67.58 100.75,67.66 100.8,67.71 100.8,67.95 100.93,68.08 101.11,68.08 101.2,67.99 101.2,67.77 101.3,67.67 102.76,67.67 102.84,67.74 102.84,68.7 102.76,68.78 102.7,68.78 102.6,68.88 102.6,69.03 102.7,69.13 102.76,69.13 102.84,69.21 102.84,69.29 102.94,69.4 103.09,69.4 103.19,69.29 103.19,68.17 103.28,68.08 103.46,68.08 103.59,68.21 103.59,68.46 103.8,68.67 103.8,68.8 103.59,69.01 103.59,69.17 103.65,69.24 104.35,69.24 104.49,69.38
  IN1 w0.178: 104.49,69.38 114.64,69.38 115.11,68.91 117.59,68.91 118.01,69.34 118.49,69.34 118.92,68.91 120.02,68.91 127.46,61.47 128.89,61.47 130.54,59.82 130.88,59.82 131.58,59.12 133.43,59.12 134.21,58.35 135.49,58.35 135.72,58.58 136.05,58.58 v1(136.28,58.35)
M_ODT5: length 58
  TOP w0.089: v1(99.4,67.92) 98.9,68.42 JCPU1.AH2
  TOP w0.102: JDIMM1.120 135.7,58.6 136.54,59.44 140.04,59.44 140.17,59.31 140.17,58.43 v1(140.09,58.35)
  IN1 w0.089: v1(99.4,67.92) 99.41,67.93 99.42,67.92 99.53,67.92 100.11,68.5 100.38,68.5 101.52,69.64 101.52,69.76 101.4,69.89 101.4,70.01 101.52,70.14 101.65,70.14 101.77,70.02 101.9,70.02 102.02,70.14 102.02,70.27 101.9,70.39 101.9,70.52 102.03,70.64 102.15,70.64 102.24,70.55 102.42,70.55 102.51,70.64 102.51,70.89 102.6,70.98 102.78,70.98 102.87,70.89 102.87,70.64 102.96,70.55 103.13,70.55 103.22,70.64 103.22,70.89 103.31,70.98 103.49,70.98 103.58,70.89 103.58,70.66 103.69,70.55 103.84,70.55 103.95,70.66 103.95,70.88 104.03,70.96 104.27,70.96 104.4,70.83 104.49,70.83
  IN1 w0.178: 104.49,70.83 120.15,70.83 128.03,62.95 129.47,62.95 131.15,61.27 131.48,61.27 131.72,61.03 133.58,61.03 134.53,60.08 136.85,60.08 137.11,59.82 137.6,59.82 138.08,59.34 138.78,59.34 138.89,59.23 138.89,58.99 139.03,58.85 139.22,58.85 139.65,59.28 139.77,59.28 140.28,58.77 140.28,58.54 v1(140.09,58.35)
M_ODT6: length 78.5
  TOP w0.089: v5(95.4,63.92) 95.4,64.33 95.52,64.45 JCPU1.AD5
  TOP w0.102: JDIMM3.116 151.07,57.4 152.45,58.78 152.86,58.78 v1(153.29,59.21)
  IN3 w0.089: v5(95.4,63.92) 95.4,64.37 95.79,64.76 95.79,65.2 95.92,65.33 96.68,65.33 96.8,65.46 96.8,67.14 98.19,68.52 101.21,68.52 103.11,70.42 104.49,70.42
  IN3 w0.152: v1(153.29,59.21) 153.29,59.54 153.42,59.67 154.67,59.67 154.8,59.8 154.8,60 154.67,60.13 148.55,60.13 146.84,61.83 143.86,61.83 142.3,63.39 142.16,63.39 142.04,63.26 142.04,63.09 141.91,62.97 141.65,62.97 141.53,63.09 141.53,63.26 141.4,63.39 136.64,63.39 136.44,63.59 135.94,63.59 135.8,63.73 135.8,64.23 134.7,65.33 134.03,65.33 133.51,64.81 132.13,64.81 131.61,65.33 127.66,65.33 127.53,65.2 127.53,64.94 127.4,64.81 125.59,64.81 125.07,65.33 122.09,65.33 117.01,70.41 116.92,70.41 116.82,70.31 116.82,70.07 116.69,69.94 116.37,69.94 116.25,70.07 116.25,70.28 116.12,70.41 113.87,70.41 113.86,70.42 104.49,70.42
M_ODT7: length 78.5
  TOP w0.089: v5(96.4,64.92) 96.05,64.92 95.9,65.07 JCPU1.AE5
  TOP w0.102: JDIMM3.120 150.28,58.6 150.4,58.47 150.4,57.95 150.53,57.82 150.75,57.82 150.87,57.95 150.87,58.36 150.91,58.4 151.45,58.4 152.02,58.97 v1(152.02,59.21)
  IN3 w0.089: 104.49,69.96 102.91,69.96 101.27,68.32 98.24,68.32 96.99,67.07 96.99,64.78 97.2,64.57 97.2,64.42 97.11,64.32 96.23,64.32 96.13,64.22 95.75,64.22 95.69,64.28 95.69,64.41 95.97,64.68 95.97,65.01 96.09,65.14 96.28,65.14 96.4,65.01 v5(96.4,64.92)
  IN3 w0.152: v1(152.02,59.21) 152.09,59.21 152.22,59.34 152.22,59.54 152.09,59.67 150.37,59.67 150.26,59.56 150.26,59.49 150.14,59.36 149.83,59.36 149.71,59.49 149.71,59.54 149.58,59.67 149.25,59.67 149.12,59.54 149.12,59.44 149.04,59.36 148.69,59.36 148.56,59.49 148.56,59.56 148.44,59.68 148.11,59.68 146.96,60.83 146.96,61.06 146.65,61.38 143.67,61.38 143.2,61.84 142.79,61.84 142.66,61.97 142.66,62.35 142.54,62.47 136.91,62.47 136.28,63.1 135.41,63.1 135.28,63.23 135.28,64.1 134.89,64.49 134.78,64.49 134.68,64.59 134.68,64.7 134.56,64.83 134.17,64.83 134.05,64.7 134.05,64.48 133.92,64.35 132.24,64.35 132.16,64.27 132.16,64.19 132.03,64.06 131.68,64.06 131.55,64.19 131.55,64.75 131.42,64.87 130.2,64.87 130.07,64.75 130.07,64.49 129.93,64.35 128.8,64.35 128.63,64.52 128.63,64.75 128.5,64.87 128.15,64.87 128.02,64.75 128.02,64.52 127.86,64.35 125.4,64.35 124.88,64.87 124.64,64.87 124.41,64.65 124.11,64.65 123.88,64.87 121.91,64.87 117.84,68.94 117.61,68.94 117.51,68.83 117.51,68.64 117.4,68.53 117.04,68.53 116.89,68.68 116.89,68.78 116.73,68.93 116.43,68.93 116.28,68.78 116.28,68.68 116.12,68.53 115.56,68.53 115.43,68.66 115.43,69.83 115.31,69.95 114.49,69.95 114.3,69.76 113.81,69.76 113.6,69.96 104.49,69.96
MASK_BASE_LEDS#: length 358.2
  TOP w0.102: JIO1.106 35.13,14.35 v1(34.94,14.54) ; v1(251.99,71.78) 251.43,71.22 251.43,63.84 250.39,62.8 247.1,62.8 v1(246.98,62.93)
  IN1 w0.109: v1(221.91,60.1) 221.82,60.01 221.82,57.03 223.25,55.6 233.75,55.6 234.24,56.08 234.24,58.14 v1(234.34,58.24) 234.92,58.83 244.31,58.83 246.75,61.27 246.75,62.8 246.87,62.93 v1(246.98,62.93)
  IN3 w0.127: v1(251.99,71.78) 252.08,71.69 262.51,71.69 262.62,71.81 276.3,71.81 277.6,73.1 279.21,73.1 280.1,73.99 280.1,80.71 282.28,82.89 282.28,85.43 283.66,86.81 v1(283.66,87.19) 283.66,88.43 284.31,89.09 284.31,94.07 286.87,96.62 v1(286.87,102.81)
  IN4 w0.109: v1(221.91,60.1) 220.93,59.12 207.02,59.12 203.34,62.8 198.11,62.8 196.9,61.6 196.9,60.86 196.85,60.81 196.85,60.81 192.04,56 191.37,56 190.03,54.66 185.86,54.66 185.75,54.78 184.17,54.78 183.42,54.03 180.55,54.03 179.35,52.82 176.97,52.82 162.89,38.74 162.89,23.53 156.66,17.31 154.83,17.31 154.42,16.9 152.35,16.9 150.68,15.24 119.01,15.24 117.97,16.28 114.17,16.28 109.97,12.08 108.38,12.08 107.73,11.43 105.72,11.43 105.35,11.06 105.34,11.06 103.43,9.14 38.26,9.14 34.9,12.51 34.9,14.34 34.94,14.38 v1(34.94,14.54)
  BOTTOM w0.102: v1(286.87,102.81) 286.99,102.93 289.15,102.93 289.76,102.32 290.96,102.32 291.76,103.12 291.76,105.92 291.44,106.24 Q318.2 ; Q74.2 233.78,58.8 v1(234.34,58.24) ; v1(246.98,62.93) 246.59,62.93 246.08,63.44 U58.4 ; Q78.2 226.41,65.06 226.32,65.15 225.45,65.15 225.18,64.88 225.18,63.35 v2(223.17,61.34) 221.93,60.1 v1(221.91,60.1) ; Q84.2 280.53,88.71 282.05,87.19 v1(283.66,87.19)
MASK_SATA_LED#: length 36.4
  TOP w0.102: v1(226.41,63.32) v2(225.83,63.32)
  IN1 w0.109: v1(226.41,63.32) 226.33,63.32 222.05,59.04 222.05,57.13 223.36,55.81 231.78,55.81 233.34,57.36 v1(233.34,58.2) 233.34,61.58 233.75,62 233.75,62.32 234.39,62.95 235.04,62.95 235.75,63.67 235.75,65.95 236.73,66.92 v1(236.73,68.3)
  BOTTOM w0.102: v1(236.73,68.3) 236.73,67.71 U46.B9 ; v1(226.41,63.32) Q78.5 ; v1(233.34,58.2) 233.39,58.2 233.78,57.81 Q74.5
MAX8731_IINP: length 246.9
  TOP w0.254: PC922.1 172.09,25.21 165.85,25.21 160.65,30.4 v1(159.03,30.4) ; PC922.1 v1(173.84,27.75) ; PC922.1 PR925.1 174.88,26.98 PU901.8 ; v1(130.17,135.31) 130.3,135.18 144.59,135.18 148.96,130.81 151.45,130.81 152.16,130.1 152.16,116.85 147.85,112.55 147.85,103.16 148.27,102.74 v1(148.27,96.1) ; R388.2 v1(132.31,157.54)
  IN1 w0.254: v1(159.03,30.4) 157.06,32.37 157.06,91.96 154.13,94.89 151.15,94.89 150.86,95.19 148.99,95.19 148.27,95.91 v1(148.27,96.1)
  IN3 w0.254: v1(173.84,27.75) 174.47,28.39 188.4,28.39 191.24,31.22 203.11,31.22 209.24,25.08 234.72,25.08 v1(236.18,23.62)
  BOTTOM w0.254: PR939.1 v1(236.18,23.62) ; v1(130.17,135.31) 130.57,135.7 130.57,143.22 130.71,143.36 130.71,144.17 130.03,144.84 v2(130.03,146.3) 130.03,153.1 132.69,155.75 132.69,157.16 v1(132.31,157.54)
MAX8731_REF: length 78.5
  TOP w0.254: v1(171.3,33.21) 171.93,32.58 PC924.1 172.78,31.81 PU901.3 ; PR924.1 v1(169.9,26.99) ; PR912.1 v1(176.66,23.47)
  IN3 w0.254: v1(228.01,18.05) 226.8,19.27 226.8,21.17 224.7,23.27 210.64,23.27 208.52,21.15 179.06,21.15 176.74,23.47 v1(176.66,23.47)
  IN4 w0.254: v1(171.3,33.21) 171.3,28.39 v1(169.9,26.99) 173.42,23.47 v1(176.66,23.47)
  BOTTOM w0.102: v1(228.01,18.05) v2(227.47,18.05)
  BOTTOM w0.254: PR934.1 PR933.1 v1(228.01,18.05)
MAX8731A_LDO: length 25.5
  TOP w0.508: v1(175.61,40.83) 176.7,40.83 PD903.2 177.14,40.4 PR918.1 ; PR911.1 v1(180.06,25.97)
  IN1 w0.508: v1(175.61,40.83) 180.95,40.83 181.46,40.32 181.46,35.5 182.22,34.74 v1(182.22,31.31) 182.22,28.13 v1(180.06,25.97)
  vias: v2(180.12,33.15)
MB_DP_CA_DET: length 108.6
  TOP w0.102: v1(290.56,75.84) 289,77.41 282.21,77.41 281.82,77.03 v1(281.82,76.53)
  IN3 w0.127: v1(281.82,76.53) 281.82,77.08 280.68,78.22 280.68,80.3 281.95,81.57 283.61,81.57 284.22,82.18 284.22,86.08 284.88,86.74 284.88,93.84 287.42,96.38 287.42,110.64 288.87,112.09 288.87,126.84 288.01,127.7 288.01,131.76 287.12,132.65 287.12,136.97 289.41,139.26 290.61,139.26 292.36,141.01 292.36,142.82 JDP1.13
  BOTTOM w0.102: v1(290.56,75.84) 291.33,75.84 292.62,74.55 292.62,70.84 291.54,69.76 291.54,67.52 291.82,67.23 292.5,67.23 292.62,67.11 292.62,64.5 292.34,64.21 291.83,64.21 291.44,63.82 Q339.2 291.44,62.57 290.78,61.91 C1341.1 ; R62.2 278.48,75.63 278.9,76.04 v2(279,76.04) U22.10 281.34,76.04 v1(281.82,76.53)
MB_DP_HPD: length 79.9
  IN3 w0.127: v1(282.47,76.53) 282.47,76.82 280.94,78.36 280.94,80.23 281.94,81.23 283.75,81.23 284.53,82 284.53,86.06 285.11,86.64 285.11,93.75 287.67,96.3 287.67,110.56 289.1,112 289.1,131.05 287.37,132.78 287.37,136.84 289.41,138.88 290.55,138.88 292.2,140.53 294.19,140.53 294.54,140.18 295.02,140.18 295.38,140.53 295.38,141.15 JDP1.18
  BOTTOM w0.102: U22.11 280.9,76.54 281.33,76.98 282.03,76.98 v1(282.47,76.53)
MB_DP_RP_AUX: length 76.9
  IN4 w0.117: v1(289.66,80.58) 289.61,80.53 289.61,80.09 289.25,79.73 288.65,79.73 287.41,80.96 287.41,82.41 287.88,82.88 287.88,90.33 287.88,92.38 288.81,93.32 289.06,93.56 289.06,100.96 289.34,101.24 289.34,101.74 289.34,102.74 289.06,103.01 288.9,103.17 288.9,107.4 290.64,109.14 290.64,125.65 290.81,125.82 292.5,127.51 292.5,142.82 292.92,143.24 293.78,143.24 JDP1.15
  BOTTOM w0.102: U22.28 288.79,75.54 289.66,76.42 v1(289.66,78.74) 289.66,79.41 289.58,79.49 289.58,80.06 289.66,80.14 v1(289.66,80.58) 289.66,81.06 R59.2
MB_DP_RP_AUX#: length 76.8
  IN4 w0.117: JDP1.17 293.78,142.24 293.51,141.97 293.28,141.97 293.2,142.05 293.2,142.48 293.42,142.7 293.42,142.8 293.26,142.96 293.04,142.96 292.78,142.7 292.78,127.39 290.93,125.54 290.93,109.03 289.18,107.28 289.18,103.29 289.62,102.85 289.62,101.85 289.62,101.12 289.34,100.84 289.34,93.44 289.18,93.28 288.17,92.27 288.17,82.76 287.7,82.29 287.7,81.08 288.77,80.01 289.13,80.01 289.32,80.2 289.32,80.28 v1(289.03,80.58)
  BOTTOM w0.102: R56.2 289.03,80.93 v1(289.03,80.58) 289.04,80.57 289.09,80.57 289.28,80.38 289.28,80.33 289.38,80.23 289.38,80.16 289.32,80.1 289.32,79.38 289.39,79.3 v1(289.39,76.85) 289.39,76.53 288.69,75.82 287.88,75.82 287.83,75.87 287.83,75.98 287.77,76.04 U22.27
MB_DP_RP_C_N0: length 2.8
  BOTTOM w0.102: C304.2 285.48,79.72 285.48,79.33 v3(285.28,79.13) 285.49,78.92 285.49,78.72 285.64,78.57 285.64,78.37 285.53,78.26 U22.22
MB_DP_RP_C_N1: length 3.1
  BOTTOM w0.102: U22.19 284.03,78.24 284.14,78.36 284.14,78.44 284.05,78.54 283.81,78.54 283.61,78.73 283.61,78.73 283.61,78.85 v3(283.34,79.12) 283.42,79.21 283.42,79.74 C308.2
MB_DP_RP_C_N2: length 3.2
  BOTTOM w0.102: C309.2 281.17,80.11 281.49,79.78 v3(281.49,79.15) 281.51,79.15 281.75,78.91 281.75,78.88 282.15,78.47 282.46,78.47 282.53,78.41 U22.16
MB_DP_RP_C_N3: length 4.3
  BOTTOM w0.102: U22.13 281.03,78.33 281.07,78.38 281.07,78.46 280.9,78.64 279.41,78.64 v3(278.88,79.16) 279.17,79.45 279.17,79.93 C302.2
MB_DP_RP_C_P0: length 2.7
  BOTTOM w0.102: U22.23 286.03,78.24 285.91,78.36 285.91,78.68 285.76,78.83 285.76,78.98 v1(285.91,79.13) 285.74,79.3 285.74,79.75 C307.2
MB_DP_RP_C_P1: length 3.1
  BOTTOM w0.102: U22.20 284.53,78.31 284.41,78.43 284.41,78.56 284.16,78.8 283.98,78.8 283.88,78.91 283.88,79.03 v1(283.97,79.12) 283.69,79.4 283.69,79.81 283.99,80.11 C295.2
MB_DP_RP_C_P2: length 3.2
  BOTTOM w0.102: C306.2 281.8,79.87 281.8,79.53 282.13,79.2 v1(282.13,79.15) 282.07,79.09 282.08,79.08 282.08,78.93 282.26,78.74 282.61,78.74 282.84,78.51 282.84,78.45 283.03,78.27 U22.17
MB_DP_RP_C_P3: length 4.4
  BOTTOM w0.102: C303.2 279.69,80.11 279.45,79.87 279.45,79.23 v1(279.52,79.16) 279.52,79.16 279.52,79.02 279.63,78.91 v1(280.15,78.91) 281.01,78.91 281.34,78.58 281.34,78.42 281.53,78.24 U22.14
MB_DP_RP_N0: length 77.6
  IN4 w0.117: v3(285.01,83.69) 285.01,83.9 285.15,84.04 285.33,84.04 285.46,83.91 285.46,83.24 285.23,83.01 284.91,83.01 284.2,83.72 284.2,85.79 285.6,87.19 285.6,92.63 287.61,94.64 287.61,107.18 287.61,107.3 287.61,107.92 288.67,108.99 288.67,111.71 289.36,112.39 289.36,126.27 291.22,128.13 291.22,142.49 291.22,143.48 291.57,143.83 291.57,148.91 292.61,149.96 293.23,149.96 293.51,149.68 293.71,149.68 293.9,149.49 293.9,149.37 JDP1.3
  BOTTOM w0.102: v3(285.01,83.69) 285.23,83.48 285.23,81.97 285.46,81.73 285.46,81.43 C304.1
MB_DP_RP_N1: length 84
  IN4 w0.117: v3(282.87,82.73) 282.87,82.84 283.1,83.08 283.1,84.45 282.64,84.91 282.64,88.84 284.36,90.56 284.36,93.02 286.48,95.13 286.48,101.94 286.14,102.28 286.14,103.81 286.45,104.13 286.45,108.28 287.47,109.29 287.47,112.07 287.64,112.24 287.64,112.24 288.3,112.89 288.3,126.92 290.01,128.63 290.01,141.55 289.5,142.06 289.5,142.29 289.5,143.31 290.26,144.07 290.26,149.66 291.82,151.22 295.66,151.22 296.42,150.46 296.42,148.57 295.59,147.74 294.79,147.74 JDP1.6
  BOTTOM w0.102: v3(282.87,82.73) 282.88,82.72 282.88,82.7 283.32,82.26 283.32,81.32 C308.1
MB_DP_RP_N2: length 76.8
  IN4 w0.117: JDP1.9 293.74,146.29 292.53,146.29 292.36,146.12 292.36,143.49 292,143.14 292,142.81 292,127.76 290.14,125.9 290.14,109.35 288.39,107.6 288.39,94.17 287.12,92.9 287.12,82.82 285.67,81.37 281.78,81.37 280.98,82.17 280.98,82.58 v3(280.82,82.74)
  BOTTOM w0.102: v3(280.82,82.74) 281,82.56 281,82.15 281.4,81.75 281.4,81.43 C309.1
MB_DP_RP_N3: length 97.6
  IN4 w0.117: v3(278.83,82.42) 278.85,82.45 278.85,83.12 278.93,83.2 278.93,86.62 279.59,87.28 279.59,89.07 282.41,91.89 282.41,92.81 283.01,93.41 283.01,98.66 283.98,99.63 283.98,103.5 284.46,103.98 284.86,103.98 285.1,103.98 285.67,104.56 285.67,108.6 286.69,109.62 286.69,112.39 287.31,113.02 287.31,113.02 287.51,113.22 287.51,126.65 286.84,127.33 286.84,140.81 287.72,141.7 287.72,143.56 289.25,145.09 289.25,149.79 291.92,152.45 291.92,153.22 293.77,155.07 296.82,155.07 297.95,153.94 297.95,146.44 296.25,144.74 294.78,144.74 JDP1.12
  BOTTOM w0.102: C302.1 279.4,81.46 279.4,81.56 279.06,81.91 279.06,82.19 v3(278.83,82.42)
MB_DP_RP_P0: length 77.6
  IN4 w0.117: v1(285.9,83.69) 285.88,83.69 285.69,83.51 285.69,83.07 285.35,82.72 284.79,82.72 283.91,83.6 283.91,85.91 285.31,87.3 285.31,92.74 287.32,94.76 287.32,107.06 287.32,107.06 287.32,107.18 287.32,107.37 287.32,108.04 288.39,109.11 288.39,111.82 289.08,112.51 289.08,126.39 290.94,128.24 290.94,142.37 290.94,143.6 291.28,143.95 291.28,149.03 292.5,150.24 293.77,150.24 JDP1.1
  BOTTOM w0.102: v1(285.9,83.69) 285.89,83.69 285.88,83.71 285.49,83.33 v1(285.49,82.26) 285.49,82.08 285.73,81.84 285.73,81.43 C307.1
MB_DP_RP_P1: length 84
  IN4 w0.117: JDP1.4 294.78,148.55 295.31,148.02 295.47,148.02 296.14,148.69 296.14,150.34 295.55,150.93 291.94,150.93 290.55,149.54 290.55,143.96 289.79,143.19 289.79,142.18 290.13,141.84 290.3,141.67 290.3,128.52 289.29,127.51 288.58,126.8 288.58,112.78 287.76,111.95 287.76,109.17 286.74,108.16 286.74,104.01 286.43,103.7 286.43,102.4 286.76,102.06 286.76,95.01 284.65,92.9 284.65,90.44 282.93,88.72 282.93,85.03 283.39,84.57 283.39,82.96 283.31,82.88 283.31,82.47 283.44,82.35 283.63,82.35 283.75,82.47 v1(283.75,82.72)
  BOTTOM w0.102: v1(283.75,82.72) 283.7,82.66 283.7,82.64 283.59,82.53 283.59,81.54 C295.1
MB_DP_RP_P2: length 76.8
  IN4 w0.117: JDP1.7 293.78,147.08 293.27,146.58 292.41,146.58 292.07,146.24 292.07,143.61 291.72,143.26 291.72,142.69 291.72,127.87 289.86,126.02 289.86,109.47 288.11,107.71 288.11,94.29 287,93.19 286.84,93.02 286.84,92.67 286.84,82.94 285.55,81.65 281.9,81.65 281.27,82.28 281.27,82.55 v1(281.46,82.74)
  BOTTOM w0.102: C306.1 281.87,81.06 281.67,81.26 281.67,81.86 281.27,82.26 281.27,82.55 v1(281.46,82.74)
MB_DP_RP_P3: length 97.5
  IN4 w0.117: v1(279.46,82.42) 279.14,82.75 279.14,83 279.21,83.08 279.21,86.5 279.87,87.16 279.87,88.96 282.69,91.78 282.69,92.69 283.29,93.29 283.29,98.54 284.27,99.52 284.27,103.38 284.58,103.7 285.22,103.7 285.96,104.44 285.96,108.48 286.97,109.5 286.97,112.28 287.43,112.73 287.8,113.1 287.8,126.77 287.12,127.45 287.12,140.69 288.01,141.58 288.01,141.82 288.01,143.45 289.53,144.97 289.53,149.67 292.2,152.34 292.2,153.1 293.88,154.78 296.71,154.78 297.66,153.83 297.66,146.55 296.13,145.03 295.33,145.03 295.24,145.12 295.24,145.38 295.43,145.57 295.43,145.94 295.29,146.08 295.1,146.08 294.78,145.76 JDP1.10
  BOTTOM w0.102: v1(279.46,82.42) 279.32,82.28 279.32,82.02 279.67,81.67 279.67,81.4 C303.1
MB_DP_RST#: length 5.4
  BOTTOM w0.102: U22.35 288.09,72.04 v2(289.15,70.99) 289.82,70.31 C88.1 289.82,69.09 R415.2
MCARD_MISC_PWREN: length 162.2
  TOP w0.102: v1(159.83,154.83) 159.76,154.83 R733.1 158.56,156.02 Q312.2 ; v1(221.44,89.7) 221.44,88.96 220.43,87.96 218.32,87.96 217.37,87.01 217.37,84.71 218.63,83.45 220.83,83.45 220.93,83.55 221.93,83.55 226.16,79.32 226.16,79.1 227.99,77.27 229.37,77.27 229.82,76.81 231.04,76.81 231.88,77.65 232.8,77.65 232.91,77.53 238.63,77.53 239.72,76.44 239.72,75.49 v1(239.99,75.22)
  IN2 w0.127: v1(159.83,154.83) 160.13,154.52 163.83,154.52 164.27,154.97 164.96,154.97 165.48,155.49 167.19,155.49 167.44,155.73 167.44,156.08 167.82,156.46 178.08,156.46 178.34,156.2 180.51,156.2 182.35,154.36 190.77,154.36 192.05,155.64 195.17,155.64 195.58,155.23 197.04,155.23 198.22,154.06 198.22,152.78 199.06,151.94 199.06,143.66 199.63,143.09 199.63,140.88 200.67,139.84 200.67,116.66 201.62,115.7 201.62,113.73 202.83,112.53 202.83,104.52 203.73,103.62 204.79,103.62 206.53,101.89 206.53,96.65 210.54,92.64 219.23,92.64 220.95,90.91 220.95,90.18 v1(221.44,89.7)
  BOTTOM w0.102: U46.B53 241.13,75.7 240.92,75.91 240.61,75.91 239.99,75.29 v1(239.99,75.22) ; v2(159.57,155.36) 159.83,155.11 v1(159.83,154.83)
MCARD_MISC_PWREN#: length 3.9
  TOP w0.102: Q312.6 156.31,155.37 156.46,155.52 156.46,155.87 156.31,156.02 Q312.5 ; Q312.6 155.87,154.42 v2(155.78,154.33) ; Q312.6 155.05,155.37 R735.2
MCARD_PCIE_SATA: length 5.1
  TOP w0.102: Q322.5 35.66,149.34 35.81,149.49 36.18,149.49 36.32,149.35 36.32,148.98 Q322.6 36.31,148.46 36.17,148.32 R740.2 36.17,147.59 35.69,147.1 35.69,145.77 v2(35.75,145.71)
MCARD_PCIE_SATA#: length 326.4
  TOP w0.102: v1(33.18,155.87) v2(33.72,155.33) 34.28,154.78 35.47,154.78 36.14,154.1 36.14,151.77 35.66,151.28 Q322.2
  IN1 w0.109: v1(240.09,60.67) 240.09,60.69 240.45,61.05 240.45,65.08 239.98,65.55 239.98,66.75 239.83,66.91 v1(239.83,68.33) 239.33,68.82 239.33,69.49 240.54,70.7 241.32,70.7 241.97,71.35 241.97,75.78 241.59,76.16 241.59,76.94 242.43,77.78 242.43,78.89 240.3,81.03 238.22,81.03 237.98,81.27 233.43,81.27 232.82,81.88 232.82,82.3 232.53,82.59 232.11,82.59 231.18,83.52 v1(229.83,83.52)
  IN2 w0.127: v1(229.83,83.52) 229.37,83.06 228.95,83.06 228.36,83.65 228.36,84.6 223.89,89.07 223.89,89.34 222.51,90.72 221.47,90.72 219.24,92.95 210.71,92.95 207.69,95.97 207.69,101.05 205.84,102.9 205.84,118.78 204.91,119.71 204.91,131.06 205.17,131.31 205.17,151.48 201.34,155.31 199.69,155.31 197.15,157.85 190.75,157.85 190.21,158.39 184.67,158.39 184.35,158.08 179.51,158.08 179.2,158.39 167.96,158.39 165.09,161.27 160.58,161.27 157.92,158.61 156.83,158.61 152.23,154.01 148.64,154.01 148.35,154.31 146.84,154.31 145.87,155.27 144.71,155.27 143.89,154.45 143.89,154.23 143.42,153.76 142.48,153.76 142.17,154.06 138.03,154.06 136.7,152.73 130.63,152.73 128.41,150.51 118.76,150.51 118.15,149.9 114.35,149.9 114.08,150.17 114.08,151 113.74,151.35 111.57,151.35 110.91,150.69 110.07,150.69 109.34,149.96 96.98,149.96 95.87,151.07 82.16,151.07 76.87,156.35 76.87,158.73 73.75,161.85 69.76,161.85 69.1,161.19 65.4,161.19 65.17,161.42 57.14,161.42 56.09,160.38 50.71,160.38 49.35,159.02 44.45,159.02 43.08,160.39 40.07,160.39 35.55,155.87 v1(33.18,155.87)
  BOTTOM w0.102: v1(33.18,155.87) 32.84,156.21 JMINI4.51 ; v1(240.09,60.67) 239.75,60.67 239.06,59.97 R457.2 ; v1(239.83,68.33) U46.B3
MCARD_WWAN_PWREN: length 168.8
  TOP w0.102: v1(236.33,76.07) 235.27,77.13 232.9,77.13 231.69,75.92 227.04,75.92 v1(226.11,76.85) ; Q311.2 107.55,131.38 108.37,132.2 R727.1 108.41,132.65 107.76,133.3 v1(107.76,133.66) 107.21,133.66 v2(106.92,133.36)
  IN2 w0.127: v1(107.76,133.66) 107.76,133.39 108.88,132.27 113.43,132.27 113.89,132.73 131.91,132.73 132.61,133.43 137.21,133.43 138.09,134.3 151.79,134.3 156.72,129.38 158.49,129.38 159.22,128.65 169.35,128.65 175.65,122.35 175.65,118.16 176.27,117.54 181.93,111.88 181.93,111.6 182.54,110.99 182.54,108.26 188.38,102.42 188.38,99.98 190.43,97.92 190.43,96.92 195.4,91.95 195.4,90.24 195.66,89.99 195.66,89.45 197.63,87.48 200.62,87.48 201.32,86.78 201.32,86.15 202.47,85 208.94,85 210.33,83.6 214.7,83.6 216.68,81.62 222.15,81.62 225.08,78.69 225.08,77.87 v1(226.11,76.85)
  BOTTOM w0.102: v1(236.33,76.07) U46.B42
MCARD_WWAN_PWREN#: length 9.6
  TOP w0.102: Q311.6 104.96,130.62 R721.2 104.21,131.13 104.62,131.13 104.88,131.38 Q311.5 105.81,131.38 106.22,131.79 106.22,134.1 v2(105.8,134.53) 105.53,134.8 Q73.2
ME_FWP: length 304.8
  IN2 w0.127: v1(16.99,136.59) 17.18,136.78 19.18,136.78 20.29,137.89 20.29,138.07 22.78,140.55 25.14,140.55 26.11,139.59 26.94,139.59 27.82,138.71 28.51,138.71 28.93,138.29 32.2,138.29 32.34,138.15 35.09,138.15 37.29,135.95 42.66,135.95 43.79,137.08 45.7,137.08 47.32,138.71 53.98,138.71 54.87,139.6 61.44,139.6 61.64,139.4 64.92,139.4 65.36,138.95 68.36,138.95 70.4,136.92 70.54,136.92 70.95,136.5 72.86,136.5 74.96,134.4 78.76,134.4 79.58,135.22 79.58,136.32 79.87,136.61 83.5,136.61 84.38,135.74 84.38,134.61 84.69,134.29 86.75,134.29 87.22,134.76 99.66,134.76 100.42,135.52 102.9,135.52 103.46,134.96 108.94,134.96 109.47,134.43 111.34,134.43 112.57,133.2 131.34,133.2 133.02,134.89 151.87,134.89 155.73,131.03 159.52,131.03 161.22,129.32 169.39,129.32 176.16,122.55 176.16,118.29 176.46,118 176.46,118 182.38,112.07 182.38,111.79 182.99,111.18 182.99,108.79 186.05,105.73 186.68,105.73 189.75,102.65 189.75,99.3 190.89,98.16 190.89,97.11 195.86,92.14 195.86,90.43 196.11,90.18 196.11,89.64 197.82,87.94 200.9,87.94 201.93,86.91 202.82,86.91 204.27,85.46 209.13,85.46 210.49,84.1 213.74,84.1 v1(215.13,85.48)
  IN3 w0.127: v1(236.54,64.92) 237.45,64.01 240.08,64.01 242.49,66.42 244.2,66.42 246.18,68.4 246.18,69.62 245.91,69.89 245.91,79.55 244.13,81.33 243.57,81.33 243.04,80.8 239.03,80.8 237.09,82.73 237.09,83.08 236.45,83.73 233.53,83.73 232.83,84.43 230.97,84.43 230.31,85.08 222.44,85.08 220.5,83.15 216.81,83.15 215.13,84.83 v1(215.13,85.48)
  BOTTOM w0.102: v1(16.99,136.59) 16.99,136.6 16.71,136.89 RH50.1 ; v1(236.54,64.92) 236.54,64.08 R793.1 236.83,64.24 237.08,64.49 v2(237.08,65.49) U46.A8
ME_RESET#: length 4.7
  TOP w0.102: v2(16.17,95.43) 16.5,95.09 RH141.1 RH138.2 18.43,95.09 18.87,94.65 19.51,94.65 19.91,95.06 UC3.2
ME_SUS_PWR_ACK: length 214.3
  TOP w0.102: RH144.2 7.72,109.03 8.62,108.13 9.33,108.13 9.47,108.27 RH121.1 9.79,108.29 10.25,108.75 11.33,108.75 v1(11.42,108.84) ; U54.A8 160.87,147.38 160.78,147.47 160.29,147.47 v1(159.84,147.03)
  IN1 w0.109: v1(159.84,147.03) 160.03,146.84 160.03,146.83 160.29,146.57 160.48,146.57 160.98,146.06 160.98,143.92 160.35,143.28 160.18,143.28 v1(159.23,142.33)
  IN2 w0.127: v1(159.23,142.33) 159.07,142.33 157.57,143.83 156.26,143.83 155.43,144.65 136.69,144.65 136.4,144.95 119.18,144.95 118.97,145.15 117.11,145.15 116.94,144.98 112.25,144.98 111.5,144.23 107.75,144.23 107.38,143.87 91.9,143.87 91,142.97 87.06,142.97 85.83,144.2 82.52,144.2 81.62,143.29 79.3,143.29 78.41,142.41 78.41,141.42 77.56,140.58 75.64,140.58 75.36,140.85 75.36,142.18 73.89,143.65 71.46,143.65 71.21,143.9 68.95,143.9 68.31,144.55 65.82,144.55 65.54,144.27 63.56,144.27 63.07,143.78 62.03,143.78 61.79,143.53 60.72,143.53 57.37,146.88 55.62,146.88 52.23,143.49 49.01,143.49 48.64,143.85 46.05,143.85 45.38,143.18 43.76,143.18 42.64,142.06 41.39,142.06 41.15,141.82 40.58,141.82 40.28,142.13 39.88,142.13 39.57,141.82 36.15,141.82 35.93,142.04 35.28,142.04 33.22,144.09 20.66,144.09 19.43,145.33 17.63,145.33 16.49,144.19 16.49,141.83 14.54,139.88 14.09,139.88 13.46,139.25 13.46,138.49 9.15,134.18 8.25,134.18 6.73,132.66 6.73,126.64 5.32,125.23 5.32,120.31 5.05,120.04 5.05,113.53 5.8,112.78 5.8,111.47 6.4,110.87 6.79,110.87 8.03,109.63 8.67,109.63 8.71,109.67 9.26,109.67 10.09,108.84 v1(11.42,108.84)
  BOTTOM w0.102: v1(159.23,142.33) 159.23,142.55 v2(159.54,142.85)
ME_SUS_PWR_ACK_R: length 14.6
  TOP w0.102: RH121.2 11.57,108.27 v1(12.06,108.75) 12.06,108.5 v2(12.29,108.27) RH323.1 ; UH4.K16 21.97,111.79 v1(21.58,111.39)
  IN4 w0.109: v1(21.58,111.39) 21.41,111.39 20.8,110.78 19.47,110.78 19.28,110.59 17.64,110.59 16.83,109.79 14.58,109.79 13.38,108.59 12.22,108.59 v1(12.06,108.75)
MEC_XTAL1: length 6.9
  TOP w0.203: Y6.1 164.54,158.05 164.2,157.71 164.2,155.02 C741.1 164.31,153.64 164.31,153.1 164.47,152.94 U54.A61
MEC_XTAL2: length 1.8
  TOP w0.203: U54.A62 163.97,153.98 R1068.2
MEC_XTAL2_R: length 3.7
  TOP w0.203: R1068.1 163.68,156.24 C743.2 163.64,157.79 163.38,158.05 Y6.2
MEM_SMBCLK: length 19.5
  TOP w0.102: v1(21.04,110.41) 21.05,110.41 21.34,110.7 UH4.H14 ; RH302.1 9.28,107.25 v2(8.85,107.68) 8.63,107.9 QH5.6 7.33,107.9 7.25,107.82 v1(7.03,107.82)
  IN1 w0.109: v1(7.03,107.82) 7.29,108.08 12.71,108.08 13.59,108.95 13.59,109.38 14.44,110.24 14.68,110.48 16.25,110.48 16.49,110.24 19.06,110.24 19.38,109.92 20.55,109.92 v1(21.04,110.41)
MEM_SMBDATA: length 25.3
  TOP w0.102: UH4.C9 19.6,108.43 19.61,108.42 v1(19.65,108.42) ; RH303.1 9.4,106.11 9.16,106.35 v2(8.81,106.35) 8.61,106.35 8.27,106.01 6.23,106.01 6.01,106.23 QH5.3 4.65,106.6 v1(4.52,106.73)
  IN1 w0.109: v1(19.65,108.42) 18.46,108.42 17.23,109.65 16.47,109.65 16.3,109.82 16.26,109.82 16.17,109.91 14.77,109.91 14.34,109.47 14.34,108.61 14.22,108.5 14.22,107.89 12.77,106.44 10.04,106.44 9.46,105.86 6.39,105.86 5.95,106.29 4.82,106.29 4.52,106.59 v1(4.52,106.73)
MINI1CLK_REQ#: length 167.2
  TOP w0.102: RH81.1 19.15,101.87 v1(19.18,101.9) 19.49,102.21 19.85,102.21 20.86,103.23 20.86,103.7 21.58,104.41 21.58,104.81 UH4.J2 ; v1(102.63,146.47) v2(102.63,147.14)
  IN2 w0.102: 16.36,103.34 16.39,103.3 17.78,103.3 17.89,103.19
  IN2 w0.127: 16.36,103.34 15.26,103.34 13.7,104.9 13.7,105.51 13.17,106.05 10.31,106.05 7.02,109.33 6.16,109.33 5.25,110.24 5.12,110.38 5.12,112.5 4.37,113.25 4.37,113.27 4.35,113.29 4.35,113.48 4.35,113.48 4.35,120.33 4.6,120.57 4.6,128.11 5.31,128.82 5.31,132.99 7.17,134.86 8.86,134.86 12.04,138.04 12.04,139.79 12.41,140.16 13.37,140.16 15.37,142.16 15.37,144.16 17.33,146.13 20.11,146.13 23.9,149.92 33.7,149.92 34.02,150.24 34.91,150.24 35.68,149.47 36.04,149.47 37.64,151.07 39.6,151.07 40.2,150.47 45.35,150.47 47.78,152.9 62.52,152.9 64.42,151 67.18,151 68.29,152.11 71.23,152.11 73.1,150.24 75.71,150.24 78.07,147.88 80.51,147.88 80.86,147.53 91.6,147.53 93.76,145.36 101.52,145.36 v1(102.63,146.47) ; 17.89,103.19 v1(19.18,101.9)
  BOTTOM w0.102: JMINI1.7 101.98,142.65 103.16,143.83 103.16,145.94 v1(102.63,146.47)
MINI2CLK_REQ#: length 225.3
  TOP w0.102: v1(22.21,111.39) 22.21,111.29 22.6,110.9 UH4.L14
  IN2 w0.102: v1(22.21,111.39) 22.26,111.39 22.71,111.84 24.53,111.84 25.42,110.96 26.07,110.96 26.9,111.79 28.71,111.79 28.98,111.52 33.48,111.52 33.53,111.57 37.83,111.57 38.41,110.99 39.38,110.99 39.41,111.01 40.54,111.01 41.07,110.48 42.77,110.48
  IN2 w0.127: v1(187.08,81.28) 187.01,81.35 187.01,82.86 184.14,85.72 184.14,89.22 182.06,91.3 181.39,91.3 179.73,92.96 178.09,92.96 176.53,94.53 176.53,96.97 173.11,100.39 168.19,100.39 166.91,101.66 161.36,101.66 161.06,101.97 151.37,101.97 150.04,103.3 130.41,103.3 128.26,105.45 126.2,105.45 125.89,105.14 125.89,104.42 124.65,103.19 100.01,103.19 90.92,112.28 81.79,112.28 81.46,111.95 79.59,111.95 78.56,112.98 74.24,112.98 70.78,109.51 64.55,109.51 61.4,112.66 53.06,112.66 52.67,112.27 49.63,112.27 49.2,111.84 45.72,111.84 44.36,110.48 42.77,110.48
  IN4 w0.102: v1(22.21,111.39) 21.79,111.81 17.03,111.81 16.4,111.18
  IN4 w0.109: 16.4,111.18 15.91,110.69 12.36,110.69 12.03,110.36 v1(12.03,110.22)
  BOTTOM w0.102: v1(187.08,81.28) 187.4,80.96 v2(188.78,80.96) 196.66,80.96 196.92,81.22 196.92,87.3 197.62,88 199.41,88 199.89,88.48 JMINI2.7 ; v1(12.03,110.22) 11.99,110.19 11.99,109.72 11.56,109.28 RH97.1
MINI3CLK_REQ#: length 272.6
  TOP w0.102: 15.57,105.62 15.57,105.63 15.58,105.64 15.58,106.03 17.48,107.93 UH4.A8 ; 15.57,105.62 15.57,105.32 15.26,105.02 15.02,105.02 14.76,104.76 14.76,104.41 14.55,104.2 RH152.1 ; 15.57,105.62 v1(15.58,105.62)
  IN2 w0.127: v3(181.25,141.12) 180.41,140.28 177.66,140.28 174.88,143.07 171.54,143.07 171.17,142.7 164.77,142.7 164.43,143.04 159.04,143.04 157.2,144.88 136.78,144.88 136.49,145.17 130.09,145.17 128.64,146.62 123.37,146.62 122.58,147.41 117.84,147.41 117.35,146.91 117.35,146.43 116.36,145.44 106.45,145.44 106.15,145.14 93.51,145.14 91.35,147.3 80.77,147.3 80.41,147.65 77.98,147.65 75.61,150.01 73.01,150.01 71.15,151.87 68.41,151.87 67.31,150.77 64.27,150.77 62.37,152.67 47.93,152.67 45.5,150.24 40.01,150.24 39.43,150.81 37.71,150.81 36.14,149.24 35.59,149.24 34.82,150.01 34.11,150.01 33.78,149.68 23.98,149.68 20.09,145.78 17.37,145.78 15.59,144.01 15.59,142.06 13.46,139.93 12.52,139.93 12.27,139.68 12.27,137.94 8.96,134.63 7.27,134.63 5.54,132.9 5.54,128.73 4.86,128.05 4.86,120.51 4.58,120.23 4.58,113.38 4.6,113.37 4.6,113.34 5.35,112.59 5.35,110.47 6.25,109.56 7.11,109.56 9.08,107.59 12.86,107.59 14.45,106.01 15.19,106.01 v1(15.58,105.62)
  IN3 w0.127: v3(181.25,141.12) 181.25,146.87 180.88,147.24 180.88,156.34 182.19,157.65 182.19,163.55 180.16,165.58 175.22,165.58 v1(174.29,166.51)
  BOTTOM w0.102: JMINI3.7 172.24,166.18 172.45,166.4 174.18,166.4 v1(174.29,166.51)
MOD_EN: length 11.6
  TOP w0.254: R515.2 27.79,17.02 27.79,17.94 R1627.1 26.9,18.83 v1(26.9,19.5) 27.09,19.69 28.47,19.69 28.66,19.5 C416.1
  BOTTOM w0.254: Q30.3 v2(27.09,20.33) 27.09,19.69 v1(26.9,19.5) 27.67,18.72 Q301.3
MODC_EN: length 274.7
  TOP w0.102: R514.1 26.39,18.23 v1(25.75,18.86)
  IN3 w0.127: v1(237.83,68.31) 237.3,67.78 235.7,67.78 235.28,67.35 234.51,67.35 233.79,66.64 230.1,66.64 228.43,64.96 206.25,64.96 203.29,62 202.79,62 199.6,58.81 194.09,58.81 193.02,57.75 186.33,57.75 185.91,57.33 185.91,55.45 185.53,55.08 184.54,55.08 183.86,54.39 175.84,54.39 163.19,41.75 163.19,20.44 158.6,15.84 158.6,12.93 157.53,11.86 127.75,11.86 126.52,13.1 126.07,13.1 124.64,11.66 122.67,11.66 121.64,12.69 121.64,13.03 121.45,13.22 119.25,13.22 117.18,15.29 114.55,15.29 111.43,12.17 111.43,10.26 111.04,9.87 109.65,9.87 109.08,9.3 107.83,9.3 105.64,7.1 36.15,7.1 35.36,7.89 33.71,7.89 32.99,7.18 26.01,7.18 24.87,8.32 24.87,17.97 v1(25.75,18.86)
  BOTTOM w0.102: v1(237.83,68.31) U46.B7 ; Q301.2 27.02,18.55 26.53,19.04 25.94,19.04 v1(25.75,18.86) v2(25.2,18.86)
MODC_EN#: length 4.4
  BOTTOM w0.102: v2(25.3,16.42) 25.52,16.64 Q301.6 26.37,17.17 26.5,17.3 26.88,17.3 27.04,17.15 27.04,16.65 Q301.5 R516.2
MODE: length 7.5
  TOP w0.102: v1(47.22,141.73) 47.22,142.01 46.75,142.48 46.41,142.48 45.39,143.5 44.51,143.5 44.17,143.16 U9.53
  BOTTOM w0.102: v1(47.22,141.73) 47.28,141.8 R58.2 R63.2 v2(48.14,143.73)
MSCLK: length 172.7
  TOP w0.102: v1(173.84,135.78) 173.53,135.47 173.53,135.11 173.11,134.69 173.11,125.03 174.01,124.13 174.01,121.56 173.57,121.12 173.57,116.76 179.86,110.48 179.86,106.6 178.34,105.09 178.34,102.42 177.48,101.56 177.48,97.17 180.03,94.62 180.03,93.59 179.65,93.21 178.84,93.21 178.23,92.6 178.23,90.84 179.45,89.62 179.45,88.75 180.52,87.68 v1(180.64,87.68) 181.49,86.83 183.01,86.83 184.26,85.57 196.65,85.57 199.13,83.08 204.91,83.08 205.17,83.34 205.17,84.05 205.47,84.35 208.55,84.35 210.44,86.25 210.44,91.45 210.76,91.77 214.04,91.77 v1(214.58,91.24) ; R847.2 v1(209.64,116.78) 210.16,116.26 210.16,111.96 209.63,111.44 JDEG2.6 ; v1(169.91,147.21) 170.34,146.77 170.75,146.77 171.11,147.13 U54.B43
  IN1 w0.109: v1(169.91,147.21) 169.91,147.1 170.27,146.75 170.84,146.75 172.35,145.24 172.35,144.65 174.5,142.5 174.5,141.61 174.77,141.33 174.77,137.01 174.38,136.61 174.38,136.27 173.92,135.8 173.86,135.8 v1(173.84,135.78)
  BOTTOM w0.102: v1(209.64,116.78) 209.18,116.78 208.52,116.12 208.52,113.97 207.02,112.47 207.02,111.48 207.49,111.01 207.49,110.45 206.92,109.88 206.92,94.46 208.5,92.88 213.35,92.88 214.58,91.64 v1(214.58,91.24) ; v1(180.64,87.68) 180.64,87.36 181.18,86.83 181.18,86.01 181.51,85.67 v2(182.15,85.67) 182.33,85.67 182.65,85.36 188.03,85.36 188.8,86.12 188.8,88.38 189.37,88.95 191.69,88.95 191.89,89.15 JMINI2.19
MSDATA: length 126.4
  TOP w0.102: R869.2 v1(175.03,145.97) 174.12,146.88 U54.A40 ; R850.2 213.61,108.88 213.52,108.97 213.52,111.39 v1(213.69,111.56) 213.55,111.56 213.17,111.94 JDEG2.7 ; v1(180.16,96.13) 180.16,102.5 180.24,102.58 180.24,105.63 180.95,106.34 180.95,110.68 175.36,116.26 175.36,128.23 v2(175.57,128.44) 175.75,128.62 175.75,131.1 174.98,131.87 174.98,133.55 175.54,134.11 175.54,135.57 176.27,136.3 176.3,136.3 v1(176.43,136.42) ; R706.2 184.24,99.1 184.24,97.26 183.95,96.97 183.95,96.69 184.34,96.29 184.76,96.29 185.1,95.95 v1(185.1,95.94)
  IN1 w0.109: v1(175.03,145.97) 175.03,145.83 175.93,144.93 175.93,142.77 176.15,142.56 176.15,136.71 v1(176.43,136.42)
  IN3 w0.127: v1(213.69,111.56) 213.35,111.21 213.35,107.49 213.84,107 213.84,105.1 208.66,99.92 208.66,92.43 v1(207.24,91.01) ; v1(185.1,95.94) 184.75,96.29 183.51,96.29 183.25,96.03 180.26,96.03 v1(180.16,96.13)
  IN4 w0.109: v1(185.1,95.94) 185.28,95.76 186.55,95.76 187.08,95.23 189.11,95.23 189.63,95.75 194.32,95.75 195.54,96.97 v1(195.82,96.97) 195.82,96.42 198.36,93.88 198.86,93.88 199.77,92.96 200.93,92.96 201.24,92.65 201.24,91.73 201.91,91.06 203.5,91.06 204.15,90.42 206.65,90.42 v1(207.24,91.01)
  BOTTOM w0.102: JMINI2.14 197.09,97.63 196.7,97.23 196.2,97.23 195.93,96.97 v1(195.82,96.97)
MXM_ALERT#: length 12.7
  TOP w0.102: JMXM1.58 206.6,158.02 206.86,157.76 206.86,156.46 v2(207.65,155.66) 208.89,154.43 208.89,153.76 208.98,153.67 208.98,152.74 R4.2 208.92,149.2 208.82,149.1 208.82,148.39 209.5,147.71 Q5.3
MXM_BIA_PWM: length 142.8
  TOP w0.102: U3.2 80.36,131.65 81.38,130.63 v1(81.74,130.63) ; v1(196.56,156.66) 196.67,156.77 JMXM1.63
  IN1 w0.109: v1(104.43,146.46) 104.06,146.46 103.22,145.62 102.8,145.62 98.92,141.73 98.92,139.04 95.9,136.02 84.77,136.02 84.26,135.51 84.26,133.08 81.81,130.63 v1(81.74,130.63)
  IN2 w0.127: v1(104.43,146.46) 104.99,145.9 116.17,145.9 116.89,146.62 116.89,147.18 117.68,147.97 123.37,147.97 123.91,147.42 128.48,147.42 130.27,145.63 136.94,145.63 137.2,145.38 143.88,145.38 145.43,146.93 158.15,146.93 158.76,146.32 161.47,146.32 162.18,145.61 165.58,145.61 166.51,146.53 168.5,146.53 169.65,147.68 172.02,147.68 172.88,148.54 175.59,148.54 175.75,148.37 181.14,148.37 182.07,147.45 185.79,147.45 187.81,145.43 v1(187.81,144.95)
  BOTTOM w0.102: v1(187.81,144.95) 187.81,145.61 v2(188.7,146.5) 188.82,146.62 191.6,146.62 195.73,150.75 195.73,155.83 v1(196.56,156.66)
MXM_CLK_REQ#: length 8.9
  TOP w0.102: JMXM1.182 207.35,125.02 207.94,125.6 207.94,128.78 208.01,128.85 v1(208.01,128.96) ; v1(208.6,130.84) 209.07,130.37 R7.2
  BOTTOM w0.102: v1(208.6,130.84) 208.63,130.8 208.63,129.59 v2(208.4,129.36) 208.01,128.97 v1(208.01,128.96)
MXM_CRT_BLU: length 188.9
  TOP w0.102: JMXM1.200 207.67,120.52 209.46,122.31 v1(209.46,122.62)
  IN3 w0.127: v1(198.82,142.65) 197.88,142.65 197.24,142.01 196.01,142.01 188.97,134.98 183.49,134.98 182.32,133.81 180.44,133.81 179.98,133.35 163.93,133.35 162.98,134.3 162.09,134.3 159.71,136.68 159.71,136.84 158.6,137.96 151.55,137.96 150.87,137.29 133.36,137.29 127.91,142.74 119.05,142.74 118.67,142.35 111.23,142.35 110.56,143.02 96.11,143.02 95.44,142.34 92.48,142.34 91.17,141.03 85.2,141.03 80.12,146.11 77.04,146.11 74.48,148.67 72.4,148.67 72.01,149.06 72.01,150.25 70.9,151.36 70.39,151.36 69.68,152.07 66.08,152.07 v1(65.58,151.58)
  IN4 w0.109: v1(209.46,122.62) 209.46,129.16 206.79,131.83 206.79,139 206.35,139.45 206.35,142.95 205.97,143.33 205.97,144.08 204.54,145.5 203.59,145.5 203.16,145.94 199.82,145.94 198.66,144.78 198.66,142.8 v1(198.82,142.65)
  BOTTOM w0.102: U19.9 65.09,152.59 v2(65.29,152.39) 65.58,152.1 v1(65.58,151.58)
