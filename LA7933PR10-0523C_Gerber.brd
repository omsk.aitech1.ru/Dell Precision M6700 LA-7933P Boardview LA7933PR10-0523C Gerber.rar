# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CTX_PRX_N2: length 107.5
  TOP w0.089: v1(80.39,46.92) 80.28,46.92 79.9,46.54 JCPU1.F21
  TOP w0.102: v3(44.33,114.87) 44.32,114.87 44.07,114.62 44.07,114.49 43.64,114.07 42.77,113.19 42.15,112.57 41.32,112.57 41.01,112.88 UH4.BG18
  IN4 w0.089: 83.42,78.55 82.76,77.9 82.76,76.29 82.83,76.23 82.81,76.21 82.81,66.31 82.2,65.7 82.2,63.29 82.33,63.16 82.33,53.89 82.04,53.59 82.04,52.86 80.25,51.07 80.25,47.68 80.86,47.07 80.86,46.82 80.39,46.34 80.15,46.34 80.01,46.48 80.01,46.8 80.13,46.92 v1(80.39,46.92)
  IN4 w0.117: v3(44.33,114.87) 44.14,115.06 44.14,115.16 44.46,115.47 45.77,115.47 46.79,114.46 48.05,114.46 50.16,112.35 59.91,112.35 62.34,109.93 62.34,109.55 63.94,107.95 65.36,107.95 67.43,105.89 67.84,105.89 68.21,105.51 68.79,105.51 69.55,104.76 69.55,104.76 71.31,103 75.29,103 76.76,101.53 78.02,101.53 78.5,101.05 78.5,99.66 84.55,93.62 84.55,84.63 83.44,83.52 83.44,78.58 83.42,78.55
DMI_CTX_PRX_N3: length 114.6
  TOP w0.089: JCPU1.D21 79.9,44.43 v5(79.42,43.95)
  TOP w0.102: UH4.BG20 40.78,113.68 41.16,113.68 41.3,113.55 42.1,113.55 42.9,114.35 42.9,114.8 43.41,115.3 43.41,115.42 v1(43.64,115.65)
  IN4 w0.089: v5(79.42,43.95) 79.64,43.73 79.87,43.73 79.92,43.78 79.92,44.09 79.77,44.24 79.77,45.3 79.98,45.52 80.58,45.52 80.77,45.71 80.77,45.75 80.79,45.77 80.79,46.05 81.29,46.55 81.29,47.21 80.67,47.83 80.67,50.76 82.5,52.6 84.66,52.6 85.26,53.2 85.26,66.94 83.8,68.4 83.8,77.81 84.54,78.55
  IN4 w0.117: 84.54,78.55 84.54,78.7 85.5,79.66 85.5,81.51 85.31,81.7 85.31,93.94 79.24,100.01 79.24,101.39 78.07,102.57 76.85,102.57 75.65,103.76 71.6,103.76 69.06,106.29 68.49,106.29 68.02,106.76 67.65,106.76 65.58,108.83 64.15,108.83 63.07,109.9 63.07,110.26 60.24,113.09 50.68,113.09 48.53,115.23 47.2,115.23 46.21,116.22 43.52,116.22 43.31,116.01 43.31,115.89 43.56,115.65 v1(43.64,115.65)
DMI_CTX_PRX_P0: length 105.5
  TOP w0.089: v1(79.37,47.94) 78.9,47.47 JCPU1.G22
  TOP w0.102: v6(39.62,115.35) 39.61,115.41 39.61,115.45 39.27,115.79 UH4.BE24
  IN4 w0.089: 81.82,78.55 81.82,68.43 81.27,67.88 81.27,54.92 81.46,54.73 81.46,54.01 81.01,53.56 81.01,52.69 79.83,51.51 79.83,47.68 79.48,47.32 79.21,47.32 79.14,47.38 79.14,47.71 v1(79.37,47.94)
  IN4 w0.102: v6(39.62,115.35) 39.55,115.35 39.2,115.71 39.2,115.78 39.43,116.01 40.74,116.01 41.1,115.65 41.1,115.21 41.65,114.65 42.67,114.65 42.68,114.64 42.75,114.64 42.75,114.64 42.77,114.64
  IN4 w0.117: 81.82,78.55 81.83,78.56 81.83,84.49 83.78,86.44 83.78,93.34 77.15,99.97 76.35,99.97 74.09,102.24 71.03,102.24 69.28,103.99 68.68,103.99 67.67,105 67.25,105 65.26,107 63.84,107 61.59,109.26 61.59,109.63 59.6,111.62 49.09,111.62 48.62,112.09 48.09,112.09 45.99,114.19 43.35,114.19 42.9,114.64 42.77,114.64
DMI_CTX_PRX_P1: length 104.7
  TOP w0.089: JCPU1.D22 78.9,44.62 79.22,44.95 v1(79.32,44.95)
  TOP w0.102: v1(39.01,114.31) 38.64,113.94 UH4.BC20
  IN4 w0.089: v1(79.32,44.95) 78.96,45.3 78.96,49.64 79.42,50.1 79.42,51.61 80.48,52.66 80.48,54.71 80.6,54.83 80.6,68.17 81.03,68.6 81.03,76.93 79.95,78.01 79.95,78.55
  IN4 w0.102: v1(39.01,114.31) 39.18,114.48 39.18,114.68 39.45,114.95 40.78,114.95 41.62,114.11 42.72,114.11 42.77,114.06
  IN4 w0.117: 42.77,114.06 43.14,113.69 45.74,113.69 47.84,111.59 48.42,111.59 48.89,111.12 59.39,111.12 61.09,109.42 61.09,109.03 63.61,106.5 63.96,106.5 63.96,106.5 65.05,106.5 66.53,105.02 66.53,104.46 67.18,103.81 68.05,103.81 68.36,103.49 69.08,103.49 70.85,101.71 73.9,101.71 76.48,99.14 77.28,99.14 80.72,95.7 80.72,91.05 80.54,90.87 80.54,88.97 80.79,88.72 80.79,84.15 80.19,83.55 80.19,79.56 79.95,79.33 79.95,78.55
DMI_CTX_PRX_P2: length 107.4
  TOP w0.089: v3(80.39,45.94) 80.9,46.45 JCPU1.F20
  TOP w0.102: v1(43.7,114.9) 43.7,114.89 43.85,114.74 43.85,114.58 43.48,114.21 43.48,114.21 42.77,113.5 42.06,112.79 41.87,112.79 41.82,112.84 41.82,113.3 41.77,113.35 41.44,113.35 41.24,113.15 41.24,112.97 41.32,112.88 UH4.BJ18
  IN4 w0.089: v3(80.39,45.94) 80.39,46.05 81.07,46.73 81.07,47.15 80.46,47.76 80.46,50.98 82.25,52.77 82.25,53.51 82.54,53.8 82.54,63.25 82.41,63.38 82.41,65.61 83.02,66.22 83.02,76.12 83.04,76.14 83.04,76.31 82.97,76.38 82.97,77.79 83.68,78.5 83.68,78.55
  IN4 w0.117: 83.68,78.55 83.68,83.43 84.78,84.53 84.78,93.71 78.74,99.76 78.74,101.15 78.12,101.77 76.86,101.77 75.39,103.24 71.41,103.24 69.65,104.99 69.65,104.99 68.89,105.75 68.31,105.75 67.93,106.12 67.52,106.12 65.46,108.19 64.04,108.19 62.57,109.65 62.57,110.02 60.01,112.59 50.25,112.59 48.15,114.69 46.89,114.69 45.87,115.71 44.36,115.71 43.91,115.26 43.91,115.11 v1(43.7,114.9)
DMI_CTX_PRX_P3: length 114.5
  TOP w0.089: v1(80.35,43.95) 79.9,43.49 JCPU1.C21
  TOP w0.102: v6(42.98,115.61) 43.04,115.61 43.18,115.47 43.18,115.38 42.68,114.89 42.68,114.44 42.62,114.38 42.02,113.78 41.9,113.78 41.83,113.84 41.83,114.24 41.72,114.36 41.45,114.36 41.26,114.16 41.26,114.16 41.15,114.05 41.15,113.99 41.26,113.87 UH4.BJ20
  IN4 w0.089: 84.77,78.55 84.77,78.49 84.76,78.48 84.76,78.46 84.63,78.33 84.61,78.33 84.01,77.73 84.01,68.48 85.47,67.02 85.47,53.11 84.75,52.39 82.59,52.39 80.88,50.68 80.88,47.91 81.49,47.3 81.49,46.46 81,45.97 81,45.68 80.98,45.67 80.98,45.63 80.66,45.31 80.07,45.31 79.98,45.22 79.98,44.33 v1(80.35,43.95)
  IN4 w0.117: 84.77,78.55 84.77,78.6 85.74,79.56 85.74,81.61 85.55,81.8 85.55,94.04 79.48,100.11 79.48,101.49 78.16,102.8 76.94,102.8 75.75,104 71.7,104 69.16,106.53 68.59,106.53 68.12,107 67.75,107 65.68,109.06 64.24,109.06 63.31,110 63.31,110.35 60.34,113.32 50.77,113.32 48.63,115.47 47.3,115.47 46.31,116.45 43.42,116.45 43.08,116.11 43.08,115.71 v6(42.98,115.61)
DMIC0: length 140
  TOP w0.102: v1(29.56,36.35) 29.96,35.95 JIO1.33 ; JCAM1.13 8.16,131.2 9.18,132.22 9.18,132.64 10.25,133.71 10.84,133.71 11.25,134.11 D13.2 12.14,134.63 12.62,135.12 v1(12.69,135.12)
  IN3 w0.127: v1(12.69,135.12) 12.72,135.12 13.1,134.73 13.1,131.45 13.87,130.68 13.87,127.67 12.99,126.8 12.2,126.8 10.67,125.26 5.9,125.26 3.12,122.48 3.12,115.81 3.4,115.53 3.4,109.54 2.39,108.52 2.39,85.15 3.4,84.14 3.4,76.13 3.12,75.85 3.12,61.3 5.43,58.99 12.18,58.99 12.69,58.48 23.47,58.48 25.88,56.07 25.88,45.59 27.33,44.15 27.33,42.81 28.54,41.6 28.54,40.73 28.21,40.4 28.21,39.14 29.7,37.64 29.7,36.49 v1(29.56,36.35)
  BOTTOM w0.102: v1(29.56,36.35) 29.59,36.35 v2(30.22,35.71)
DMIC_CLK: length 135.6
  TOP w0.102: v1(12.38,132) 11.68,132.7 D13.3 10.74,132.7 9.76,131.72 9.05,131.72 8.49,131.17 8.49,130.73 7.96,130.2 JCAM1.11 ; v1(28.84,37.48) 29.3,37.48 30.23,36.55 JIO1.31
  IN3 w0.127: v1(28.84,37.48) 28.84,38.11 27.93,39.03 27.93,40.49 28.31,40.87 28.31,41.51 27.1,42.72 27.1,43.94 25.63,45.42 25.63,55.94 23.72,57.85 6.2,57.85 2.7,61.34 2.7,73.81 2.89,74 2.89,75.99 3.15,76.25 3.15,84.01 2.13,85.03 2.13,122.58 5.08,125.53 10.54,125.53 12.11,127.1 12.67,127.1 13.51,127.94 13.51,130.59 12.56,131.55 12.56,131.83 v1(12.38,132)
  BOTTOM w0.102: v1(28.84,37.48) v2(29.78,37.48)
DOCK_AC_OFF: length 239.8
  TOP w0.254: v1(175.36,78.93) PR1014.2
  IN2 w0.127: v1(175.36,78.93) 176.03,79.6 178.36,79.6 178.85,79.12 178.85,77.09 182.41,73.53 182.41,62.47 183.97,60.91 184.57,60.91 184.68,60.8 187.2,60.8 188.96,62.56 192.35,62.56 194.32,60.59 199.03,60.59 199.45,61.01 202.53,61.01 204.31,62.79 226,62.79 226.14,62.65 227.6,62.65 228.83,63.87 v1(228.83,67.12) 229,66.94 242.27,66.94 242.63,67.3 245.07,69.74 248.43,69.74 v1(248.77,69.41) ; v1(81.74,128.01) 81.74,127.86 82.21,127.39 82.55,127.39 82.56,127.38 88.67,127.38 89.93,128.64 94.74,128.64 97.12,126.26 101.71,126.26 103.11,124.87 105.6,124.87 105.88,124.59 107.77,124.59 111.15,121.21 111.15,120.09 111.57,119.67 115.47,119.67 117.37,117.77 119.09,117.77 121.65,115.21 128.46,115.21 129.51,116.27 130.73,116.27 131.21,115.78 131.21,113.65 131.89,112.97 156.74,112.97 v1(158.6,114.82)
  BOTTOM w0.102: v1(158.6,114.82) 157.02,113.25 157.02,112.4 156.83,112.21 156.83,100.34 154.21,97.73 v2(154.21,94.73) 154.21,93.79 155.09,92.91 155.09,90.74 158.94,86.89 167.6,86.89 175.36,79.13 v1(175.36,78.93) ; D34.1 249.21,69.41 v1(248.77,69.41) ; R770.1 228.19,66.49 v1(228.83,67.12) ; JDOCK1.2 v1(81.74,128.01)
DOCK_AC_OFF_EC: length 86.6
  TOP w0.102: v1(245.59,68.64) 245.2,68.25 v2(245.2,64.4) 245.2,63.63 v1(245.45,63.37)
  TOP w0.254: PR1020.2 v1(177.39,78.93) 177.43,78.96 PR1018.1
  IN4 w0.109: v1(245.45,63.37) 243.58,61.51 207.02,61.51 202.49,66.04 194.47,66.04 186.54,73.98 181.93,73.98 177.39,78.51 v1(177.39,78.93)
  BOTTOM w0.102: U46.A63 243.76,68.95 244.07,68.64 U47.2 v1(245.59,68.64)
DOCK_DCIN_IS+: length 14.3
  TOP w0.254: v1(116.66,125.33) 116.66,125.33 116.8,125.18 116.8,124.94 117.91,123.84 118.97,123.84 119.63,123.18 119.63,122.24 118.34,120.94 v2(118.34,120.29) 118.34,119.2 117.95,118.81 116.28,118.81 115.46,119.63 PQ904.6
  BOTTOM w0.102: JDOCK1.134 116.74,125.77 116.84,125.67 116.84,125.51 v1(116.66,125.33)
DOCK_DCIN_IS-: length 15
  TOP w0.254: v1(117.29,125.33) 117.29,125.01 118.08,124.22 119.15,124.22 120.01,123.36 120.01,122.06 119.58,121.63 119.58,119.48 118.22,118.12 v2(116.86,118.12) 115.9,118.12 115.51,117.73 PQ904.4
  BOTTOM w0.102: v1(117.29,125.33) 117.12,125.51 117.12,125.67 117.24,125.79 JDOCK1.136
DOCK_DET#: length 154.9
  TOP w0.102: v1(117.19,128.18) v2(117.19,128.85)
  TOP w0.127: v1(117.19,128.18) D32.2 116.97,127.28 R755.2
  IN2 w0.127: v1(117.19,128.18) 117.64,128.63 124.29,128.63 124.7,129.05 130.53,129.05 131.6,130.11 152.16,130.11 157.3,124.97 166.51,124.97 174.23,117.25 174.89,117.25 181.62,110.52 181.62,107.53 186.66,102.48 186.66,100.4 189.16,97.9 189.16,97.4 188.78,97.02 188.78,96.65 189.93,95.5 190.4,95.5 193.66,92.25 193.66,89.32 198.66,84.32 208.57,84.32 209.99,82.89 214.44,82.89 216.39,80.94 221.87,80.94 224.39,78.42 224.39,76.82 225.29,75.92 229.82,75.92 230.38,75.36 231.14,75.36 232.74,73.76 233.59,73.76 233.61,73.78 234.87,73.78 235.39,74.3 v1(235.39,75.13)
  BOTTOM w0.102: U46.B41 235.83,76.01 235.89,75.95 235.89,75.54 235.48,75.13 v1(235.39,75.13)
DOCK_DET_R#: length 5.3
  TOP w0.127: v1(118.85,125.29) 118.73,125.17 v2(117.91,125.17) 117.74,125.34 117.74,125.56 D32.1
  BOTTOM w0.102: JDOCK1.144 119.24,125.66 118.87,125.29 v1(118.85,125.29) 118.85,125.31 118.75,125.4 118.75,126.69 JDOCK1.142
DOCK_HP_DET: length 284.1
  TOP w0.102: v1(28.97,34.84) 29.18,35.05 29.77,35.05 30.07,35.35 JIO1.35 ; v1(235.02,59.93) v2(235.02,60.59)
  IN1 w0.109: v1(235.02,59.93) 236.05,60.96 236.05,63.46 237.64,65.05 v1(238.07,65.05)
  IN4 w0.109: v1(235.02,59.93) 231.33,59.93 230.88,59.48 226.88,59.48 224.87,57.47 223.79,57.47 223.17,58.09 195.66,58.09 193.33,55.76 193.33,54.76 192.09,53.52 186.25,53.52 185.44,52.71 180.99,52.71 178.19,49.91 175.67,49.91 164.14,38.38 164.14,22.99 160.73,19.58 160.73,16.06 160.15,15.48 160.15,14.35 159.83,14.03 155.19,14.03 154.5,13.35 132.47,13.35 131.41,12.28 127.13,12.28 127.02,12.17 125.63,12.17 125.51,12.28 123.29,12.28 122.85,11.84 121.98,11.84 121.32,11.17 120.86,11.17 120.36,11.67 120.36,12.58 117.42,15.52 114.53,15.52 111.9,12.89 111.9,10.95 111.07,10.12 110.08,10.12 109.38,9.42 108.22,9.42 106.11,7.32 36.52,7.32 34.1,9.74 31.69,9.74 29.12,12.31 29.12,21.99 30.96,23.84 30.96,33.86 29.98,34.84 v1(28.97,34.84)
  BOTTOM w0.102: v1(238.07,65.05) 237.58,65.54 U46.A7
DOCK_LOM_ACTLED_YEL#: length 24.2
  TOP w0.102: v1(108.51,128.07) 109.13,127.45 110.01,127.45 110.25,127.69 110.25,129.26 v2(115.45,134.46) 116.01,135.03 116.01,139.79 116.61,140.39 116.61,142.49 117.28,143.17 117.75,143.17 118.16,143.57 U32.19
  BOTTOM w0.102: v1(108.51,128.07) 108.24,127.8 JDOCK1.100
DOCK_LOM_SPD10LED_GRN#: length 97.7
  TOP w0.102: v1(130.53,115.43) 130.73,115.23 v2(132.21,115.23) 132.92,115.23 136.41,118.72 136.41,126.76 135.76,127.41 132.37,127.41 130.96,128.82 130.96,132.23 129.06,134.14 129.06,137.33 130.52,138.79 130.52,142.79 130.24,143.07 U32.40
  IN2 w0.127: v1(130.53,115.43) 129.79,114.69 120.37,114.69 118.72,116.34 116.51,116.34 114.34,118.5 108.85,118.5 106.83,120.52 104.74,120.52 102.36,122.9 99.54,122.9 98.78,123.66 97.26,123.66 96.57,124.35 93.83,124.35 92.25,125.92 90.18,125.92 85.6,121.34 82.27,121.34 v1(81.76,120.83)
  BOTTOM w0.102: v1(81.76,120.83) 82.27,120.32 82.27,118.73 JDOCK1.3
DOCK_LOM_SPD100LED_ORG#: length 60
  TOP w0.102: U32.20 118.23,143.07 117.94,142.79 117.24,142.79 116.86,142.41 116.86,140.22 116.33,139.69 116.33,134.33 v2(113.37,131.36) 111.83,129.83 111.83,124.98 111.54,124.69 v1(111.38,124.69)
  IN2 w0.127: v1(82.97,128.77) 83.31,128.42 86.63,128.42 87.65,129.45 95.91,129.45 96.33,129.03 102.98,129.03 103.78,129.83 106.27,129.83 106.58,129.52 111.43,129.52 111.82,129.13 111.82,125.13 v1(111.38,124.69)
  BOTTOM w0.102: JDOCK1.4 82.24,128.04 v1(82.97,128.77)
DOCK_LOM_TRD0+: length 20.4
  TOP w0.089: v3(119.68,138.32) 119.82,138.46 119.82,140.96 119.8,140.98 U32.22
  IN1 w0.102: v3(119.68,138.32) 119.89,138.11 119.89,137.97 112,130.09 110.7,130.09 109.67,129.05 109.67,128.92 109.41,128.66 109.41,128.32 v1(109.17,128.08)
  BOTTOM w0.089: v1(109.17,128.08) 109.33,127.91 109.33,127.67 109.24,127.58 JDOCK1.104
DOCK_LOM_TRD0-: length 20.2
  TOP w0.089: U32.23 120.3,141.01 120.17,140.88 120.17,138.46 v1(120.31,138.32)
  IN1 w0.102: v3(109.8,128.08) 109.76,128.12 109.76,128.52 110.02,128.77 110.02,128.9 110.85,129.73 112.15,129.73 120.24,137.82 120.24,138.25 v1(120.31,138.32)
  BOTTOM w0.089: JDOCK1.106 109.74,127.66 109.68,127.72 109.68,127.95 v3(109.8,128.08)
DOCK_LOM_TRD1+: length 20.5
  TOP w0.089: v3(121.73,139.87) 121.88,140.01 121.88,140.92 121.8,141 U32.26
  IN1 w0.102: v3(121.73,139.87) 121.87,139.73 121.87,138.99 121.49,138.61 121.49,137.85 112.51,128.87 111.31,128.87 111,128.55 111,128.31 v1(110.72,128.04)
  BOTTOM w0.089: v1(110.72,128.04) 110.89,127.87 110.89,127.78 110.74,127.62 JDOCK1.110
DOCK_LOM_TRD1-: length 20.3
  TOP w0.089: v1(122.37,139.87) 122.22,140.01 122.22,140.92 122.3,140.99 U32.27
  IN1 w0.102: v1(122.37,139.87) 122.23,139.73 122.23,138.84 121.85,138.46 121.85,137.7 112.66,128.51 111.46,128.51 111.35,128.4 111.35,128.05 v3(111.36,128.04)
  BOTTOM w0.089: JDOCK1.112 111.24,127.92 v3(111.36,128.04)
DOCK_LOM_TRD2+: length 19.6
  TOP w0.089: U32.31 124.3,140.92 124.38,140.84 124.38,139.97 v1(124.33,139.91)
  IN1 w0.102: v1(124.33,139.91) 124.46,139.77 124.46,139.09 114.49,129.12 114.49,129.1 113.85,128.47 113.85,128.34 v3(113.64,128.13)
  BOTTOM w0.089: JDOCK1.122 113.74,127.76 113.8,127.82 113.8,127.97 v3(113.64,128.13)
DOCK_LOM_TRD2-: length 19.6
  TOP w0.089: U32.32 124.8,140.92 124.72,140.84 124.72,140.15 v3(124.96,139.91)
  IN1 w0.102: v1(114.27,128.13) 114.21,128.2 114.21,128.32 114.84,128.96 114.84,128.97 124.82,138.94 124.82,139.77 v3(124.96,139.91)
  BOTTOM w0.089: v1(114.27,128.13) 114.15,128 114.15,127.85 114.24,127.76 JDOCK1.124
DOCK_LOM_TRD3+: length 21.9
  TOP w0.089: v1(126.23,140.03) 126.38,140.18 126.38,140.84 126.3,140.92 U32.35
  IN1 w0.102: v3(120.35,129.86) 120.55,130.05 120.55,131.01 126.37,136.83 126.37,139.89 v1(126.23,140.03)
  BOTTOM w0.089: v3(120.35,129.86) 120.53,129.67 120.53,129.49 120.02,128.98 116.87,128.98 116.7,128.8 116.26,128.8 115.4,127.94 115.4,127.77 115.24,127.61 JDOCK1.128
DOCK_LOM_TRD3-: length 21.8
  TOP w0.089: U32.36 126.8,140.92 126.72,140.84 126.72,140.18 v3(126.87,140.03)
  IN1 w0.102: v1(120.99,129.86) 120.9,129.94 120.9,130.86 126.73,136.68 126.73,139.89 v3(126.87,140.03)
  BOTTOM w0.089: v1(120.99,129.86) 120.88,129.75 120.88,129.35 120.17,128.64 117.02,128.64 116.84,128.46 116.41,128.46 115.74,127.79 JDOCK1.130
DOCK_MIC_DET: length 287.6
  TOP w0.102: v1(236.68,68.97) 236.68,69.09 v2(237.09,69.51) ; v1(28.99,34.15) 29.06,34.21 29.06,34.23 29.58,34.75 JIO1.37
  IN1 w0.109: v1(236.68,68.97) 236.28,68.58 236.28,66.8 235.52,66.04 235.52,65.05 232.78,62.31 232.78,59.54 v1(232.38,59.14)
  IN4 w0.109: v1(28.99,34.15) 29.44,34.59 29.9,34.59 30.73,33.76 30.73,23.97 28.55,21.78 28.55,18.99 27.71,18.15 27.71,13.15 32.08,8.78 34.68,8.78 36.37,7.09 106.2,7.09 108.31,9.2 109.48,9.2 110.18,9.89 111.26,9.89 112.15,10.78 112.15,12.82 114.62,15.29 117.33,15.29 120.15,12.47 120.15,11.58 120.83,10.9 121.35,10.9 122.06,11.61 123.02,11.61 123.46,12.05 125.44,12.05 125.54,11.96 127.11,11.96 127.2,12.05 131.69,12.05 132.75,13.12 154.6,13.12 155.27,13.79 159.92,13.79 160.39,14.26 160.39,15.4 160.96,15.97 160.96,19.48 164.37,22.89 164.37,38.28 175.77,49.68 178.34,49.68 179.35,50.69 180.31,50.69 180.92,51.3 190.19,51.3 193.57,54.68 193.57,55.69 195.74,57.86 223.07,57.86 223.7,57.24 224.94,57.24 226.96,59.27 232.26,59.27 v1(232.38,59.14)
  BOTTOM w0.102: U46.B8 237.33,67.89 237.17,68.05 237.17,68.64 236.84,68.97 v1(236.68,68.97)
DOCK_POR_RST#: length 66.1
  TOP w0.102: U54.B22 164.72,142.92 165.09,143.28 v1(165.53,143.28)
  IN1 w0.109: v1(161.1,132.78) 159.38,132.78 158.48,133.68 156.51,133.68 155.81,132.98 155.14,132.98 154.68,133.45 137.94,133.45 137.12,132.63 126.95,132.63 122.17,127.85 121.26,127.85 119.7,126.29 119.7,125.49 118.87,124.66 118.58,124.66 v1(118.51,124.73)
  BOTTOM w0.102: C736.1 165.23,142.98 v1(165.53,143.28) ; C736.1 165.23,141.43 165.5,141.16 v2(165.5,140.78) 165.5,138.74 165.72,138.52 165.72,135.14 163.49,132.91 161.22,132.91 v1(161.1,132.78) ; C736.1 R881.2 ; JDOCK1.140 118.24,125.08 118.51,124.8 v1(118.51,124.73)
DOCK_PSID: length 237.4
  TOP w0.127: v1(117.71,120.97) 117.28,121.4 114.34,121.4 114.16,121.58 114.16,126.78 114.81,127.43 114.81,130.26 117.24,132.7 117.24,138.71 v1(117.33,138.8)
  IN2 w0.127: v1(2.41,76.83) 2.74,77.16 2.74,82.02 1.76,83 1.76,100.53 3.33,102.1 3.33,102.59 1.1,104.81 1.1,133.99 1.04,134.05 1.04,136.84 4,139.8 7.19,139.8 7.87,140.49 9.36,140.49 11.1,142.23 11.1,147.23 13.78,149.91 14.17,149.91 17.63,153.38 26.86,153.38 30.85,157.37 36.24,157.37 39.74,160.86 44.03,160.86 45.37,159.53 47.36,159.53 48.66,160.83 54.71,160.83 55.95,162.08 73.84,162.08 77.1,158.82 77.1,156.46 82.27,151.3 96.96,151.3 97.18,151.51 104.09,151.51 105.36,150.24 107.89,150.24 109.29,151.64 114.09,151.64 115.24,150.5 115.24,150.42 v1(115.26,150.39)
  BOTTOM w0.127: v1(117.71,120.97) 117.3,120.55 117.3,119.99 117.24,119.93 JDOCK1.135 ; v1(117.33,138.8) 117.49,138.8 117.96,139.27 117.96,142.24 116.91,143.28 116.91,148.58 v2(116.56,148.93) 115.26,150.23 v1(115.26,150.39)
  BOTTOM w0.254: v1(2.41,76.83) 2.75,76.48 PU1.1
DOCK_PWR_BTN#: length 76.6
  TOP w0.102: R825.2 157.23,152.46 C733.1 155.52,151.67 155.18,151.33 154.6,151.33 154.13,151.8 153.47,151.8 152.83,151.17 152.83,149.64 152.94,149.53 152.94,147.92 152.83,147.8 152.83,139.47 v2(158.14,134.16) 158.37,133.93 v1(158.37,132.87)
  IN1 w0.109: v1(118.92,120.64) 118.97,120.69 118.97,121.08 119.61,121.72 119.61,125.06 119.92,125.37 119.92,126.15 121.4,127.62 122.32,127.62 127.06,132.36 137.18,132.36 138.04,133.22 154.58,133.22 155.05,132.75 155.05,132.75 155.28,132.51 158.01,132.51 v1(158.37,132.87)
  BOTTOM w0.102: v1(118.92,120.64) 118.24,119.96 JDOCK1.139
DOCK_PWR_SW#: length 32.5
  TOP w0.102: U54.A1 158.88,150.88 C734.1 R825.1 R819.2 159.47,153.61 v1(159.6,153.48) ; U10.1 v1(144.01,170.73) v2(144.01,171.39)
  IN3 w0.127: v1(144.01,170.73) 144.02,170.73 152.72,162.03 153.76,162.03 156.21,159.58 156.21,159.29 157.36,158.14 157.36,156.01 159.6,153.77 v1(159.6,153.48)
DOCK_SMB_ALERT#: length 268.6
  TOP w0.102: v1(209.52,23.62) 208.76,24.38 208.76,53.4 209.78,54.42 215.43,54.42 215.59,54.59 233.16,54.59 v2(233.35,54.39) 237.45,54.39 238.49,55.43 238.49,55.41 241.65,58.58 241.65,64.45 242.56,65.35 242.56,69.56 242.87,69.88 243.47,69.88 243.93,70.33 244.23,70.33 245.08,71.18 245.08,75.65 v1(244.07,76.67) ; v1(205.89,9.67) 205.94,9.61 PQ1.3
  IN1 w0.109: v1(209.52,23.62) 209.33,23.43 209.33,13.11 v1(205.89,9.67)
  IN2 w0.127: v1(244.07,76.67) 243.66,76.26 243.18,76.26 241.1,74.18 240.75,74.18 240.3,73.73 240.3,73.39 240.04,73.14 238.26,73.14 237.96,72.84 233.94,72.84 233.93,72.82 233.47,72.82 233.15,73.14 232.71,73.14 230.95,74.91 228.56,74.91 228.46,74.8 225.98,74.8 225.83,74.96 224.05,74.96 223.24,74.15 218.8,74.15 216.89,76.06 216.89,78.87 215.03,80.73 207.07,80.73 205.03,82.78 199.21,82.78 192.31,89.68 192.31,92.26 190.47,94.11 189.95,94.11 187.93,96.13 187.67,96.13 187.04,96.75 187.04,97.18 184.57,99.66 184.57,100.69 183.77,101.48 182.9,101.48 181.7,102.68 181.7,104.07 180.69,105.08 180.69,106.39 180.21,106.87 180.21,110.11 177.28,113.04 169.02,113.04 168.78,113.28 166.85,113.28 164.86,115.28 157.33,115.28 155.25,113.2 131.99,113.2 131.44,113.74 131.44,115.88 130.25,117.07 128.31,117.07 127.59,116.35 120.85,116.35 117.92,119.28 117.88,119.28 v1(116.84,120.32)
  BOTTOM w0.102: v1(116.84,120.32) 116.84,119.91 116.74,119.82 JDOCK1.133 ; U46.A51 242.54,74.95 243.37,75.78 244,75.78 R763.2 244.39,76.86 244.26,76.86 v1(244.07,76.67)
DOCK_SMB_CLK: length 82.1
  TOP w0.102: U54.B4 162.7,149.63 v1(162.83,149.76) ; v3(157.44,135.84) 157.39,135.84 153.34,139.89 153.34,147.61 153.43,147.7 153.43,149.78 153.34,149.87 153.34,150.57 v1(153.81,151.04)
  IN3 w0.127: v3(157.44,135.84) 157.41,135.81 157.41,135.79 156.86,135.23 155.15,135.23 154.66,134.73 131.85,134.73 131.44,134.33 129.5,134.33 124.06,128.89 121.05,128.89 121.03,128.92 121.02,128.92 117.99,125.9 117.99,125.36 117.3,124.66 115.54,124.66 114.46,123.58 114.46,121.49 115.17,120.78 v1(115.17,120.6)
  BOTTOM w0.102: v1(162.83,149.76) 162.81,149.77 162.79,149.77 162.1,150.46 159.41,150.46 158.55,149.59 R841.1 158.24,149.59 157.67,150.17 156.98,150.17 156.79,150.36 156.36,150.36 156.12,150.11 154.74,150.11 v1(153.81,151.04) ; JDOCK1.127 115.24,119.71 115.34,119.81 115.34,120.43 v1(115.17,120.6)
DOCK_SMB_DAT: length 80.9
  TOP w0.102: U54.A3 161.05,149.88 160.37,150.56 R838.1 157.75,151.11 v2(155.66,151.11) 154.47,151.11 154.01,151.56 153.62,151.56 153.08,151.03 153.08,149.77 153.17,149.68 153.17,147.81 153.08,147.72 153.08,139.55 157.28,135.36 157.8,135.36 157.81,135.37 v1(157.92,135.37)
  IN3 w0.127: v1(115.81,120.6) 115.81,120.64 114.74,121.7 114.74,123.38 115.67,124.31 117.38,124.31 118.29,125.21 118.29,125.78 121.14,128.64 124.17,128.64 129.61,134.07 131.55,134.07 131.95,134.48 154.76,134.48 155.26,134.98 157.41,134.98 157.81,135.37 v1(157.92,135.37)
  BOTTOM w0.102: v1(115.81,120.6) 115.68,120.47 115.68,119.66 115.74,119.6 JDOCK1.129
DOCKED: length 278.9
  TOP w0.102: v1(121.91,145.99) 121.8,145.88 U32.13 ; v1(230.43,78.45) 230.43,78.48 231.05,79.11 232.71,79.11 233.13,79.53 234.62,79.53 v1(235.02,79.12) ; v1(116.79,139.42) 116.79,134.11 112.11,129.43 112.11,125.29 112.62,124.78 v1(112.62,124.68)
  IN1 w0.109: v1(116.79,139.42) 116.79,139.5 120.22,142.93 120.22,144.3 v1(121.91,145.99)
  IN2 w0.127: v1(116.79,139.42) 115.92,139.42 114.92,140.42 111.24,140.42 110.48,139.66 108.88,139.66 107.58,140.96 105.19,140.96 104.42,141.73 92.94,141.73 91.16,139.95 89.3,139.95 88.46,140.8 84.16,140.8 81.62,138.25 76.53,138.25 75.96,137.68 75.47,137.68 75.18,137.97 74.8,137.97 74.66,137.83 73.81,137.83 73.44,138.2 73.44,138.37 72.82,138.99 71.84,138.99 70,140.83 69.8,140.83 68.55,142.08 68.2,142.08 67.55,142.72 66.57,142.72 65.45,141.59 63.52,141.59 63.12,141.19 52.42,141.19 51.46,140.23 46.63,140.23 46.24,139.84 45.93,139.84 v1(45.74,139.65) ; v1(226.45,75.48) 226.39,75.41 223.86,75.41 223.05,74.6 218.99,74.6 217.35,76.25 217.35,79.66 214.41,82.6 205.85,82.6 205.22,83.24 199.41,83.24 193.43,89.21 193.43,92.15 190.55,95.03 190.08,95.03 188.47,96.65 188.47,97.6 185.67,100.39 185.67,101.21 185.24,101.64 185.24,103.01 181.08,107.18 181.08,110.49 176.25,115.32 175.33,115.32 167.24,123.41 157.81,123.41 156.3,121.9 156.3,119.09 152.82,115.61 140.23,115.61 139.3,116.54 133.58,116.54 132.93,117.18 132.93,119.69 131.72,120.89 127.82,120.89 123.96,117.03 121.13,117.03 119.68,118.48 119.68,120.49 119.63,120.54 119.63,120.95 119.04,121.54 113.69,121.54 112.62,122.61 v1(112.62,124.68)
  IN3 w0.127: v1(230.43,78.45) 230.39,78.41 228.31,78.41 226.49,76.59 226.49,75.51 v1(226.45,75.48)
  BOTTOM w0.102: v1(45.74,139.65) 45.88,139.51 v2(45.88,138.67) 45.88,137.99 45.12,137.22 Q326.2 ; v1(235.02,79.12) 235.02,79.13 235.58,78.58 U46.A38
DOCKED#: length 6
  TOP w0.102: U9.45 40.97,140.09 v1(40.99,140.07)
  BOTTOM w0.102: v1(40.99,140.07) v2(40.99,139.32) 41.76,138.56 R518.2 42.09,137.87 Q326.6
DP_A_MXM_AUX_Q: length 8.2
  TOP w0.102: v1(290.05,63.34) v2(291.39,63.34) 293.46,63.34 v1(293.85,63.73)
  BOTTOM w0.102: Q339.3 290.79,62.69 290.68,62.57 290.41,62.57 290.26,62.72 290.26,63.13 v1(290.05,63.34) R2193.2 ; Q340.2 v1(293.85,63.73) Q340.5
DP_CFG0: length 3.5
  TOP w0.102: U9.44 40.57,142.04 40.66,141.95 40.66,141.49 v2(40.46,141.29) 40.29,141.12 R61.2 R64.2
DP_CFG1: length 5.3
  TOP w0.102: R73.2 37.53,152.98 R72.2 38.5,150.97 v2(38.5,150.89) 38.5,148.96 38.75,148.71 U9.29
DP_MB_P14: length 12.3
  TOP w0.102: R801.2 v1(290.37,142.62)
  BOTTOM w0.102: JDP1.14 295.3,143.75 295.64,143.41 295.64,140.23 295.34,139.93 292.3,139.93 v2(290.63,141.6) 290.37,141.86 v1(290.37,142.62)
DP_MUX_PRIORITY: length 8.5
  TOP w0.102: v1(21.51,122.3) 21.49,122.28 21.49,121.95 UH4.H36
  BOTTOM w0.102: RH163.2 14.44,122.42 14.86,122.42 15.26,122.01 15.71,122.01 15.73,122.03 16.32,122.03 16.36,122 16.36,121.96 16.62,121.69 21.06,121.69 v2(21.18,121.82) 21.5,122.14 21.5,122.3 v1(21.51,122.3)
DP_RP_CEXT: length 5.1
  BOTTOM w0.102: C87.1 278.66,69.23 278.67,69.23 278.84,69.41 v2(278.84,70.03) 278.84,70.33 278.76,70.41 278.76,71.46 279.34,72.04 U22.2
DP_RP_CFG0: length 3.8
  BOTTOM w0.102: U22.5 278.9,73.54 R77.1 R76.2
DP_RP_CFG1: length 3.9
  BOTTOM w0.102: U22.40 285.03,69.84 v2(285.44,69.43) 286.36,68.51 R78.2 R79.1
DP_RP_PEQ: length 5.3
  BOTTOM w0.102: U22.4 v2(278.95,73.04) 278.48,72.58 278.48,71.09 R80.2 R81.1
DP_RP_REXT: length 2.7
  BOTTOM w0.102: U22.7 278.89,74.54 v2(278.82,74.48) R75.2
DPC_CA_DET: length 67.4
  TOP w0.102: U21.2 106.09,149.16 105.87,148.93 105.87,148.31 106.23,147.94 107.25,147.94 107.64,147.55 107.64,143.28 106.12,141.76 v2(106.12,141) 106.12,139.57 ; 106.12,139.57 109.93,139.57 110.67,140.31 110.67,143.07 111.14,143.54 R492.2 C1174.1 112.37,144.44 112.96,145.03 U20.1 112.96,147.55 113.22,147.82 113.78,147.82 114.02,147.57 114.02,147.43 114.91,146.55 U20.4 ; 106.12,139.57 106.12,138.75 106.84,138.03 106.85,138.03 107.09,137.79 107.09,137.78 107.59,137.28 108.18,137.28 Q110.2 108.32,136.97 107.96,136.61 107.96,135.14 106.45,133.63 106.45,130.05 v1(105.75,129.35)
  IN2 w0.127: v1(82.98,128.05) 86.83,128.05 87.8,129.03 95.32,129.03 95.54,128.8 105.21,128.8 v1(105.75,129.35)
  BOTTOM w0.102: v1(82.98,128.05) 82.74,127.81 JDOCK1.6
DPC_CA_DET#: length 12.3
  TOP w0.102: v1(115.95,150.38) 115.56,150.77 U20.10 ; U21.4 109.34,148.51 109.69,148.86 109.69,149.99 109.94,150.24 v2(110.21,150.24) 112.06,150.24 112.39,149.91 112.84,149.91 v1(113.27,150.34) 113.35,150.34 113.61,150.61 U20.13
  IN3 w0.127: v1(113.27,150.34) 113.93,151 115.33,151 v1(115.95,150.38)
DPC_DOCK_AUX: length 13.4
  TOP w0.102: v1(113.51,147.33) 113.51,147.27 113.59,147.19 113.59,146.94 113.61,146.92 U20.2 ; C387.1 115.67,154.46 115.67,154.62 v3(115.49,154.8)
  IN3 w0.127: v1(113.51,147.33) 113.57,147.27 113.59,147.27 113.89,146.96 114.35,146.96 117.45,150.06 117.45,150.6 115.69,152.36 115.69,154.59 115.49,154.79 v3(115.49,154.8)
DPC_DOCK_AUX#: length 13.5
  TOP w0.102: v1(116.19,154.79) 115.94,154.53 115.94,154.43 116.25,154.12 C388.1 ; v3(115.67,146.96) 115.56,146.85 U20.5
  IN3 w0.127: v3(115.67,146.96) 115.67,146.93 115.33,146.58 114.91,146.58 114.76,146.74 114.76,146.94 117.75,149.94 117.75,150.72 115.99,152.48 115.99,154.59 v1(116.19,154.79)
DPC_DOCK_LANE_C_N0: length 1.7
  BOTTOM w0.102: R2173.2 83.12,132.05 82.99,132.17 82.99,133.02 83.12,133.14 C438.1
DPC_DOCK_LANE_C_N1: length 1.5
  BOTTOM w0.102: C440.1 85.14,132.84 85.14,132.19 85.24,132.09 R2175.2
DPC_DOCK_LANE_C_N2: length 1.7
  BOTTOM w0.102: C442.1 87.2,133.14 87.1,133.04 87.1,132.19 87.2,132.09 R2177.2
DPC_DOCK_LANE_C_N3: length 1.6
  BOTTOM w0.102: R2179.2 89.24,132.09 89.15,132.17 89.15,132.93 89.36,133.14 C444.1
DPC_DOCK_LANE_C_P0: length 1.7
  BOTTOM w0.102: C431.1 82.64,133.14 82.73,133.05 82.73,132.14 82.64,132.05 R2172.2
DPC_DOCK_LANE_C_P1: length 1.5
  BOTTOM w0.102: C439.1 84.43,133.13 84.87,132.69 84.87,132.21 84.75,132.09 R2174.2
DPC_DOCK_LANE_C_P2: length 1.6
  BOTTOM w0.102: R2176.2 86.7,132.09 86.83,132.21 86.83,133.02 86.7,133.14 C441.1
DPC_DOCK_LANE_C_P3: length 1.6
  BOTTOM w0.102: R2178.2 88.7,132.09 88.89,132.27 88.89,132.94 88.68,133.14 C443.1
DPC_DOCK_LANE_N0_R: length 5
  BOTTOM w0.102: R2173.1 82.99,130.78 82.99,129.83 84.1,128.73 84.1,127.75 84.24,127.61 JDOCK1.12
DPC_DOCK_LANE_N1_R: length 4.8
  BOTTOM w0.102: JDOCK1.18 85.74,127.61 85.63,127.71 85.63,128.69 85.19,129.13 85.19,130.81 R2175.1
DPC_DOCK_LANE_N2_R: length 4.6
  BOTTOM w0.102: JDOCK1.24 87.24,127.58 87.11,127.71 87.11,130.77 R2177.1
DPC_DOCK_LANE_N3_R: length 4.8
  BOTTOM w0.102: JDOCK1.30 88.74,127.75 88.63,127.86 88.63,128.68 89.15,129.2 89.15,130.7 R2179.1
DPC_DOCK_LANE_P0_R: length 5
  BOTTOM w0.102: JDOCK1.10 83.74,127.61 83.83,127.7 83.83,128.62 82.73,129.72 v1(82.73,130.12) 82.73,130.77 R2172.1
DPC_DOCK_LANE_P1_R: length 4.8
  BOTTOM w0.102: JDOCK1.16 85.24,127.66 85.37,127.79 85.37,128.58 84.92,129.02 v1(84.92,129.97) 84.92,130.77 R2174.1
DPC_DOCK_LANE_P2_R: length 4.6
  BOTTOM w0.102: JDOCK1.22 86.74,127.61 86.84,127.71 v1(86.84,130.05) 86.84,130.75 R2176.1
DPC_DOCK_LANE_P3_R: length 4.8
  BOTTOM w0.102: JDOCK1.28 88.24,127.75 88.37,127.87 88.37,128.79 88.7,129.13 88.89,129.31 v1(88.89,130.04) 88.89,130.67 R2178.1
DPC_DOCK_SW_AUX: length 57.9
  TOP w0.102: U20.3 114.26,144.95 114.32,144.88 114.63,144.88 114.76,144.76 114.76,144.55 114.45,144.24 114.45,143.8 114.4,143.75 114.06,143.75 R1538.2 114.45,143.02 114.45,141.97 114.26,141.78 113.96,141.78 113.36,141.19 112.33,141.19 v1(112.15,141.01) 111.81,140.67 Q113.1 ; U20.11 114.91,150.71 114.63,150.43 v1(114.63,150.42)
  IN1 w0.117: v3(110.6,133.26) 110.34,133.52 110.01,133.52 109.75,133.78 109.75,138.09 112.15,140.49 v1(112.15,141.01) 112.45,141.31 112.45,142.39 113.63,143.56 113.63,144.84 112.33,146.14 112.33,149.07 113.16,149.9 113.52,149.9 114.04,150.42 v1(114.63,150.42)
  IN4 w0.117: v3(110.6,133.26) 110.6,133.26 110.42,133.43 110.15,133.43 109.48,132.76 105.81,132.76 105.16,132.11 99.37,132.11 97.23,129.98 91.91,129.98 91.02,129.09 90.47,129.09 90.13,129.43 90.13,129.75 v1(89.96,129.92)
  BOTTOM w0.102: JDOCK1.34 89.74,127.75 89.86,127.87 89.86,128.36 90.14,128.64 90.14,129.74 v1(89.96,129.92)
DPC_DOCK_SW_AUX#: length 60.5
  TOP w0.102: v1(112.11,139.52) 112.27,139.37 Q113.4 113.34,139.37 113.77,139.79 114.15,139.79 R1523.2 114.72,139.79 114.72,144.13 115.31,144.73 115.87,144.73 116.21,145.06 U20.6 ; U20.8 116.86,150.82 117,150.67 v1(117,150.34)
  IN1 w0.117: v1(117,150.34) 116.6,149.94 114.03,149.94 113.71,149.61 113.27,149.61 112.61,148.96 112.61,146.26 113.91,144.96 113.91,143.44 112.74,142.27 112.74,141.19 112.67,141.13 112.67,140.08 v1(112.11,139.52) 112.02,139.62 111.69,139.62 111.52,139.45 110.04,137.97 110.04,133.9 110.13,133.81 110.52,133.81 v3(110.6,133.89)
  IN4 w0.117: v1(90.59,129.92) 90.42,129.75 90.42,129.54 90.59,129.38 90.9,129.38 91.79,130.26 97.12,130.26 99.25,132.4 105.04,132.4 105.69,133.05 109.36,133.05 110.03,133.72 110.43,133.72 v3(110.6,133.89)
  BOTTOM w0.102: v1(90.59,129.92) 90.41,129.74 90.41,128.53 90.12,128.25 90.12,127.87 90.24,127.75 JDOCK1.36
DPD_CA_DET: length 87.4
  TOP w0.102: U9.42 38.84,143.51 38.1,142.77 R491.2 v2(37.19,141.75) v1(37.83,141.11)
  BOTTOM w0.102: 52.4,140.92 51.24,140.92 50.84,140.51 38.43,140.51 v1(37.83,141.11) ; 52.4,140.92 52.41,140.93 52.41,147.08 52.06,147.43 51.15,147.43 50.84,147.75 48.46,147.75 48.08,148.13 C1332.1 48.22,151.09 Q336.2 ; 52.4,140.92 52.97,140.92 53.3,140.59 53.3,140.26 53.49,140.07 54.18,140.07 54.45,140.34 64.87,140.34 65.06,140.15 67.71,140.15 71.02,136.84 71.98,136.84 73.28,135.55 73.28,131.29 71.49,129.5 71.49,125.02 72.48,124.03 72.48,121.39 77.85,116.02 81.49,116.02 82.14,116.66 82.14,117.18 82.74,117.78 JDOCK1.5
DPD_DOCK_AUX: length 97.6
  TOP w0.102: v1(45.03,141.73) 44.97,141.79 U9.55
  IN4 w0.117: v3(89.79,117.03) 89.88,117.03 90.16,116.74 90.16,116.36 88.74,114.94 75.33,114.94 71.41,118.86 71.41,122.6 70.51,123.5 70.51,127.73 70.88,128.09 70.88,130.54 71.27,130.94 71.27,131.52 71.98,132.23 71.98,135.51 71.51,135.98 70.41,135.98 68.38,138.01 64.91,138.01 64.22,138.7 63.07,138.7 61.13,140.64 54.69,140.64 54.07,141.25 51.59,141.25 50.92,140.58 45.31,140.58 44.77,141.12 44.77,141.47 v1(45.03,141.73) 44.83,141.93 44.83,142.92 46.59,144.68 46.59,147.16 48.17,148.74 48.17,151.46 49.24,152.52 50.92,152.52 52.01,153.61 52.01,156.88 v1(51.48,157.4)
  BOTTOM w0.102: v3(89.79,117.03) 89.88,117.03 90.23,117.39 90.23,117.49 90.18,117.54 89.72,117.54 89.67,117.59 89.67,117.7 89.74,117.77 JDOCK1.33 ; Q337.1 53.87,156.53 53.4,157 52.53,157 52.27,156.74 R2162.2 51.91,156.98 v1(51.48,157.4)
DPD_DOCK_AUX#: length 93.8
  TOP w0.102: U9.54 44.57,141.91 v3(44.4,141.73)
  IN4 w0.117: v1(51.41,154.84) 51.73,154.52 51.73,153.73 50.8,152.81 49.12,152.81 47.89,151.58 47.89,148.85 46.31,147.27 46.31,144.8 44.55,143.03 44.55,141.88 v3(44.4,141.73) 44.49,141.64 44.49,141 45.19,140.3 51.04,140.3 51.71,140.97 53.95,140.97 54.57,140.35 61.01,140.35 62.95,138.41 64.1,138.41 64.79,137.73 68.27,137.73 70.29,135.7 71.39,135.7 71.7,135.39 71.7,132.35 70.99,131.64 70.99,131.06 70.59,130.66 70.59,128.21 70.23,127.84 70.23,123.39 71.13,122.49 71.13,118.74 75.21,114.65 88.86,114.65 90.45,116.24 90.45,116.98 v1(90.5,117.03)
  BOTTOM w0.102: JDOCK1.35 90.24,117.86 90.5,117.6 v1(90.5,117.03) ; Q337.4 52.9,155.23 R2163.2 52.64,154.15 51.95,154.84 v1(51.41,154.84)
DPD_DOCK_AUX_Q: length 17.6
  IN3 w0.127: v1(50.43,151.92) 50.43,154.52 v1(50.76,154.85)
  BOTTOM w0.102: v2(47.15,151.12) 47.57,151.54 Q336.3 ; 46.12,152.52 46.12,153.07 45.57,153.63 Q335.5 45.57,154.41 45.69,154.53 R2153.2 ; 46.12,152.52 Q335.2 ; 46.12,152.52 46.52,152.52 47.09,151.95 Q336.3 ; Q336.3 47.57,152.31 48,152.74 49.6,152.74 v1(50.43,151.92) ; v1(50.76,154.85) 50.76,154.9 51.24,155.39 52.34,155.39 52.83,155.88 Q337.5 Q337.2
DPD_DOCK_LANE_N0: length 1.9
  BOTTOM w0.102: R2165.1 83.37,113.32 83.29,113.23 83.29,112.25 83.49,112.04 C367.1
DPD_DOCK_LANE_N0_R: length 5
  BOTTOM w0.102: JDOCK1.11 84.24,117.9 83.3,116.95 83.3,114.64 R2165.2
DPD_DOCK_LANE_N1: length 1.7
  BOTTOM w0.102: R2167.1 85.63,113.32 85.34,113.03 85.34,112.28 85.58,112.04 C369.1
DPD_DOCK_LANE_N1_R: length 4.8
  BOTTOM w0.102: JDOCK1.17 85.74,117.65 85.51,117.42 85.29,117.2 85.29,114.67 R2167.2
DPD_DOCK_LANE_N2: length 1.9
  BOTTOM w0.102: C425.1 87.43,112.04 87.36,112.12 87.36,113.15 87.52,113.32 R2169.1
DPD_DOCK_LANE_N2_R: length 4.7
  BOTTOM w0.102: R2169.2 87.31,114.69 87.31,116.55 87.13,116.73 87.13,117.74 87.24,117.85 JDOCK1.23
DPD_DOCK_LANE_N3: length 1.8
  BOTTOM w0.102: R2171.1 89.52,113.32 89.39,113.2 89.39,112.24 89.59,112.04 C427.1
DPD_DOCK_LANE_N3_R: length 5
  BOTTOM w0.102: R2171.2 89.58,114.27 89.38,114.47 89.38,115.19 88.64,115.92 88.64,117.65 88.74,117.75 JDOCK1.29
DPD_DOCK_LANE_P0: length 1.8
  BOTTOM w0.102: R2164.1 82.93,113.32 83.02,113.23 83.02,112.25 82.82,112.04 C366.1
DPD_DOCK_LANE_P0_R: length 4.9
  BOTTOM w0.102: R2164.2 83.03,114.65 v1(83.03,115.51) 83.03,117.07 83.74,117.77 JDOCK1.9
DPD_DOCK_LANE_P1: length 1.8
  BOTTOM w0.102: R2166.1 84.84,113.32 85.08,113.09 85.08,112.27 84.85,112.04 C368.1
DPD_DOCK_LANE_P1_R: length 4.7
  BOTTOM w0.102: JDOCK1.15 85.24,117.53 85.02,117.31 v1(85.02,115.41) 85.02,114.61 R2166.2
DPD_DOCK_LANE_P2: length 1.9
  BOTTOM w0.102: C424.1 87.02,112.04 87.09,112.11 87.09,113.1 86.87,113.32 R2168.1
DPD_DOCK_LANE_P2_R: length 4.7
  BOTTOM w0.102: JDOCK1.21 86.74,117.82 86.87,117.69 86.87,116.62 87.04,116.44 v1(87.04,115.42) 87.04,114.6 R2168.2
DPD_DOCK_LANE_P3: length 1.8
  BOTTOM w0.102: C426.1 88.92,112.04 89.13,112.25 89.13,113.14 88.95,113.32 R2170.1
DPD_DOCK_LANE_P3_R: length 5
  BOTTOM w0.102: R2170.2 88.91,114.27 89.11,114.47 89.11,115.08 v1(88.87,115.32) 88.38,115.81 88.38,117.7 88.24,117.83 JDOCK1.27
DPD_GPU_HPD: length 99.5
  TOP w0.102: v1(93.13,144.37) 93.13,143.05 91.58,141.51 91.58,140.17 91.35,139.93 91.35,135.07 91.68,134.73 91.68,129.86 v2(90.1,128.28) 89.81,127.99 89.81,123.04 v1(89.97,122.89) ; v1(36.82,148.07) 37.08,147.8 38.42,147.8 38.71,147.51 U9.32
  IN2 w0.127: v1(36.82,148.07) 36.56,148.32 36.56,149.02 37.33,149.78 46.87,149.78 47.92,150.83 50.87,150.83 51.34,151.3 52.21,151.3 52.22,151.31 52.47,151.31 52.47,151.3 52.84,151.3 52.85,151.31 53.61,151.31 53.62,151.3 53.99,151.3 54,151.31 54.24,151.31 54.25,151.3 54.62,151.3 54.63,151.31 62.99,151.31 63.99,150.31 66.43,150.31 67.16,149.58 68.96,149.58 69.32,149.23 71.47,149.23 72.17,148.53 76.4,148.53 77.77,147.16 80.26,147.16 80.58,146.84 90.66,146.84 v1(93.13,144.37)
  BOTTOM w0.102: R757.1 90.55,113.8 90.55,115.98 91.24,116.66 91.24,117.45 91.24,117.45 JDOCK1.39 91.24,120.02 91.46,120.24 91.46,120.82 89.97,122.31 v1(89.97,122.89)
  BOTTOM w0.127: R757.1 C695.1
DPD_GPU_LANE_N0: length 78.8
  TOP w0.102: U9.39 38.78,144.71 38.72,144.65 38.47,144.65 38.3,144.49 37.96,144.49 v5(37.89,144.56)
  IN3 w0.127: v5(37.89,144.56) 37.89,144.56 37.93,144.51 38.42,144.51 38.7,144.23 38.7,142.96 39.56,142.1 39.56,140.18 40.33,139.41 41.43,139.41 43.11,137.72 43.76,137.72 46.53,134.95 56.54,134.95 57.1,135.51 60.95,135.51 62.8,133.66 66.03,133.66 66.29,133.39 67.35,133.39 67.74,132.99 67.74,130.65 67.87,130.52 67.87,127.62 68.21,127.28 68.21,124.24 66.01,122.05 66.01,117.65 69.18,114.49 69.18,113.44 73.11,109.5 80.59,109.5 81.14,110.05 82.66,110.05 83.01,109.7 83.01,109.61 83.26,109.36 v1(83.26,109.31)
  BOTTOM w0.102: v1(83.26,109.31) 83.16,109.41 83.16,109.98 83.42,110.25 83.42,110.85 C367.2
DPD_GPU_LANE_N1: length 80.8
  TOP w0.102: U9.36 38.75,145.91 38.7,145.86 38.45,145.86 v3(38.19,146.12)
  IN3 w0.127: v1(87.4,108.59) 87.31,108.67 87.31,109.13 86.95,109.49 86.26,109.49 85.96,109.79 85.96,111.76 83.5,114.22 75.42,114.22 69.32,120.33 69.32,130.33 68.55,131.09 68.55,133.35 67.3,134.61 66.31,134.61 66.18,134.48 64.11,134.48 63.75,134.84 63.75,135.22 63.27,135.7 62.55,135.7 61.73,136.51 56.78,136.51 56.16,135.89 53.68,135.89 53.22,136.35 53.22,136.72 52.5,137.44 47.31,137.44 44.99,139.75 43.75,139.75 42.56,140.95 41.34,140.95 41.12,141.16 41.12,142.32 39.51,143.93 39.51,145.28 38.82,145.96 38.35,145.96 v3(38.19,146.12)
  BOTTOM w0.102: v1(87.4,108.59) 87.32,108.66 87.32,109.14 86.96,109.5 86.56,109.5 85.44,110.61 85.44,110.84 C369.2
DPD_GPU_LANE_N2: length 77
  TOP w0.102: U9.33 38.77,147.11 38.7,147.04 37.87,147.04 37.72,147.19 v3(37.72,147.19)
  IN3 w0.127: v3(37.72,147.19) 37.79,147.12 38.82,147.12 40.35,145.59 40.35,144.49 42.84,142 43.27,142 44.65,140.61 45.91,140.61 48.12,138.41 53.26,138.41 53.97,137.69 58.27,137.69 58.62,137.34 64.69,137.34 66.61,135.42 66.64,135.42 67.64,135.42 69.39,133.67 69.39,133.57 69.42,133.54 69.42,132.21 70.72,130.9 70.72,120.12 75.79,115.05 83.92,115.05 87.63,111.34 87.63,110.11 v1(87.76,109.98)
  BOTTOM w0.102: C425.2 87.45,110.82 87.45,110.6 87.63,110.42 87.63,110.11 v1(87.76,109.98)
DPD_GPU_LANE_N3: length 82.1
  TOP w0.102: v3(37.65,149.09) 37.88,148.86 38.16,148.86 38.7,148.31 U9.30
  IN3 w0.127: v3(37.65,149.09) 37.85,148.9 38.45,148.9 39.1,148.25 39.1,148.07 41.18,145.99 41.18,144.86 41.95,144.09 46.89,144.09 48.6,142.38 48.6,140.72 49.87,139.45 53.96,139.45 54.86,138.54 59.09,138.54 59.49,138.15 65.11,138.15 66.6,136.67 67.59,136.67 70.77,133.49 70.77,132.57 70.78,132.56 70.78,132.17 71.54,131.41 71.54,120.48 75.84,116.18 84.71,116.18 90.33,110.55 90.33,109.93 v1(90.39,109.87)
  BOTTOM w0.102: C427.2 89.52,110.85 89.52,110.69 89.63,110.58 90,110.58 90.27,110.31 90.27,109.99 v1(90.39,109.87)
DPD_GPU_LANE_P0: length 78.9
  TOP w0.102: U9.40 38.76,144.31 38.69,144.39 38.58,144.39 38.41,144.22 38.19,144.22 37.89,143.93 v3(37.89,143.92)
  IN3 w0.127: v1(82.62,109.31) 82.7,109.39 82.7,109.58 82.54,109.74 81.27,109.74 80.72,109.2 72.99,109.2 68.87,113.31 68.87,114.36 65.71,117.53 65.71,122.17 67.91,124.37 67.91,127.15 67.56,127.5 67.56,130.39 67.44,130.52 67.44,132.87 67.22,133.08 66.17,133.08 65.9,133.35 62.67,133.35 60.82,135.2 57.22,135.2 56.67,134.65 46.4,134.65 43.64,137.41 42.99,137.41 41.3,139.1 40.21,139.1 39.25,140.06 39.25,141.97 38.39,142.84 38.39,144.11 38.29,144.21 38.18,144.21 v3(37.89,143.92)
  BOTTOM w0.102: C366.2 83.07,111.1 83.16,111.01 83.16,110.36 82.89,110.09 82.89,109.54 82.66,109.31 v1(82.62,109.31)
DPD_GPU_LANE_P1: length 80.7
  TOP w0.102: v1(38.19,145.49) 38.25,145.49 38.36,145.59 38.65,145.59 38.73,145.51 U9.37
  IN3 w0.127: v1(38.19,145.49) 38.36,145.66 38.7,145.66 39.2,145.15 39.2,143.8 40.82,142.19 40.82,141.03 41.21,140.64 42.43,140.64 43.62,139.45 44.87,139.45 47.18,137.14 52.37,137.14 52.92,136.59 52.92,136.22 53.55,135.59 56.29,135.59 56.91,136.21 61.61,136.21 62.42,135.4 63.14,135.4 63.44,135.1 63.44,134.72 63.98,134.18 66.3,134.18 66.43,134.3 67.17,134.3 68.25,133.22 68.25,130.96 69.01,130.2 69.01,120.21 75.3,113.92 83.37,113.92 85.66,111.63 85.66,109.66 86.14,109.18 86.83,109.18 87.01,109 87.01,108.83 v3(86.76,108.59)
  BOTTOM w0.102: C368.2 85.09,111.1 85.18,111.01 85.18,110.5 86.45,109.23 86.85,109.23 87.06,109.03 87.06,108.85 86.79,108.59 v3(86.76,108.59)
DPD_GPU_LANE_P2: length 77
  TOP w0.102: U9.34 38.74,146.71 38.68,146.77 37.93,146.77 37.72,146.56 v1(37.72,146.55)
  IN3 w0.127: v1(37.72,146.55) 37.98,146.81 38.7,146.81 40.04,145.47 40.04,144.36 42.71,141.69 43.14,141.69 44.53,140.31 45.78,140.31 47.99,138.1 53.14,138.1 53.85,137.39 58.14,137.39 58.5,137.03 64.57,137.03 66.48,135.12 66.52,135.12 67.51,135.12 69.09,133.54 69.09,133.44 69.11,133.42 69.11,132.08 70.42,130.77 70.42,119.99 75.67,114.75 83.79,114.75 87.32,111.21 87.32,110.17 v3(87.13,109.98)
  BOTTOM w0.102: C424.2 87.1,111.1 87.18,111.01 87.18,110.49 87.36,110.31 87.36,110.15 87.19,109.98 v3(87.13,109.98)
DPD_GPU_LANE_P3: length 82.1
  TOP w0.102: v1(37.65,148.46) 37.79,148.59 38.05,148.59 38.72,147.91 U9.31
  IN3 w0.127: v1(37.65,148.46) 37.7,148.46 37.83,148.59 38.33,148.59 38.8,148.12 38.8,147.94 40.88,145.86 40.88,144.73 41.82,143.79 46.76,143.79 48.3,142.25 48.3,140.59 49.74,139.14 53.83,139.14 54.74,138.24 58.97,138.24 59.36,137.85 64.97,137.85 66.46,136.36 67.47,136.36 70.46,133.36 70.46,132.44 70.47,132.44 70.47,132.04 71.23,131.28 71.23,120.36 75.72,115.88 84.58,115.88 90.03,110.43 90.03,110.14 v3(89.76,109.87)
  BOTTOM w0.102: v3(89.76,109.87) 89.78,109.87 90,110.1 90,110.2 89.89,110.31 89.52,110.31 89.25,110.58 89.25,110.99 89.14,111.1 C426.2
DSCHRG_MOSFET_GC: length 93.5
  TOP w0.254: v1(172.19,73.22) 172.19,73.28 172.58,73.68 172.63,73.68 172.64,73.69 173.06,73.69 173.06,73.68 PU1001.29
  TOP w0.381: v1(160.86,14.83) 160.86,14.68 161.33,14.21 166.44,14.21 168.46,16.23 168.46,18.48 171.51,21.53 178.23,21.53 178.48,21.78 v2(179.51,21.78) 179.77,21.78 PR1004.2
  IN1 w0.381: v1(160.86,14.83) 160.86,15.11 161.36,15.62 161.36,22.63 160.45,23.55 160.45,26.63 161.44,27.62 161.44,42.23 163.18,43.97 163.18,45.03 163.78,45.63 164.22,45.63 165.3,46.71 165.3,48.13 167.3,50.13 170.41,50.13 172.52,52.23 172.52,62.47 171.38,63.6 171.38,72.42 v1(172.19,73.22)
DSWODVREN: length 5.2
  TOP w0.102: UH4.A18 17.48,113.26 15.45,113.26 15.27,113.07 14.82,113.07 14.29,112.55 RH127.1 RH129.2
DYN_TUR_CURRNT_SET#: length 185.9
  TOP w0.102: v1(173.94,136.45) 173.33,136.45 172.59,135.71 172.59,117.09 179.23,110.45 179.23,107.2 177.89,105.86 177.89,102.61 177.02,101.75 177.02,96.98 178.87,95.14 178.87,94.04 177.77,92.95 177.77,90.49 v2(178.42,89.84) 178.99,89.27 178.99,88.29 180.97,86.31 181.52,86.31 v1(181.65,86.18) ; U54.A35 172.93,144.38 173.49,143.82 173.49,142.23 v1(174.05,141.67) 174.43,141.29 R1178.1
  IN1 w0.109: v1(174.05,141.67) 174.53,141.19 174.53,140.22 174.26,139.94 173.9,139.94 173.76,139.8 173.76,136.68 173.94,136.5 v1(173.94,136.45) ; v1(243.54,22.28) 240.47,25.35 213.31,25.35 203.92,34.74 202.67,34.74 201.45,35.95 201.45,45.01 198.96,47.5 196.91,47.5 196.47,47.94 187.67,47.94 181.41,54.2 181.41,59.6 183.64,61.84 183.64,65.15 184.89,66.4 184.89,76.28 181.75,79.41 181.75,86.08 v1(181.65,86.18)
  BOTTOM w0.102: v1(243.54,22.28) PQ909.2
DYN_TURB_GPU_PWR_ALRT#: length 77.7
  TOP w0.102: v1(174.29,149.48) 173.69,148.88 U54.A44 ; R14.2 PR30.2 172.48,173.75 v1(172.48,172.36)
  IN2 w0.127: v1(203.27,160.07) 202.79,160.55 201.01,160.55 196.17,165.39 175.3,165.39 174.83,165.86 172.64,165.86 v1(171.96,166.55)
  IN3 w0.127: v1(174.29,149.48) 174.29,151.74 175.32,152.77 175.32,158.43 176.36,159.47 176.36,162.5 176.05,162.81 175.33,162.81 171.96,166.19 v1(171.96,166.55) 171.96,167.45 172.32,167.82 172.32,172.21 v1(172.48,172.36)
  BOTTOM w0.102: v1(203.27,160.07) 203.6,159.74 203.6,157.91 201.66,155.97 200.85,155.97 198,153.12 v2(198,152.6) D19.1
DYN_TURB_SYS_PWR_ALRT#: length 383.2
  IN1 w0.127: v1(239.42,78.37) 238.82,77.78 238.82,75.41 238.29,74.88 238.29,68.03 239.76,66.56 239.76,65.46 240.22,65 240.22,63.72 239.38,62.88 239.38,60.96 v1(239.18,60.76)
  IN2 w0.127: v1(166.66,17.17) 166.61,17.22 166.55,17.22 166.22,17.55 165.19,17.55 164.29,16.65 162.49,16.65 161.99,17.16 159.85,17.16 159.76,17.07 158.27,17.07 154.51,13.3 131.62,13.3 130.72,12.41 127.93,12.41 127.63,12.7 126.66,13.68 121.5,13.68 121.12,14.06 119.28,14.06 117.92,15.42 117.46,15.42 117.23,15.65 114.13,15.65 111.52,13.04 110.46,13.04 109.53,12.12 107.45,12.12 103.92,8.59 35.77,8.59 34.52,9.84 31.91,9.84 30.62,11.14 30.62,35.94 31.05,36.37 31.05,44.84 27.67,48.21 27.67,57.22 22.91,61.99 12.89,61.99 6.26,68.62 6.26,77.15 5.1,78.31 5.1,85.32 4.32,86.11 4.32,89.43 4.98,90.09 10.72,90.09 v1(10.77,90.04)
  IN3 w0.127: v1(239.18,60.76) 239.18,60.53 238.25,59.6 236.1,59.6 235.17,60.53 232.56,60.53 231.91,61.18 231.91,61.19 231.41,61.7 223.26,61.7 221.6,63.36 208.11,63.36 v1(204.72,59.97) 201.97,57.21 194.87,57.21 193.8,56.15 189.51,56.15 189.13,55.77 189.13,54.89 188.09,53.85 186.61,53.85 185.56,52.79 180.83,52.79 177.89,49.86 173.92,49.86 164.35,40.29 164.35,21.43 166.28,19.5 166.28,17.56 166.66,17.18 v1(166.66,17.17)
  BOTTOM w0.102: v1(239.18,60.76) 239.18,61.23 v2(239.33,61.38)
  BOTTOM w0.127: U46.A46 239.58,78.26 239.42,78.42 v1(239.42,78.37)
  BOTTOM w0.254: R35.2 12.1,91.38 v1(10.77,90.04)
EC_32KHZ_ECE5048: length 158.3
  IN3 w0.127: v1(227.42,82.22) 228.2,82.22 232.14,78.28 v1(232.14,77.01)
  IN4 w0.109: v1(163.75,160.47) 163.75,161.46 165.48,163.18 170,163.18 171.21,161.98 171.21,161.48 172.21,160.48 175.33,160.48 176.31,161.46 176.31,162.32 177.11,163.11 177.11,163.63 178.56,165.09 195.73,165.09 198.05,162.76 200,162.76 200.71,163.48 205.45,163.48 206.4,162.52 206.4,159.91 207.17,159.14 208.56,159.14 210.19,157.51 212.32,157.51 212.63,157.2 212.63,130.14 212.01,129.52 212.01,120.07 212.44,119.64 212.44,114.44 211.96,113.96 211.96,107.92 215.14,104.74 v1(215.28,104.74)
  BOTTOM w0.102: v1(227.42,82.22) 227.42,89.36 v2(226.74,90.04) 218.07,98.7 218.07,100.97 215.28,103.76 v1(215.28,104.74) ; U46.B35 232.83,77.14 232.7,77.27 232.4,77.27 v1(232.14,77.01) ; R867.1 165.96,155.53 166.19,155.76 166.19,156.14 166.5,156.44 166.5,156.87 166.35,157.01 166.35,158.96 165.38,159.93 164.3,159.93 163.75,160.48 v1(163.75,160.47)
EDID_SELECT#: length 251.4
  IN1 w0.109: v1(226.36,82.9) 226.99,82.9 227.05,82.84 230.58,82.84 232.62,80.8 237.8,80.8 238.03,80.57 240.04,80.57 241.95,78.66 241.95,77.98 241.13,77.16 241.13,75.94 241.39,75.68 241.39,71.86 240.93,71.4 240.69,71.4 v1(240.66,71.37)
  IN2 w0.127: v1(226.36,82.9) 226.36,83.46 225.98,83.85 225.6,83.85 225.25,84.2 225.25,84.97 224.12,86.09 220.97,86.09 219.98,87.08 219.17,87.08 216.97,89.28 213.31,89.28 213.03,89.56 209.93,89.56 205.62,93.87 205.62,94.69 204.68,95.63 200.24,95.63 197.23,98.64 197.23,101.63 195.4,103.47 195.4,105.43 195.66,105.69 195.66,106.5 194.03,108.13 194.03,110.49 191.34,113.18 191.34,137.43 186.99,141.77 185.57,141.77 184.59,140.79 v1(184.58,140.79)
  IN4 w0.109: v1(65.14,157.53) 66.1,157.53 66.6,157.04 69.7,157.04 71.95,154.78 73.54,154.78 77.7,150.61 80.75,150.61 81.99,149.37 85.84,149.37 86.39,149.91 96.05,149.91 97.9,151.77 104.86,151.77 105.52,152.43 117.1,152.43 117.95,151.58 127.19,151.58 128.59,152.97 142.72,152.97 143.33,153.58 146.16,153.58 146.87,152.87 149.33,152.87 153.29,148.9 153.29,147.47 155.95,144.82 156.85,144.82 157.81,143.86 157.81,143.12 159.08,141.85 161.06,141.85 161.54,141.36 162.42,141.36 163.5,140.28 163.5,139.68 165.01,138.16 178,138.16 178.18,138.34 181.6,138.34 183.3,140.04 183.83,140.04 v1(184.58,140.79)
  BOTTOM w0.102: U19.1 64.43,155.79 65.14,156.49 v1(65.14,157.53) 64.48,157.53 v2(64.35,157.66) ; U46.B61 241.26,71.7 240.93,71.37 v1(240.66,71.37)
EDP_COMP: length 11.5
  TOP w0.089: 82.4,39.69 82.4,40.96 82.89,41.45 JCPU1.A18
  TOP w0.102: RC1.1 82.4,36.61 82.4,39.69
  TOP w0.305: JCPU1.A17 83.9,40.81 82.9,39.82 v2(82.9,37.05) RC1.1
EDP_DET#: length 302
  TOP w0.102: v1(66.19,158.47) 66.72,157.94 66.95,157.94 67.24,157.65 JEDP1.1 ; U627.1 44.65,167.71 44.77,167.6 v1(44.77,166.73)
  IN1 w0.109: v1(66.19,158.47) 65.87,158.47 64.44,159.9 61.85,159.9 61.4,159.46 57.83,159.46 56.72,160.57 50.48,160.57 44.77,166.29 v1(44.77,166.73)
  IN2 w0.127: v1(184.63,142.28) 184.83,142.48 187.29,142.48 192.14,137.64 192.14,113.94 195.39,110.69 195.39,107.85 196.4,106.83 196.4,105.3 196.09,104.99 196.09,103.75 197.94,101.89 197.94,100.89 200.3,98.53 204.75,98.53 205.38,97.9 205.38,96.18 206.49,95.07 206.49,93.97 209.75,90.72 216.51,90.72 219.45,87.77 223.53,87.77 226.81,84.48 v1(226.81,82.46)
  IN3 w0.127: v1(226.81,82.46) 226.81,82.46 226.83,82.46 228.33,83.96 230.72,83.96 231.41,83.27 236.26,83.27 236.57,82.96 236.57,82.45 236.38,82.26 236.38,80.95 236.99,80.34 243.35,80.34 243.49,80.2 243.98,80.2 245.45,78.73 245.45,72.07 244.92,71.54 244.92,69.36 244,68.44 243.77,68.44 242.44,67.11 242.19,67.11 241.74,66.66 239.5,66.66 238.83,67.32 235.89,67.32 235.47,66.9 234.72,66.9 234.08,66.26 v1(234.08,65.96)
  IN4 w0.109: v1(184.63,142.28) 184.08,141.73 183.75,141.73 182.01,139.99 178.94,139.99 178.88,139.93 177.74,139.93 176.94,140.73 175.56,140.73 174.7,139.87 174,139.87 172.79,138.66 165.59,138.66 164.11,140.15 164.11,140.48 162.71,141.87 161.88,141.87 160.62,143.13 159.91,143.13 157.76,145.28 156.14,145.28 153.85,147.56 153.85,149.19 147.03,156.01 142.5,156.01 139.93,153.43 116.69,153.43 116.17,152.91 105.16,152.91 104.61,152.36 97.65,152.36 95.65,150.37 86.2,150.37 85.62,149.79 82.27,149.79 80.99,151.07 77.84,151.07 73.71,155.2 72.33,155.2 69.69,157.84 67.35,157.84 67.04,158.14 66.52,158.14 v1(66.19,158.47)
  BOTTOM w0.102: U46.A14 v1(234.08,65.96) 234.08,65.65 v2(233.4,64.97) 233.27,64.85 R779.2
