# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_CRT_DDC_CLK: length 175.8
  TOP w0.102: v1(202.47,124.65) 202.98,124.65 203.63,124 204.61,124 205.09,123.52 JMXM1.188
  IN4 w0.109: v1(69.15,154.89) 69.15,154.85 69.77,154.23 73.45,154.23 77.53,150.15 80.58,150.15 81.81,148.92 86.03,148.92 86.56,149.45 99.99,149.45 101.71,151.17 105.23,151.17 105.99,151.93 116.91,151.93 117.75,151.09 127.7,151.09 128.57,151.97 135.37,151.97 135.67,151.66 142.67,151.66 142.77,151.77 148.13,151.77 150.93,148.97 150.93,147.96 155.35,143.54 156.9,143.54 157.12,143.32 157.12,142.78 157.35,142.56 158.04,141.87 158.72,141.19 160.24,141.19 161,140.43 161.76,140.43 162.1,140.09 162.1,139.26 163.02,138.34 164.02,138.34 164.76,137.61 168.93,137.61 169.62,136.92 169.62,135.77 172.4,132.99 174.14,132.99 175.72,131.42 182.19,131.42 183.62,132.85 196.76,132.85 197.46,132.14 200.89,132.14 201.52,131.51 201.52,128.21 201.65,128.08 201.65,125.98 202.47,125.16 v1(202.47,124.65)
  BOTTOM w0.102: v1(202.47,124.65) 202.05,125.07 196.15,125.07 194.28,126.94 194.28,127.73 R5.2 ; U19.5 64.53,154.19 64.76,153.96 67.51,153.96 67.64,154.09 v2(67.82,154.09) 68.35,154.09 v1(69.15,154.89)
MXM_CRT_DDC_DAT: length 175.5
  TOP w0.102: v1(202.93,125.13) 203.8,124.27 204.86,124.27 205.11,124.02 JMXM1.186
  IN4 w0.109: v1(202.93,125.13) 201.9,126.16 201.9,128.21 201.78,128.33 201.78,131.64 201.01,132.4 197.54,132.4 196.85,133.08 183.5,133.08 182.09,131.67 175.8,131.67 174.24,133.23 172.49,133.23 169.9,135.83 169.9,137.16 169.18,137.88 164.86,137.88 164.15,138.6 163.12,138.6 162.36,139.36 162.36,140.2 161.86,140.69 161.1,140.69 160.35,141.44 158.82,141.44 157.38,142.89 157.38,143.42 157,143.8 155.45,143.8 151.18,148.07 151.18,149.08 148.24,152.02 142.67,152.02 142.6,151.96 135.84,151.96 135.6,152.2 128.38,152.2 127.53,151.35 117.85,151.35 117.02,152.18 105.74,152.18 105.05,151.5 101.62,151.5 99.81,149.68 86.46,149.68 85.93,149.16 81.91,149.16 80.67,150.39 77.63,150.39 73.53,154.48 70.14,154.48 v1(69.78,154.84)
  BOTTOM w0.102: v1(202.93,125.13) 202.74,125.33 196.22,125.33 194.54,127.01 194.54,127.73 R3.2 ; v1(69.78,154.84) 69.78,154.51 v2(69.39,154.12) 69.01,153.73 64.66,153.73 64.61,153.79 U19.6
MXM_CRT_GRN: length 186.5
  TOP w0.102: v1(208.72,122.62) 208.72,122.23 207.52,121.02 JMXM1.198
  IN3 w0.127: v1(200.58,143.73) 200.4,143.55 197.5,143.55 197.17,143.22 196.19,143.22 189.42,136.45 187.84,136.45 187.63,136.67 184.86,136.67 184.08,135.89 181.52,135.89 179.61,133.99 164.41,133.99 163.46,134.94 162.36,134.94 160.35,136.94 160.35,137.12 158.85,138.62 139.48,138.62 135.29,142.81 133.6,142.81 131.91,144.5 119.43,144.5 117.94,143.02 111.67,143.02 110.98,143.7 95.67,143.7 94.94,142.98 92.22,142.98 90.91,141.67 86.53,141.67 85.21,142.99 84.16,142.99 79.96,147.19 77.29,147.19 74.15,150.34 73.09,150.34 71.44,151.99 70.66,151.99 70.29,152.36 70.29,152.54 v1(70.27,152.57)
  IN4 w0.109: v1(208.72,122.62) 208.72,127.55 206.16,130.11 206.16,138.68 205.71,139.13 205.71,142.69 204.95,143.45 204.1,143.45 202.26,145.29 200.2,145.29 199.44,144.53 199.44,143.75 199.64,143.55 200.4,143.55 v1(200.58,143.73)
  BOTTOM w0.102: v1(70.27,152.57) 70.12,152.72 v2(69.2,152.72) 66.23,152.72 65.96,152.99 U19.8
MXM_CRT_HSYNC: length 179
  TOP w0.102: v1(207.11,122.9) 206.73,122.52 JMXM1.192
  IN3 w0.127: v1(65.94,154.62) 65.94,154.46 66.48,153.91 67.62,153.91 67.79,154.08 72.1,154.08 73.24,152.93 74.15,152.93 78.18,148.91 80.59,148.91 82.52,146.98 105.81,146.98 106.46,146.33 111.23,146.33 111.83,145.72 116.24,145.72 119.49,148.97 131.77,148.97 133.54,147.19 140.47,147.19 145.15,142.52 155.15,142.52 155.75,141.92 157.52,141.92 158.33,141.11 159.59,141.11 161.21,139.48 161.21,138.82 162.14,137.9 173.14,137.9 174.03,138.79 183.83,138.79 185.3,140.26 185.3,140.74 186.33,141.77 191.63,141.77 196.09,146.23 199.73,146.23 201.57,144.39 v1(201.57,144.11)
  IN4 w0.109: v1(207.11,122.9) 207.47,123.25 207.47,125.06 206.79,125.73 206.79,127.64 204.89,129.54 204.89,135.2 202.16,137.93 202.16,143.52 v1(201.57,144.11)
  BOTTOM w0.102: v2(66.65,154.94) 66.33,154.62 v1(65.94,154.62) 65.94,154.86 65.66,155.14 64.84,155.14 64.68,154.99 U19.3
MXM_CRT_RED: length 181.1
  TOP w0.102: v1(208,122.62) 208,122.17 207.34,121.52 JMXM1.196
  IN3 w0.127: v1(70.93,152.63) 72.08,152.63 73.67,151.04 74.36,151.04 77.56,147.84 80.21,147.84 84.25,143.8 85.3,143.8 86.79,142.3 90.65,142.3 91.96,143.61 94.59,143.61 95.31,144.34 101.7,144.34 102.5,145.14 110.59,145.14 112.06,143.66 116.37,143.66 117.84,145.14 133.96,145.14 139.84,139.26 159.13,139.26 160.98,137.4 160.98,137.22 162.63,135.57 163.72,135.57 164.68,134.62 179.35,134.62 181.62,136.89 184.1,136.89 185.37,138.16 190.19,138.16 195.92,143.89 196.78,143.89 197.15,144.26 199.91,144.26 v1(200,144.17)
  IN4 w0.109: v1(208,122.62) 208.08,122.7 208.08,127.3 205.52,129.86 205.52,138.24 205,138.76 205,140.84 203.08,142.76 203.08,143.52 202,144.6 200.43,144.6 v1(200,144.17)
  BOTTOM w0.102: v1(70.93,152.63) 70.93,152.77 70.31,153.39 v2(66.36,153.39) U19.7
MXM_CRT_VSYNC: length 177.3
  TOP w0.102: JMXM1.190 206.56,123.02 207.02,123.48 v1(207.02,123.53)
  IN3 w0.127: v1(201.55,143.47) 201.53,143.47 200.71,144.3 200.71,144.45 200.1,145.06 196.16,145.06 191.15,140.04 185.69,140.04 183.86,138.21 174.31,138.21 173.61,137.52 161.96,137.52 160.83,138.65 160.83,139.31 159.41,140.73 155.68,140.73 155.4,140.45 142.01,140.45 137.76,144.7 135.49,144.7 132.92,147.28 119.57,147.28 118.24,145.96 117.56,145.96 116.83,145.23 111.54,145.23 111,145.77 102.13,145.77 101.62,145.26 92.21,145.26 89.89,142.94 87.06,142.94 83.4,146.6 82.36,146.6 80.47,148.49 78.04,148.49 73.98,152.55 73.09,152.55 71.94,153.7 67.94,153.7 67.78,153.53 65.63,153.53 65.3,153.86 v3(65.3,154.62)
  IN4 w0.109: v1(207.02,123.53) 207.02,124 206.09,124.93 206.09,126.18 203.74,128.52 203.74,130.54 201.55,132.74 v1(201.55,143.47)
  BOTTOM w0.102: U19.4 65.27,154.59 v3(65.3,154.62)
MXM_CURI2C_CLK: length 74.1
  TOP w0.102: U60.5 155.25,175.47 155.03,175.25 154.81,175.25 v3(154.6,175.45)
  IN3 w0.127: v3(154.6,175.45) 154.41,175.26 154.14,175.26 153.78,174.9 153.78,174.42 154.34,173.86 164.63,173.86 166.6,175.83 173.62,175.83 175.64,173.81 175.64,170.11 177.02,168.73 178.81,168.73 182.43,165.11 195.3,165.11 205.19,155.22 205.19,151.74 206.37,150.56 207.39,150.56 v1(207.55,150.4)
  BOTTOM w0.102: R2182.2 206.23,150.46 206.37,150.6 207.34,150.6 v1(207.55,150.4)
MXM_CURI2C_DATA: length 73.3
  TOP w0.102: v3(154.6,174.82) 154.81,175.02 155.06,175.02 155.26,174.82 U60.6
  IN3 w0.127: v1(207.55,151.04) 207.32,150.81 206.48,150.81 205.45,151.84 205.45,155.32 195.4,165.37 182.54,165.37 178.92,168.99 177.13,168.99 175.89,170.22 175.89,173.91 173.72,176.09 166.49,176.09 164.52,174.12 154.44,174.12 154.04,174.52 154.04,174.8 154.24,175.01 154.42,175.01 v3(154.6,174.82)
  BOTTOM w0.102: R2183.2 206.23,150.97 206.36,150.83 207.34,150.83 v1(207.55,151.04)
MXM_DP_HDMI_HPD: length 80.1
  TOP w0.102: v1(188.63,81.95) 188.89,82.21 v2(190.54,82.21) 191.3,82.21 191.77,81.74 195.27,81.74 198.73,78.28 198.73,70.51 199.72,69.52 202.81,69.52 207.2,65.13 228.65,65.13 229.65,64.12 231.29,64.12 231.8,63.61 235.39,63.61 235.79,64.02 238.58,64.02 238.87,64.31 v1(238.87,64.58) 238.56,64.9 238.56,66.21 239.3,66.95 239.3,68.61 238.9,69.01 v1(238.8,69.01) ; D8.1 D18.1 D7.1 188.42,86.9 v1(187.78,86.26)
  IN2 w0.127: v1(187.78,86.26) 187.98,86.26 188.63,85.61 v1(188.63,81.95)
  BOTTOM w0.102: U46.B4 239.33,68.48 v1(238.8,69.01) ; R17.2 238.86,64.57 v1(238.87,64.58)
MXM_DPB_AUX: length 146.2
  TOP w0.102: v1(203.4,96.53) 203.41,96.52 203.41,96.02 203.91,95.52 JMXM1.300 ; v3(187.03,108.09) 187.06,108.09 187.2,108.23 187.2,110.38 185.91,111.66 185.91,116.76 183.64,119.03 183.64,120.85 182.9,121.59 182.45,121.59 181.37,122.67 181.37,123.26 181.13,123.5 181.13,127.24 181.37,127.48 181.37,135.35 182.09,136.08 182.09,137.22 181.91,137.4 v1(181.91,137.41) ; C387.2 115.58,152.94 115.58,152.72 115.47,152.6 114.81,152.6 114.26,152.05 U20.12 114.1,151.39 114.1,150.18 114.95,149.33 114.95,149.02 v1(114.9,148.97)
  IN1 w0.117: v1(203.4,96.53) 203.4,96.95 203.31,97.04 202.4,97.04 201.72,97.72 199.04,97.72 198.36,97.04 196.78,97.04 196.1,97.72 193.11,97.72 192.34,98.49 192.34,107.51 192.73,107.89 193.01,107.89 v1(193.15,108.04) ; v1(181.91,137.41) 181.94,137.41 181.98,137.38 181.98,137.16 181.68,136.86 181.5,136.86 179.23,134.59 168.36,134.59 167.97,134.98 164.85,134.98 163.35,136.47 161.67,136.47 158.86,139.29 155.62,139.29 155.61,139.28 148.7,139.28 139.31,148.67 129.52,148.67 128.15,150.04 118.21,150.04 117.6,149.43 115.4,149.43 114.95,148.97 v1(114.9,148.97)
  BOTTOM w0.102: v3(187.03,108.09) 187.22,108.09 187.56,108.43 188.3,108.43 188.3,108.42 189.72,108.42 189.74,108.41 190.4,108.41 190.93,107.87 192.99,107.87 v1(193.15,108.04)
MXM_DPB_AUX#: length 146.1
  TOP w0.102: C388.2 116.08,153.17 115.86,152.95 115.86,152.64 116.21,152.29 U20.9 116.21,150.81 116.43,150.58 116.43,150.18 116.15,149.9 115.05,149.9 114.97,149.82 114.97,149.68 115.19,149.46 115.19,149.35 v1(115.57,148.97) ; v1(187.62,107.85) 187.46,108 187.46,110.49 186.18,111.77 186.18,116.87 183.91,119.14 183.91,120.96 183.01,121.86 182.56,121.86 181.63,122.78 181.63,123.37 181.39,123.61 181.39,127.13 181.63,127.37 181.63,135.24 182.36,135.97 182.36,137.23 v1(182.54,137.41) ; JMXM1.298 204.88,96.02 204.8,95.94 204.8,95.83 204.76,95.79 204.02,95.79 203.68,96.13 203.68,96.19 204.02,96.53 v1(204.04,96.53)
  IN1 w0.117: v1(115.57,148.97) 115.57,149.04 115.66,149.13 117.71,149.13 118.33,149.75 128.04,149.75 129.4,148.39 139.19,148.39 148.58,139 155.73,139 155.73,139 158.74,139 161.55,136.19 163.24,136.19 164.74,134.69 167.86,134.69 168.24,134.3 179.35,134.3 181.62,136.58 182.13,136.58 182.39,136.84 182.39,137.26 v1(182.54,137.41) ; v3(193.15,107.4) 192.95,107.61 192.84,107.61 192.62,107.39 192.62,98.61 193.23,98.01 196.21,98.01 196.89,97.33 198.24,97.33 198.92,98.01 201.84,98.01 202.52,97.33 203.43,97.33 203.69,97.07 203.69,96.88 v1(204.04,96.53)
  BOTTOM w0.102: v3(193.15,107.4) 193.08,107.48 193.06,107.48 192.94,107.61 190.82,107.61 190.48,107.95 190.29,108.14 189.63,108.14 189.61,108.15 188.03,108.15 188.03,108.17 187.68,108.17 187.62,108.11 v1(187.62,107.85)
MXM_DPB_HPD: length 178.6
  TOP w0.102: v1(196.48,94.68) 194.85,94.68 192.53,92.35 192.53,91.18 D18.2 ; v1(188.06,116.14) 188.06,113.42 191.1,110.39 191.1,108.67 v1(190.05,107.63)
  IN1 w0.109: v1(198.82,96.09) 197.88,96.09 196.48,94.69 v1(196.48,94.68)
  IN2 w0.127: v1(183.09,120.76) 183.09,120.63 183.82,119.9 184.73,119.9 186.12,118.51 186.13,118.51 188.06,116.58 v1(188.06,116.14) ; v1(196.48,94.68) 196.29,94.68 192.87,98.1 192.87,99 191.86,100.02 191.86,104.22 190.63,105.45 190.63,106.86 190.05,107.43 v1(190.05,107.63)
  IN3 w0.127: v1(198.82,96.09) 199.85,96.09 200.46,96.7 200.46,97.36 200.52,97.42 200.52,98.84 201.67,99.99 201.67,100.98 201.49,101.16 201.49,101.74 201.4,101.84 201.4,103.46 202.35,104.41 203.16,104.41 203.82,105.07 204.97,105.07 205.21,104.84 207.75,104.84 208.25,104.33 v1(208.43,104.33) ; v1(183.09,120.76) 183.06,120.8 183.06,121.4 182.64,121.82 163.46,121.82 157.05,115.41 141.31,115.41 140.69,116.03 140.28,116.03 139.11,117.2 136.6,117.2 v1(136.26,117.54)
  IN4 w0.109: v1(91.49,128.11) 91.58,128.11 92.14,128.66 95.24,128.66 97.66,126.24 101.9,126.24 103.52,124.63 106.58,124.63 108.74,126.78 119.91,126.78 122.43,129.3 127.35,129.3 131.16,125.49 131.16,123.2 136.26,118.11 v1(136.26,117.54)
  BOTTOM w0.102: JDOCK1.40 91.24,127.86 v1(91.49,128.11) 91.54,128.16 C696.1 R2160.1 ; U14.2 210.65,105.73 v2(209.48,104.56) 209.26,104.33 v1(208.43,104.33)
MXM_DPB_HPD_GATE: length 25.3
  TOP w0.102: JMXM1.302 204.83,95.02 204.51,94.69 v1(204.51,94.01)
  IN3 w0.127: v1(209.26,105.52) 209.26,103.8 206.81,101.35 206.81,96.65 204.51,94.35 v1(204.51,94.01)
  BOTTOM w0.102: v1(209.26,105.52) 208.8,105.98 208.8,106.86 209.22,107.28 210.59,107.28 211.11,106.76 211.69,106.76 212.07,106.38 U14.4 213.42,106.38 213.63,106.58 v2(213.63,108) 213.05,108.58 R758.1
MXM_DPB_N0: length 153.3
  TOP w0.102: JMXM1.274 205.17,102.02 205.05,101.9 204.91,101.9 204.84,101.98 204.84,102.35 204.51,102.68 204.33,102.68 204.1,102.91 v3(204.1,103.06)
  IN4 w0.117: v1(181.84,116.56) 182.11,116.56 182.23,116.45 182.23,116 182.09,115.87 181.8,115.87 181.03,115.11 179.21,115.11 177.6,116.71 170.19,116.71 166.14,120.76 161.8,120.76 157.36,125.2 156.3,125.2 154.46,127.05 154.46,128.11 152.14,130.42 147.41,130.42 145.45,132.37 138.27,132.37 137.24,131.34 132.41,131.34 132.24,131.51 117.82,131.51 115.38,133.95 111.68,133.95 110.94,134.69 107.55,134.69 106.75,133.88 105.38,133.88 104.73,133.23 98.94,133.23 96.8,131.09 85.55,131.09 83.15,133.49 83.15,135.3 v1(83.35,135.51)
  BOTTOM w0.102: v3(204.1,103.06) 203.99,102.94 203.99,102.6 204.06,102.53 204.33,102.53 204.51,102.34 204.87,102.34 205.17,102.64 205.17,106.7 203.24,108.63 203.24,109.8 201.22,111.81 198.33,111.81 196.8,113.34 188.71,113.34 186.45,115.6 182.55,115.6 182.19,115.95 182.19,116.56 182.07,116.69 181.97,116.69 v1(181.84,116.56) ; v1(83.35,135.51) 83.35,135.51 83.08,135.24 83.08,134.42 C438.2
MXM_DPB_N1: length 149.2
  TOP w0.102: v1(202.78,102.33) 202.79,102.33 202.97,102.15 203.3,102.15 204.16,101.28 204.16,100.64 204.4,100.4 204.88,100.4 204.99,100.52 JMXM1.280
  IN4 w0.117: v3(84.86,135.4) 84.89,135.4 85.3,134.98 85.3,133.34 86.73,131.92 96.32,131.92 98.78,134.37 103.28,134.37 103.66,134.75 106.05,134.75 107.18,135.88 114.77,135.88 118.35,132.3 133.09,132.3 133.41,132.61 137.4,132.61 137.96,133.17 146.04,133.17 148.01,131.21 152.46,131.21 155.28,128.39 155.28,127.72 156.91,126.09 157.57,126.09 162.13,121.54 166.47,121.54 170.13,117.87 178.07,117.87 179.97,115.98 180.51,115.98 180.71,116.17 180.71,116.47 180.57,116.61 180.43,116.61 v1(180.33,116.51)
  BOTTOM w0.102: v1(180.33,116.51) 180.59,116.51 180.72,116.38 180.72,115.7 181.87,114.55 185.71,114.55 187.68,112.59 196.42,112.59 198.55,110.45 200.7,110.45 202.47,108.68 202.47,108.03 203.3,107.2 203.3,103.95 203.24,103.89 203.24,102.19 203.14,102.1 203.01,102.1 202.78,102.33 v1(202.78,102.33) ; C440.2 85.44,134.81 v3(84.86,135.4)
MXM_DPB_N2: length 154.2
  TOP w0.102: JMXM1.286 205.14,99.02 205.08,98.96 205.08,98.86 205,98.79 203.93,98.79 203.67,99.04 203.67,99.17 204.02,99.51 v1(204.04,99.51)
  IN4 w0.117: v3(87.11,135.22) 87.02,135.12 87.02,134.79 87.1,134.71 87.43,134.71 89.37,132.78 96.02,132.78 99.08,135.83 102.77,135.83 103.06,135.53 105.52,135.53 106.66,136.67 115.17,136.67 118.75,133.1 132.7,133.1 133.01,133.4 137.08,133.4 137.72,134.04 146.61,134.04 148.11,132.54 152.24,132.54 156.2,128.57 156.2,127.91 157.19,126.93 157.85,126.93 162.38,122.39 166.72,122.39 169.82,119.29 178.17,119.29 179.92,117.54 183.35,117.54 183.87,117.02 183.87,115.79 182.81,114.73 182.21,114.73 181.54,114.06 181.54,113.85 181.79,113.59 182.45,113.59 182.53,113.67 182.53,113.76 v1(182.22,114.07)
  BOTTOM w0.102: v1(182.22,114.07) 182.45,113.84 182.45,113.64 182.74,113.35 183.23,113.35 183.45,113.12 185.75,113.12 187.21,111.66 195.95,111.66 198.52,109.09 200.94,109.09 201.61,108.42 201.61,107.61 202.55,106.67 202.55,104.96 201.99,104.4 201.99,101.42 202.61,100.79 202.61,99.03 203.01,98.63 203.49,98.63 203.78,98.92 203.78,99.26 v1(204.04,99.51) ; C442.2 86.99,134.57 86.99,135.1 v3(87.11,135.22)
MXM_DPB_N3: length 155.9
  TOP w0.102: v1(204,98.02) 203.98,98.02 203.63,97.67 203.63,97.45 203.8,97.29 204.9,97.29 204.95,97.34 204.95,97.48 204.99,97.52 JMXM1.292
  IN1 w0.117: v1(204,98.02) 203.83,98.18 203.83,98.43 203.43,98.83 198.56,98.83 197.99,98.26 197.31,98.26 196.7,98.88 194.34,98.88 193.44,99.78 193.44,104.34 194.07,104.97 194.07,109.72 194.29,109.94 194.55,109.94 194.7,109.79 v1(194.7,109.75)
  IN4 w0.117: v1(182.83,112.03) 183.01,112.21 183.53,112.21 184.84,113.52 184.84,117.72 184.22,118.34 180.22,118.34 177.38,121.18 169.04,121.18 166.99,123.23 162.65,123.23 158.14,127.74 157.54,127.74 157.11,128.17 157.11,128.77 152.56,133.32 148.43,133.32 146.76,134.99 135.28,134.99 134.56,134.26 132.73,134.26 132.47,134 118.98,134 115.53,137.46 106.05,137.46 105.42,136.83 98.92,136.83 95.65,133.56 89.77,133.56 88.95,134.38 88.95,135.36 v3(89.08,135.48)
  BOTTOM w0.102: v1(182.83,112.03) 182.99,112.19 185.55,112.19 187.04,110.71 193.29,110.71 194.02,109.98 194.47,109.98 v1(194.7,109.75) ; v3(89.08,135.48) 88.97,135.38 88.97,134.63 C444.2
MXM_DPB_P0: length 153.3
  TOP w0.102: v1(204.12,102.08) 204.12,102.29 204.24,102.41 204.4,102.41 204.57,102.24 204.57,101.87 204.8,101.64 205.04,101.64 205.16,101.52 JMXM1.276
  IN4 w0.117: v3(182.66,116.56) 182.52,116.42 182.52,115.89 182.21,115.58 181.91,115.58 181.15,114.82 179.09,114.82 177.49,116.43 170.07,116.43 166.03,120.47 161.69,120.47 157.24,124.92 156.19,124.92 154.17,126.93 154.17,127.99 152.03,130.13 147.29,130.13 145.33,132.09 138.38,132.09 137.36,131.06 132.29,131.06 132.12,131.23 117.7,131.23 115.26,133.67 111.56,133.67 110.82,134.4 107.67,134.4 106.86,133.6 105.5,133.6 104.85,132.94 99.05,132.94 96.92,130.81 85.43,130.81 82.86,133.37 82.86,135.37 v1(82.72,135.51)
  BOTTOM w0.102: v1(204.12,102.08) 204.98,102.08 205.43,102.53 205.43,106.81 203.5,108.74 203.5,109.91 201.33,112.08 198.44,112.08 196.91,113.6 188.82,113.6 186.56,115.86 182.66,115.86 182.46,116.06 182.46,116.37 v3(182.66,116.56) ; C431.2 82.82,134.51 82.82,135.41 v1(82.72,135.51)
MXM_DPB_P1: length 149.2
  TOP w0.102: v1(202.78,101.7) 202.96,101.88 203.19,101.88 203.9,101.17 203.9,100.53 204.29,100.14 204.88,100.14 204.99,100.02 JMXM1.282
  IN4 w0.117: v1(84.86,134.76) 85.02,134.6 85.02,133.22 86.61,131.63 96.44,131.63 98.89,134.09 103.4,134.09 103.77,134.46 106.17,134.46 107.3,135.6 114.65,135.6 118.24,132.02 133.21,132.02 133.52,132.33 137.52,132.33 138.08,132.89 145.93,132.89 147.89,130.92 152.34,130.92 155,128.27 155,127.6 156.79,125.81 157.46,125.81 162.01,121.26 166.35,121.26 170.02,117.59 177.95,117.59 179.85,115.69 180.63,115.69 180.99,116.06 180.99,116.36 v3(181.14,116.51)
  BOTTOM w0.102: v1(202.78,101.7) 202.91,101.83 203.25,101.83 203.5,102.08 203.5,103.78 203.57,103.84 203.57,107.31 202.74,108.14 202.74,108.79 200.81,110.72 198.66,110.72 196.53,112.85 187.79,112.85 185.82,114.82 181.98,114.82 180.99,115.81 180.99,116.35 v3(181.14,116.51) ; C439.2 84.43,134.39 84.29,134.53 84.29,134.86 84.4,134.98 84.64,134.98 v1(84.86,134.76)
MXM_DPB_P2: length 154.3
  TOP w0.102: v1(203.4,99.51) 203.4,98.93 203.82,98.52 JMXM1.288
  IN4 w0.117: v3(182.85,114.07) 182.81,114.03 182.81,113.55 182.57,113.3 181.68,113.3 181.25,113.73 181.25,114.18 182.09,115.02 182.69,115.02 183.58,115.91 183.58,116.9 183.23,117.25 179.8,117.25 178.05,119.01 169.7,119.01 166.61,122.11 162.27,122.11 157.73,126.64 157.07,126.64 155.92,127.79 155.92,128.46 152.12,132.25 147.99,132.25 146.49,133.75 137.83,133.75 137.2,133.12 133.13,133.12 132.82,132.81 118.63,132.81 115.06,136.39 106.78,136.39 105.64,135.25 102.94,135.25 102.65,135.54 99.19,135.54 96.14,132.49 89.25,132.49 87.32,134.43 86.98,134.43 86.73,134.68 86.73,134.93 v1(86.45,135.22)
  BOTTOM w0.102: v1(203.4,99.51) 203.52,99.4 203.52,99.03 203.38,98.9 203.12,98.9 202.88,99.14 202.88,100.91 202.26,101.53 202.26,104.29 202.82,104.85 202.82,106.78 201.88,107.72 201.88,108.53 201.05,109.36 198.63,109.36 196.06,111.93 187.32,111.93 185.86,113.39 183.56,113.39 183.34,113.61 182.85,113.61 182.71,113.75 182.71,113.93 v3(182.85,114.07) ; v1(86.45,135.22) 86.73,134.94 86.73,134.36 C441.2
MXM_DPB_P3: length 156
  TOP w0.102: JMXM1.294 203.69,97.02 203.37,97.34 v1(203.37,98.02)
  IN1 w0.117: v3(194.7,110.39) 194.54,110.23 194.17,110.23 193.78,109.84 193.78,105.08 193.15,104.45 193.15,99.66 194.22,98.59 196.58,98.59 197.2,97.98 198.11,97.98 198.68,98.55 203.31,98.55 203.55,98.31 203.55,98.2 v1(203.37,98.02)
  IN4 w0.117: v1(182.83,112.67) 183,112.5 183.41,112.5 184.55,113.64 184.55,117.6 184.1,118.06 180.1,118.06 177.26,120.9 168.92,120.9 166.87,122.95 162.53,122.95 158.03,127.45 157.42,127.45 156.83,128.05 156.83,128.65 152.44,133.04 148.31,133.04 146.64,134.7 135.4,134.7 134.68,133.98 132.85,133.98 132.59,133.72 118.86,133.72 115.41,137.17 106.17,137.17 105.54,136.55 99.04,136.55 95.77,133.27 89.66,133.27 88.66,134.26 88.66,135.26 v1(88.44,135.48)
  BOTTOM w0.102: v1(182.83,112.67) 183.04,112.46 185.66,112.46 187.15,110.97 193.4,110.97 194.13,110.25 194.56,110.25 v3(194.7,110.39) ; C443.2 88.71,134.31 88.71,135.22 v1(88.44,135.48)
MXM_DPC_AUX: length 213.5
  TOP w0.102: C389.2 44.51,139.87 44.4,139.76 44.4,139.07 v1(44.5,138.97) ; U9.50 42.97,142.02 42.9,141.95 42.9,141.85 43.06,141.68 43.06,141.07 42.61,140.61 42.4,140.61 42.32,140.54 v3(42.32,140.01) ; v1(200.25,108.27) 200.11,108.13 200.11,107.77 199.61,107.27 JMXM1.255
  IN4 w0.117: v1(200.25,108.27) 200.07,108.09 200.07,107.72 197.62,105.27 194.75,105.27 194.19,104.71 188.09,104.71 186.38,106.42 179.94,106.42 177.56,108.8 176.25,108.8 174.3,110.74 169.52,110.74 169.24,110.47 164.08,110.47 164.06,110.45 157.93,110.45 156.28,108.8 149.27,108.8 148.64,109.44 132.4,109.44 131.76,110.08 106.35,110.08 105.32,111.11 104.62,111.11 103.71,112.02 94.38,112.02 92.53,113.87 74.89,113.87 70.31,118.45 70.31,122.19 69.44,123.06 69.44,128.18 69.81,128.54 69.81,131 70.11,131.31 70.11,131.87 70.38,132.14 70.38,133.59 69.38,134.59 69.3,134.59 67.41,136.48 66.48,136.48 66.35,136.61 64.69,136.61 63.7,137.6 62.61,137.6 62.13,138.07 57.1,138.07 56.45,138.72 56.45,138.92 55.8,139.57 54.8,139.57 54.07,138.84 45.52,138.84 44.9,139.47 44.44,139.47 44.35,139.37 44.35,139.13 v1(44.5,138.97) 44.29,138.76 44.29,138.36 44,138.07 43.27,138.07 42.91,138.43 42.91,142.99 45.14,145.22 45.14,148.18 46.9,149.94 v1(46.9,150.46)
  BOTTOM w0.102: v1(44.5,138.97) 43.97,139.51 43.37,139.51 43.02,139.16 42.36,139.16 42.23,139.29 42.23,139.92 v3(42.32,140.01) ; v1(46.9,150.46) 46.9,150.57 46.53,150.94 R2156.2 46.22,150.96 Q335.1
MXM_DPC_AUX#: length 215.7
  TOP w0.102: C390.2 43.72,139.87 44.13,139.46 44.13,139.24 v1(43.86,138.97) ; v3(41.69,140.01) 41.7,140.01 42.05,140.37 42.05,140.65 42.29,140.88 42.5,140.88 42.8,141.18 42.8,141.57 42.63,141.74 42.63,142.01 42.57,142.08 U9.49 ; JMXM1.253 198.62,107.77 198.66,107.73 198.66,107.59 198.71,107.54 199.5,107.54 199.85,107.88 199.85,108.12 199.65,108.32 199.6,108.32 v1(199.55,108.27)
  IN4 w0.117: v1(45.02,154.55) 45.2,154.37 45.23,154.37 47.34,152.25 47.34,149.95 45.43,148.03 45.43,145.1 43.2,142.87 43.2,139.28 43.51,138.97 v1(43.86,138.97) 44.04,139.15 44.04,139.47 44.32,139.75 45.02,139.75 45.64,139.13 53.95,139.13 54.68,139.86 55.91,139.86 56.74,139.03 56.74,138.84 57.22,138.36 62.25,138.36 62.72,137.88 63.82,137.88 64.81,136.89 66.47,136.89 66.6,136.77 67.53,136.77 69.42,134.88 69.49,134.88 70.66,133.71 70.66,132.02 70.39,131.75 70.39,131.19 70.09,130.89 70.09,128.42 69.73,128.06 69.73,123.18 70.6,122.31 70.6,118.56 75.01,114.15 92.65,114.15 94.5,112.3 103.82,112.3 104.74,111.39 105.44,111.39 106.47,110.36 131.88,110.36 132.52,109.72 148.76,109.72 149.39,109.09 156.17,109.09 157.81,110.73 163.94,110.73 163.96,110.75 169.12,110.75 169.4,111.03 174.42,111.03 176.36,109.08 177.68,109.08 180.06,106.71 186.5,106.71 188.21,104.99 194.07,104.99 194.63,105.55 197.5,105.55 199.79,107.84 199.79,108.09 199.62,108.27 v1(199.55,108.27)
  BOTTOM w0.102: v3(41.69,140.01) 41.96,139.74 41.96,139.18 42.25,138.89 43.13,138.89 43.46,139.22 43.62,139.22 v1(43.86,138.97) ; Q335.4 44.92,154.44 v1(45.02,154.55) 45.02,154.61 44.72,154.91 R2155.2
MXM_DPC_AUX#_C: length 2.2
  TOP w0.102: U9.51 43.37,141.76 43.97,141.16 43.97,141.09 C390.1
MXM_DPC_AUX_C: length 2.3
  TOP w0.102: C389.1 44.61,140.82 44.23,141.2 44.23,141.28 43.77,141.74 U9.52
MXM_DPC_HPD: length 246.5
  TOP w0.102: D7.2 190.94,91.37 190.94,93.24 191.31,93.61 191.31,100.67 193.91,103.28 v3(193.91,103.77) ; U9.5 47.24,145.11 v1(47.33,145.02)
  IN3 w0.127: v3(193.91,103.77) 194.64,103.77 196.68,105.82 196.68,106.46 197.85,107.63 200.96,107.63 v1(201.01,107.58) 202.13,107.58 203.36,108.81 204.34,108.81 207.14,111.61 209.54,111.61 211.11,113.18 213.49,113.18 v1(213.82,112.85)
  IN4 w0.117: v1(47.33,145.02) 48,145.02 49.31,146.33 49.31,148.53 50.29,149.51 51.51,149.51 54.18,146.84 57.89,146.84 61.19,143.53 67.65,143.53 68.54,142.65 70.67,142.65 71.13,142.19 71.13,141.91 72.93,140.11 73.79,140.11 75.04,138.85 75.04,138.27 75.54,137.77 75.54,136.27 75.36,136.09 75.36,131.38 74.18,130.2 74.18,127.29 73.74,126.85 73.74,124.3 74.61,123.43 74.61,119.68 76.51,117.78 79.48,117.78 80.31,118.62 83.63,118.62 85.23,120.22 94.99,120.22 95.76,119.46 95.76,117.75 98.36,115.15 105.27,115.15 106.04,114.38 116.42,114.38 117.57,113.23 133.88,113.23 134.1,113.01 154.67,113.01 155.75,114.09 161.59,114.09 162.42,114.92 175.71,114.92 177.15,113.48 179.97,113.48 182.93,110.52 185.88,110.52 186.66,111.3 196.78,111.3 198.82,113.34 200.83,113.34 202.17,112 202.17,108.74 v1(201.01,107.58)
  BOTTOM w0.102: v1(213.82,112.85) 212.61,111.65 212.61,109.37 211.96,108.73 U25.2
MXM_DPC_HPD_GATE: length 10.7
  TOP w0.102: JMXM1.262 208.23,105.02 v1(208.34,105.13)
  BOTTOM w0.102: 208.25,107.95 208.25,107.1 208.53,106.82 208.53,105.32 v1(208.34,105.13) ; 208.25,107.95 208.25,109.47 209.45,110.67 R519.2 ; 208.25,107.95 v2(208.27,107.95) 208.58,107.95 208.71,108.08 U25.4
MXM_DPC_N0: length 208.6
  TOP w0.102: v1(199.56,114.28) 199.68,114.39 199.82,114.39 199.96,114.25 199.96,113.85 199.69,113.59 198.77,113.59 198.59,113.77 JMXM1.229 ; v1(50.71,143.04) 50.32,142.65 49.92,142.65 49.85,142.72 C247.2 ; v1(183.46,123.86) 183.67,124.07 183.67,124.43 183.81,124.57 183.81,126 183.67,126.14 183.67,130.85 184.67,131.85 184.67,132.21 v3(184.47,132.41)
  IN3 w0.127: v3(184.47,132.41) 184.64,132.41 184.82,132.23 184.82,132.04 184.67,131.89 181.53,131.89 179.69,130.05 173.65,130.05 172.9,130.8 164.21,130.8 160.3,134.71 159.69,134.71 157.73,136.67 154.3,136.67 153.8,136.16 132.87,136.16 132.59,136.44 129.13,136.44 126.19,133.49 122.91,133.49 120.14,130.72 118.49,130.72 114.88,127.11 113.87,127.11 113.41,126.66 113.41,124.6 111.71,122.9 109.7,122.9 107.85,121.04 107.85,118.64 104.71,115.51 96.82,115.51 96.05,116.28 92.31,116.28 89.43,119.16 81.24,119.16 79.86,117.78 76.49,117.78 74.48,119.79 74.48,133.88 74.13,134.24 74.13,137.41 73.47,138.07 73.47,138.39 72.99,138.88 71.87,138.88 71.37,139.37 70.57,139.37 70.17,138.96 62.19,138.96 58.81,142.34 51.85,142.34 51.33,142.86 50.89,142.86 v1(50.71,143.04)
  BOTTOM w0.102: v1(183.46,123.86) 183.59,123.86 183.64,123.81 183.64,122.6 191.78,114.45 196.59,114.45 196.87,114.73 199.7,114.73 199.79,114.64 199.79,114.51 v1(199.56,114.28)
MXM_DPC_N0_C: length 4.1
  TOP w0.102: C247.1 48.48,142.65 48.39,142.65 48.23,142.8 48.23,143.54 47.15,144.62 46.9,144.62 46.8,144.71 U9.4
MXM_DPC_N1: length 192.8
  TOP w0.102: v1(199.46,112.75) 199.54,112.84 199.74,112.84 199.87,112.71 199.87,112.46 199.52,112.1 198.82,112.1 198.59,112.1 198.42,112.27 JMXM1.235 ; v3(50.59,144.95) 50.41,144.76 50.19,144.76 C252.2
  IN4 w0.117: v1(199.46,112.75) 199.54,112.84 199.79,112.84 199.88,112.75 199.88,112.17 200.24,111.81 201.08,111.81 201.38,111.51 201.38,109.46 201.07,109.14 198.61,109.14 196.71,107.24 194.92,107.24 193.64,105.96 191.13,105.96 189.83,107.25 187.17,107.25 186.93,107.49 180.55,107.49 177.77,110.27 176.62,110.27 174.97,111.92 168.27,111.92 168,111.65 157.28,111.65 156.13,110.5 133,110.5 132.36,111.14 106.95,111.14 105.91,112.18 105.15,112.18 104.25,113.09 95.01,113.09 91.3,116.8 91.3,117.6 90.8,118.1 88.21,118.1 85.83,115.72 75.66,115.72 72.24,119.14 72.24,122.88 71.29,123.83 71.29,127.39 71.66,127.76 71.66,130.05 72.06,130.44 72.06,131.14 73.2,132.29 73.2,135.51 71.88,136.84 70.67,136.84 68.69,138.81 65.26,138.81 64.55,139.52 63.46,139.52 61.56,141.42 55.04,141.42 52.61,143.85 52.28,143.85 51.33,144.79 50.75,144.79 v3(50.59,144.95)
MXM_DPC_N1_C: length 3.5
  TOP w0.102: C252.1 48.48,144.68 48.39,144.68 48.04,145.02 48.04,145.3 47.5,145.85 47.02,145.85 46.95,145.91 U9.7
MXM_DPC_N2: length 188.1
  TOP w0.102: v3(50.59,147.17) 50.59,146.99 50.46,146.85 50.13,146.85 C254.2 ; v1(199.5,111.35) 199.62,111.35 199.81,111.16 199.81,111.13 199.92,111.02 199.92,110.92 199.53,110.53 198.69,110.53 198.65,110.57 198.65,110.73 198.61,110.77 JMXM1.241
  IN4 w0.117: v3(50.59,147.17) 50.51,147.08 50.51,146.9 50.62,146.79 51.08,146.79 52.93,144.93 52.93,144.7 55.43,142.2 61.92,142.2 63.66,140.46 64.85,140.46 65.71,139.6 69.01,139.6 71,137.62 72.22,137.62 73.99,135.85 73.99,131.94 72.86,130.81 72.86,127.81 72.08,127.03 72.08,124.15 73.05,123.18 73.05,119.43 75.98,116.5 84.27,116.5 86.68,118.91 91.69,118.91 95.32,115.28 96.21,115.28 97.62,113.87 104.63,113.87 105.44,113.06 106.44,113.06 107.58,111.93 132.92,111.93 133.49,111.35 155.69,111.35 156.79,112.46 164.15,112.46 164.81,113.12 168.3,113.12 168.72,112.71 175.3,112.71 176.76,111.25 178.32,111.25 180.33,109.24 190.11,109.24 190.63,108.73 190.63,108.73 192.46,106.9 193.37,106.9 194.64,108.17 195.77,108.17 198.34,110.74 199.51,110.74 199.76,110.98 199.76,111.24 199.64,111.35 v1(199.5,111.35)
MXM_DPC_N2_C: length 3
  TOP w0.102: U9.10 46.95,147.11 47.02,147.05 47.97,147.05 48.27,146.75 48.52,146.75 C254.1
MXM_DPC_N3: length 183
  TOP w0.102: v3(50.59,149.01) 50.41,148.83 50.19,148.83 C246.2 ; JMXM1.247 196.79,109.27 196.68,109.15 193.4,109.15 v1(193.19,109.36)
  IN4 w0.117: v1(193.19,109.36) 193.04,109.21 192.6,109.21 191.01,110.8 186.86,110.8 186.08,110.02 182.55,110.02 179.61,112.95 176.93,112.95 176.4,113.49 169.43,113.49 168.88,114.03 164.25,114.03 163.7,113.49 156.58,113.49 155.32,112.22 133.75,112.22 133.24,112.73 117.37,112.73 116.22,113.88 105.8,113.88 105.03,114.65 98,114.65 95.59,117.06 94.68,117.06 92.04,119.7 85.73,119.7 84.09,118.06 80.49,118.06 79.71,117.28 76.3,117.28 73.98,119.61 73.98,123.36 73.24,124.09 73.24,127.06 73.68,127.51 73.68,130.48 74.83,131.62 74.83,136.13 73.43,137.53 73.43,138.47 72.99,138.91 72.49,138.91 69.89,141.52 69.49,141.52 69.23,141.78 68.69,141.78 67.58,142.9 66.34,142.9 65.92,142.48 65.92,142.09 65.53,141.7 64.46,141.7 63.17,142.98 55.81,142.98 53.86,144.93 53.86,145.25 52.27,146.84 52.27,148.04 51.46,148.85 50.75,148.85 v3(50.59,149.01)
MXM_DPC_N3_C: length 3.1
  TOP w0.102: C246.1 48.55,148.81 48.04,148.81 47.65,148.41 47.48,148.25 46.86,148.25 46.8,148.31 U9.13
MXM_DPC_P0: length 208.6
  TOP w0.102: v1(184.1,123.86) 183.93,124.03 183.93,124.32 184.07,124.46 184.07,126.11 183.93,126.25 183.93,130.74 184.94,131.74 184.94,132.12 v1(185.23,132.41) ; JMXM1.231 198.47,113.27 198.53,113.32 199.81,113.32 200.23,113.74 200.23,114.1 v3(200.4,114.28) ; C253.2 50.23,142.38 v1(50.71,142.38)
  IN3 w0.127: v1(185.23,132.41) 185.12,132.31 185.12,131.91 184.8,131.59 181.66,131.59 179.82,129.74 173.52,129.74 172.77,130.49 164.08,130.49 160.17,134.4 159.56,134.4 157.61,136.36 154.43,136.36 153.92,135.85 132.74,135.85 132.46,136.13 129.26,136.13 126.31,133.19 123.04,133.19 120.27,130.42 118.62,130.42 115.01,126.81 113.99,126.81 113.71,126.53 113.71,124.47 111.83,122.59 109.83,122.59 108.15,120.92 108.15,118.52 104.84,115.2 96.7,115.2 95.92,115.98 92.19,115.98 89.31,118.86 81.37,118.86 79.98,117.48 76.36,117.48 74.18,119.66 74.18,133.76 73.82,134.11 73.82,137.29 73.16,137.95 73.16,138.27 72.86,138.57 71.74,138.57 71.25,139.07 70.7,139.07 70.29,138.66 62.06,138.66 58.69,142.04 51.73,142.04 51.2,142.56 50.89,142.56 v1(50.71,142.38)
  BOTTOM w0.102: v1(184.1,123.86) 183.91,123.67 183.91,122.71 191.9,114.72 196.48,114.72 196.76,115 199.81,115 200.06,114.75 200.06,114.43 200.21,114.28 v3(200.4,114.28)
MXM_DPC_P0_C: length 4.1
  TOP w0.102: C253.1 48.57,142.38 48.27,142.38 47.97,142.69 47.97,143.43 v1(47.44,143.95) 47.04,144.35 46.83,144.35 46.8,144.31 U9.3
MXM_DPC_P1: length 192.9
  TOP w0.102: v3(200.32,112.75) 200.13,112.55 200.13,112.33 199.63,111.84 198.65,111.84 198.59,111.77 JMXM1.237 ; v1(50.59,144.31) 50.41,144.49 50.26,144.49 C242.2
  IN4 w0.117: v1(50.59,144.31) 50.79,144.51 51.21,144.51 52.16,143.56 52.49,143.56 54.92,141.14 61.45,141.14 63.34,139.24 64.43,139.24 65.14,138.53 68.57,138.53 70.55,136.55 71.76,136.55 72.92,135.39 72.92,132.41 71.77,131.26 71.77,130.56 71.38,130.17 71.38,127.88 71.01,127.51 71.01,123.71 71.95,122.77 71.95,119.02 75.54,115.43 85.95,115.43 88.33,117.81 90.69,117.81 91.01,117.48 91.01,116.68 94.9,112.8 104.13,112.8 105.04,111.89 105.8,111.89 106.83,110.86 132.24,110.86 132.89,110.22 156.25,110.22 157.4,111.37 168.12,111.37 168.39,111.64 174.85,111.64 176.5,109.99 177.65,109.99 180.43,107.21 186.81,107.21 187.05,106.97 189.72,106.97 191.01,105.67 193.75,105.67 195.04,106.95 196.83,106.95 198.73,108.86 201.19,108.86 201.67,109.34 201.67,111.63 201.2,112.1 200.36,112.1 200.17,112.28 200.17,112.6 v3(200.32,112.75)
MXM_DPC_P1_C: length 3.5
  TOP w0.102: U9.6 46.95,145.51 47.02,145.58 47.39,145.58 v1(47.61,145.36) 47.78,145.19 47.78,144.91 48.27,144.41 48.57,144.41 C242.1
MXM_DPC_P2: length 188.1
  TOP w0.102: v1(50.59,146.34) 50.39,146.55 50.07,146.55 49.85,146.32 C251.2 ; JMXM1.243 197.7,110.26 199.64,110.26 200.19,110.81 200.19,111.35 v3(200.2,111.36)
  IN4 w0.117: v3(200.2,111.36) 200.04,111.2 200.04,110.86 199.63,110.45 198.46,110.45 195.89,107.89 194.75,107.89 193.48,106.62 192.34,106.62 190.52,108.44 190.51,108.44 189.99,108.95 180.21,108.95 178.2,110.97 176.64,110.97 175.19,112.42 168.6,112.42 168.19,112.83 164.92,112.83 164.26,112.17 156.91,112.17 155.81,111.07 133.37,111.07 132.8,111.64 107.46,111.64 106.32,112.78 105.32,112.78 104.52,113.58 97.51,113.58 96.1,114.99 95.2,114.99 91.57,118.63 86.8,118.63 84.39,116.22 75.86,116.22 72.76,119.31 72.76,123.06 71.79,124.03 71.79,127.15 72.57,127.93 72.57,130.93 73.7,132.06 73.7,135.73 72.11,137.33 70.88,137.33 68.9,139.32 65.59,139.32 64.74,140.18 63.55,140.18 61.81,141.92 55.32,141.92 52.65,144.59 52.65,144.82 50.96,146.5 50.76,146.5 50.6,146.34 v1(50.59,146.34)
MXM_DPC_P2_C: length 3
  TOP w0.102: U9.9 46.95,146.71 47.02,146.78 v1(47.66,146.78) 47.86,146.78 48.16,146.48 48.53,146.48 C251.1
MXM_DPC_P3: length 183.1
  TOP w0.102: v1(50.59,148.37) 50.41,148.56 50.26,148.56 C245.2 ; v3(193.19,108.73) 193.35,108.89 196.68,108.89 196.79,108.77 JMXM1.249
  IN4 w0.117: v3(193.19,108.73) 192.99,108.93 192.48,108.93 190.89,110.52 186.98,110.52 186.2,109.74 182.43,109.74 179.5,112.67 176.81,112.67 176.28,113.2 169.31,113.2 168.77,113.75 164.37,113.75 163.82,113.2 156.7,113.2 155.43,111.94 133.63,111.94 133.12,112.45 117.25,112.45 116.1,113.6 105.68,113.6 104.91,114.37 97.88,114.37 95.47,116.78 94.57,116.78 91.93,119.42 85.85,119.42 84.2,117.78 80.61,117.78 79.83,117 76.19,117 73.69,119.49 73.69,123.24 72.95,123.98 72.95,127.18 73.4,127.62 73.4,130.6 74.54,131.74 74.54,136.01 73.15,137.41 73.15,138.35 72.87,138.63 72.37,138.63 69.77,141.23 69.38,141.23 69.11,141.5 68.57,141.5 67.46,142.62 66.46,142.62 66.21,142.36 66.21,141.98 65.65,141.42 64.34,141.42 63.06,142.7 55.69,142.7 53.57,144.82 53.57,145.13 51.99,146.72 51.99,147.92 51.34,148.57 50.78,148.57 v1(50.59,148.37)
MXM_DPC_P3_C: length 3.1
  TOP w0.102: U9.12 46.81,147.91 46.87,147.98 47.59,147.98 v1(47.84,148.22) 48.15,148.54 48.51,148.54 C245.1
MXM_EDP_AUX+: length 196
  TOP w0.102: C371.1 49.45,152.71 49.35,152.6 49.35,151.78 49.45,151.68 49.53,151.68 v1(49.79,151.94) ; v3(204.64,105.52) 204.64,105.65 204.79,105.8 204.95,105.8 205.24,105.52 JMXM1.260
  IN4 w0.117: v1(49.79,151.94) 49.6,151.75 49.24,151.75 48.96,151.47 48.96,150.73 49.68,150.01 51.72,150.01 54.39,147.33 58.18,147.33 59.61,145.9 66.11,145.9 67.25,144.76 67.9,144.76 68.73,143.92 73.46,143.92 74.47,142.91 79.95,142.91 81.5,141.36 84.44,141.36 84.67,141.13 85.84,141.13 85.91,141.19 91.3,141.19 92.64,142.54 97.23,142.54 98.25,143.55 108.52,143.55 108.89,143.93 110.13,143.93 110.32,144.12 112.69,144.12 112.96,144.39 115.06,144.39 115.38,144.7 116.23,144.7 116.51,144.42 118.6,144.42 118.9,144.12 146.97,144.12 154.94,136.15 156.1,136.15 158.03,134.22 158.85,134.22 160.04,133.03 160.04,132.64 161.8,130.88 161.8,130.87 164.16,128.51 169.54,128.51 171.13,126.91 180.29,126.91 181.92,125.28 183.65,125.28 184.72,124.21 193.58,124.21 194.2,123.59 196.72,123.59 199.26,121.05 199.4,120.91 203.1,120.91 206.14,117.87 206.14,116.31 206.87,115.57 206.87,113.41 206.54,113.08 204.32,113.08 204.15,112.91 203.69,112.91 203.27,112.49 203.27,106.18 203.72,105.72 204.43,105.72 v3(204.64,105.52)
MXM_EDP_AUX+_C: length 4.3
  TOP w0.102: R336.2 C371.2 49.45,154.02 49.45,154.32 48.94,154.83 48.94,154.85 48.59,155.21 48.59,155.58 48.74,155.73 JEDP1.38
MXM_EDP_AUX-: length 195.9
  TOP w0.102: v3(49.79,151.31) 49.64,151.46 49.36,151.46 49.13,151.69 49.13,152.44 C373.1 ; v1(204.64,106.39) 204.64,106.13 204.75,106.02 JMXM1.258
  IN4 w0.117: v1(204.64,106.39) 204.79,106.39 204.91,106.27 204.91,106.08 204.79,105.96 203.82,105.96 203.5,106.27 203.5,112.39 203.79,112.68 204.25,112.68 204.42,112.84 206.64,112.84 207.11,113.31 207.11,115.67 206.37,116.41 206.37,117.97 203.2,121.14 199.5,121.14 199.36,121.29 196.82,123.83 194.3,123.83 193.68,124.45 184.82,124.45 183.75,125.52 182.02,125.52 180.39,127.15 171.23,127.15 169.63,128.75 164.26,128.75 162.04,130.97 162.04,130.98 160.28,132.73 160.28,133.13 158.95,134.46 158.13,134.46 156.2,136.39 155.04,136.39 147.07,144.36 119,144.36 118.7,144.66 116.61,144.66 116.33,144.94 115.28,144.94 114.97,144.62 112.86,144.62 112.6,144.36 110.23,144.36 110.03,144.17 108.79,144.17 108.42,143.79 98.15,143.79 97.13,142.77 92.54,142.77 91.2,141.43 85.81,141.43 85.74,141.36 84.77,141.36 84.54,141.59 81.6,141.59 80.05,143.14 74.57,143.14 73.56,144.16 68.83,144.16 68,145 67.35,145 66.21,146.14 59.71,146.14 58.28,147.57 54.49,147.57 51.81,150.24 49.78,150.24 49.2,150.83 49.2,151.37 49.34,151.51 49.59,151.51 v3(49.79,151.31)
MXM_EDP_AUX-_C: length 4.3
  TOP w0.102: JEDP1.39 48.24,155.72 48.37,155.58 48.37,155.09 v1(48.58,154.88) 49.24,154.23 49.24,154.02 C373.2 47.93,153.66 R339.2
MXM_EDP_HPD: length 214.2
  TOP w0.102: v1(56.55,157.42) 56.74,157.23 JEDP1.22 ; v1(66.83,154.39) 67.55,153.67 R222.2 ; v3(202.08,105.78) 203.16,104.7 204.86,104.7 205.04,104.52 JMXM1.264
  IN2 w0.127: v1(56.55,157.42) 57.05,156.92 61.75,156.92 62.35,156.32 65.1,156.32 66.83,154.6 v1(66.83,154.39)
  IN3 w0.127: v1(80.29,139.38) 78.8,140.87 78.8,142.57 77.14,144.23 75.05,144.23 72.55,146.74 71.28,146.74 68.77,149.25 68.77,149.8 67.78,150.79 64.63,150.79 64.12,151.3 64.11,151.3 64.11,154.48 64.9,155.27 66.15,155.27 66.83,154.6 v1(66.83,154.39)
  IN4 w0.117: v3(202.08,105.78) 202.75,106.45 202.75,112.12 201.03,113.84 198.61,113.84 196.57,111.8 185.98,111.8 185.71,111.52 182.64,111.52 180.18,113.98 177.43,113.98 176,115.42 154.96,115.42 153.05,113.5 134.39,113.5 133.01,114.88 107.52,114.88 104.42,117.98 97.03,117.98 96.3,118.71 96.3,119.85 94.93,121.22 85.38,121.22 83.46,119.3 80.24,119.3 79.35,120.19 76.36,120.19 75.11,121.45 75.11,123.64 74.26,124.49 74.26,126.64 74.69,127.08 74.69,129.95 75.42,130.68 76,130.68 76.43,131.12 76.43,132.16 76.12,132.46 76.12,137.08 76.38,137.34 76.38,137.91 77.85,139.38 v1(80.29,139.38)
MXM_EDP_TX0+: length 186.3
  TOP w0.102: C379.1 52.42,152.45 52.42,151.98 v3(52.66,151.74) ; v1(204.03,111.36) 204.31,111.64 204.88,111.64 204.99,111.52 JMXM1.236
  IN4 w0.117: v1(204.03,111.36) 204.25,111.58 205.81,111.58 206.31,112.08 206.97,112.08 208.27,113.38 208.27,117.11 203.5,121.88 199.81,121.88 199.57,122.11 196.35,125.33 186.18,125.33 185.04,126.47 182.11,126.47 180.63,127.95 171.47,127.95 169.94,129.48 164.56,129.48 163.28,130.76 163.28,131.58 161.26,133.59 160.89,133.59 158.46,136.03 158.21,136.03 157.7,136.54 157.1,136.54 156.43,137.2 155.26,137.2 147.34,145.13 119.73,145.13 119.4,145.45 116.91,145.45 116.69,145.68 114.76,145.68 114.45,145.38 109.23,145.38 108.98,145.13 102.33,145.13 101.78,144.58 97.43,144.58 96.44,143.59 92.3,143.59 90.88,142.16 86.43,142.16 85.31,143.29 80.95,143.29 80.33,143.91 75.19,143.91 73.17,145.94 69.38,145.94 68.91,146.41 68.25,146.41 67.78,146.88 60.39,146.88 58.96,148.3 54.79,148.3 52.47,150.62 52.47,151.55 v3(52.66,151.74)
MXM_EDP_TX0+_C: length 4.8
  TOP w0.102: C379.2 52.28,154.05 52.28,154.19 52.08,154.39 50.55,154.39 50.11,154.83 v1(50.11,155.08) 50.11,155.59 50.19,155.66 50.24,155.72 JEDP1.35
MXM_EDP_TX0-: length 186.3
  TOP w0.102: v3(204.03,112.2) 204.38,111.85 204.83,111.85 204.99,112.02 JMXM1.234 ; v1(52.02,151.74) 52.18,151.9 52.18,152.25 C380.1
  IN4 w0.117: v3(204.03,112.2) 204,112.17 204,111.86 204.04,111.82 205.71,111.82 206.21,112.31 206.88,112.31 208.04,113.48 208.04,117.01 203.41,121.64 199.71,121.64 199.48,121.87 196.26,125.09 186.08,125.09 184.94,126.23 182.01,126.23 180.53,127.71 171.37,127.71 169.84,129.24 164.46,129.24 163.04,130.66 163.04,131.48 161.17,133.36 160.8,133.36 158.36,135.79 158.11,135.79 157.6,136.3 157,136.3 156.34,136.96 155.17,136.96 147.24,144.89 119.63,144.89 119.31,145.22 116.82,145.22 116.59,145.45 114.85,145.45 114.55,145.14 109.33,145.14 109.08,144.89 102.43,144.89 101.87,144.34 97.53,144.34 96.54,143.35 92.4,143.35 90.97,141.93 86.34,141.93 85.21,143.05 80.86,143.05 80.23,143.68 75.09,143.68 73.07,145.7 69.28,145.7 68.81,146.17 68.15,146.17 67.68,146.64 60.29,146.64 58.86,148.07 54.69,148.07 52.23,150.53 52.23,151.53 v1(52.02,151.74)
MXM_EDP_TX0-_C: length 4.8
  TOP w0.102: C380.2 52.07,154 52.07,154.1 51.99,154.18 50.46,154.18 49.88,154.75 49.88,155.6 49.74,155.74 JEDP1.36
MXM_EDP_TX1+: length 191
  TOP w0.102: v1(54.44,151.74) 54.21,151.97 54.21,152.34 C377.1 ; JMXM1.242 204.99,110.02 204.82,110.19 204.26,110.19 v3(204.03,109.96)
  IN4 w0.117: v3(204.03,109.96) 204.21,110.14 205.48,110.14 206.53,111.19 207.9,111.19 209.01,112.3 209.01,117.41 203.81,122.61 200.11,122.61 197.12,125.61 197.12,126.05 196.64,126.53 187.28,126.53 185.12,128.68 171.77,128.68 170.24,130.21 164.88,130.21 164.18,130.91 164.18,131.75 161.53,134.4 161.13,134.4 159.64,135.89 159.64,137.27 158.72,138.19 157.4,138.19 157.15,137.94 155.57,137.94 145.54,147.96 120.25,147.96 118.57,146.29 117.25,146.29 117.12,146.42 114.38,146.42 114.11,146.15 108.9,146.15 108.65,145.9 102.04,145.9 101.5,145.36 92.42,145.36 90.05,142.98 87.5,142.98 86.46,144.02 82.19,144.02 80.07,146.15 74.19,146.15 73.62,146.71 70.75,146.71 70.31,147.16 69.26,147.16 67.92,148.49 65.72,148.49 64.88,147.65 60.76,147.65 59.37,149.04 55.11,149.04 54.37,149.78 54.37,151.67 v1(54.44,151.74)
MXM_EDP_TX1+_C: length 4.7
  TOP w0.102: JEDP1.32 51.74,155.74 51.64,155.64 51.64,155.52 51.75,155.41 52.06,155.41 52.27,155.19 52.3,155.19 52.68,154.81 52.68,154.79 53.05,154.42 53.87,154.42 54.16,154.13 54.16,154.08 C377.2
MXM_EDP_TX1-: length 190.9
  TOP w0.102: C378.1 54,152.34 54,151.94 v3(53.8,151.74) ; v1(204.03,110.73) 204.35,110.41 204.88,110.41 204.99,110.52 JMXM1.240
  IN4 w0.117: v1(204.03,110.73) 204.03,110.52 204.18,110.38 205.38,110.38 206.43,111.43 207.8,111.43 208.77,112.4 208.77,117.31 203.71,122.38 200.01,122.38 196.88,125.51 196.88,125.95 196.54,126.29 187.18,126.29 185.02,128.45 171.67,128.45 170.14,129.98 164.78,129.98 163.95,130.81 163.95,131.65 161.44,134.16 161.03,134.16 159.4,135.8 159.4,137.18 158.63,137.95 157.5,137.95 157.25,137.7 155.47,137.7 145.44,147.73 120.34,147.73 118.67,146.05 117.16,146.05 117.02,146.18 114.48,146.18 114.21,145.91 109,145.91 108.75,145.66 102.14,145.66 101.6,145.12 92.52,145.12 90.14,142.75 87.4,142.75 86.36,143.79 82.09,143.79 79.97,145.91 74.09,145.91 73.53,146.47 70.65,146.47 70.21,146.92 69.16,146.92 67.82,148.25 65.82,148.25 64.98,147.41 60.66,147.41 59.27,148.8 55.02,148.8 54.13,149.69 54.13,151.41 v3(53.8,151.74)
MXM_EDP_TX1-_C: length 4.7
  TOP w0.102: JEDP1.33 51.24,155.81 51.43,155.62 51.43,155.43 51.66,155.19 51.97,155.19 v1(52.33,154.83) 52.96,154.2 53.78,154.2 53.95,154.04 53.95,153.97 C378.2
MXM_EDP_TX2+: length 189.1
  TOP w0.102: v1(207.42,108.24) 207.06,108.6 206.87,108.6 206.79,108.52 JMXM1.248 ; v3(56.3,151.82) 56.09,152.02 56.09,152.31 C375.1
  IN4 w0.117: v3(56.3,151.82) 56.09,151.61 56.09,151.11 56.5,150.7 60.17,150.7 61.09,149.78 67.78,149.78 69.53,148.03 74.57,148.03 75.3,147.3 79.95,147.3 80.18,147.07 81.07,146.19 86.59,146.19 87.47,147.07 101.41,147.07 101.67,147.33 106.88,147.33 107.32,146.88 113.71,146.88 114.02,147.19 114.56,147.19 115.11,147.74 116.53,147.74 116.72,147.93 118.66,147.93 119.42,148.7 145.84,148.7 155.87,138.67 156.79,138.67 157.09,138.98 158.98,138.98 160.5,137.45 160.5,136.55 161.91,135.14 162.38,135.14 165,132.53 165,131.37 165.42,130.95 171.18,130.95 172.57,129.57 182.82,129.57 184.08,130.83 185.16,130.83 187.61,128.37 196.21,128.37 196.7,127.89 196.7,127.5 197.85,126.35 197.85,125.91 200.25,123.51 200.27,123.51 200.43,123.35 204.25,123.35 206.79,120.81 208.76,120.81 210.6,118.96 210.6,111.24 207.82,108.45 207.63,108.45 v1(207.42,108.24)
MXM_EDP_TX2+_C: length 5.2
  TOP w0.102: C375.2 56.09,154.05 56.09,154.18 55.9,154.37 54.93,154.37 54.16,155.13 53.37,155.13 53.14,155.36 53.14,155.59 53.24,155.69 JEDP1.29
MXM_EDP_TX2-: length 189
  TOP w0.102: v3(207.42,109.07) 207.17,108.83 206.98,108.83 206.79,109.02 JMXM1.246 ; C376.1 55.88,152.36 55.88,152.03 v1(55.66,151.82)
  IN4 w0.117: v1(55.66,151.82) 55.86,151.62 55.86,151.01 56.41,150.46 60.07,150.46 60.99,149.54 67.69,149.54 69.43,147.8 74.47,147.8 75.2,147.07 79.85,147.07 80.08,146.84 80.97,145.95 86.69,145.95 87.57,146.84 101.51,146.84 101.76,147.09 106.78,147.09 107.22,146.65 113.8,146.65 114.11,146.96 114.66,146.96 115.21,147.5 116.63,147.5 116.82,147.69 118.75,147.69 119.52,148.46 145.74,148.46 155.77,138.43 156.88,138.43 157.19,138.74 158.88,138.74 160.26,137.35 160.26,136.45 161.81,134.9 162.29,134.9 164.76,132.43 164.76,131.27 165.32,130.71 171.09,130.71 172.47,129.33 182.92,129.33 184.18,130.59 185.06,130.59 187.51,128.14 196.12,128.14 196.47,127.79 196.47,127.41 197.62,126.26 197.62,125.81 200.16,123.27 200.17,123.27 200.34,123.11 204.16,123.11 206.7,120.57 208.66,120.57 210.37,118.87 210.37,111.33 207.72,108.69 207.44,108.69 207.31,108.81 207.31,108.97 v3(207.42,109.07)
MXM_EDP_TX2-_C: length 5.2
  TOP w0.102: JEDP1.30 52.74,155.78 52.93,155.6 52.93,155.27 53.29,154.9 v1(53.82,154.9) 54.09,154.9 54.84,154.15 55.81,154.15 55.88,154.09 55.88,154 C376.2
MXM_EDP_TX3+: length 189.8
  TOP w0.102: JMXM1.254 206.79,107.02 206.89,107.12 207.05,107.12 v3(207.44,106.73) ; C372.1 57.96,152.27 57.96,152.03 v1(58.09,151.9)
  IN4 w0.117: v3(207.44,106.73) 207.66,106.95 208.36,106.95 211.43,110.02 211.43,119.18 209.07,121.54 207.1,121.54 204.56,124.08 200.74,124.08 198.61,126.21 198.61,126.64 197.44,127.81 197.44,128.31 196.64,129.11 187.93,129.11 185.48,131.56 183.5,131.56 182.25,130.32 173.09,130.32 171.72,131.68 167.72,131.68 163.49,135.92 162.19,135.92 161.26,136.85 161.26,138.72 160.16,139.82 157.75,139.82 156.87,140.71 156.56,140.71 156.07,141.2 156.07,141.28 155.37,141.97 153.64,141.97 151.5,144.11 151.5,144.74 149.77,146.47 149.15,146.47 146.16,149.46 119.04,149.46 118.34,148.76 116.52,148.76 116.28,148.53 113.86,148.53 113.71,148.37 101.67,148.37 101.1,147.81 87.17,147.81 86.53,147.16 81.13,147.16 80.25,148.04 76.95,148.04 74.41,150.58 71.26,150.58 70.59,151.26 69.59,151.26 69.3,150.97 61.28,150.97 60.82,151.44 58.05,151.44 57.94,151.55 57.94,151.75 v1(58.09,151.9)
MXM_EDP_TX3+_C: length 5.4
  TOP w0.102: JEDP1.26 54.74,155.57 55.23,155.08 55.73,155.08 55.74,155.07 56.36,155.07 v1(56.82,154.61) 57.01,154.42 57.81,154.42 58,154.23 58,154.05 C372.2
MXM_EDP_TX3-: length 189.9
  TOP w0.102: JMXM1.252 206.79,107.52 206.97,107.33 207.31,107.33 207.44,107.46 v1(207.44,107.59) ; C374.1 57.73,152.41 57.73,152.17 v1(57.46,151.9)
  IN4 w0.117: v1(57.46,151.9) 57.71,151.65 57.71,151.45 57.96,151.2 60.72,151.2 61.18,150.74 69.4,150.74 69.69,151.02 70.49,151.02 71.16,150.35 74.31,150.35 76.86,147.8 80.15,147.8 81.03,146.93 86.63,146.93 87.27,147.57 101.2,147.57 101.77,148.14 113.81,148.14 113.96,148.29 116.38,148.29 116.61,148.53 118.44,148.53 119.14,149.23 146.06,149.23 149.05,146.23 149.67,146.23 151.27,144.64 151.27,144.02 153.55,141.74 155.28,141.74 155.83,141.18 155.83,141.1 156.46,140.47 156.77,140.47 157.65,139.59 160.07,139.59 161.03,138.62 161.03,136.75 162.1,135.68 163.39,135.68 167.62,131.45 171.62,131.45 172.99,130.08 182.35,130.08 183.59,131.32 185.38,131.32 187.84,128.87 196.54,128.87 197.2,128.21 197.2,127.72 198.37,126.54 198.37,126.11 200.64,123.84 204.46,123.84 207,121.3 208.97,121.3 211.19,119.08 211.19,110.11 208.27,107.19 207.48,107.19 207.36,107.3 207.36,107.51 v1(207.44,107.59)
MXM_EDP_TX3-_C: length 5.5
  TOP w0.102: JEDP1.27 54.24,155.84 54.43,155.65 54.43,155.58 55.15,154.85 v1(55.42,154.85) 56.25,154.85 56.89,154.2 57.72,154.2 57.78,154.14 57.78,154 C374.2
MXM_ENVDD: length 149
  TOP w0.102: v1(67.41,145.61) 67.41,145.58 67.8,145.19 73.56,145.19 79.36,150.99 90.04,150.99 v2(93.85,147.18) v1(94.8,146.23) ; v1(195.9,157.29) 195.9,157.33 196.34,157.77 JMXM1.59
  IN2 w0.127: v1(184.86,146.85) 184.49,147.22 181.14,147.22 180.57,146.65 178.65,146.65 178.09,147.21 174.73,147.21 174.29,146.77 170.11,146.77 170.1,146.76 169.9,146.76 168.64,145.5 166,145.5 165.87,145.38 161.92,145.38 161.22,146.08 158.25,146.08 157.73,146.6 145.71,146.6 144.23,145.12 136.98,145.12 136.7,145.4 130.18,145.4 128.52,147.07 123.8,147.07 123.13,147.74 117.82,147.74 117.12,147.04 117.12,146.53 116.26,145.67 104.14,145.67 102.89,146.91 95.49,146.91 v1(94.8,146.23)
  IN3 w0.127: v1(185.69,152.67) 185.69,147.68 v1(184.86,146.85)
  IN4 w0.109: v1(185.69,152.67) 189.76,156.74 195.35,156.74 v1(195.9,157.29)
  BOTTOM w0.102: v1(67.41,145.61) 66.95,145.15 D6.3
MXM_LVDS_A0+: length 202.5
  TOP w0.102: v1(203.3,114.17) 203.47,114.01 203.47,113.75 204.1,113.12 205.01,113.12 205.11,113.02 JMXM1.230 ; v1(77.8,124.91) 78.01,124.91 78.09,124.83 78.09,124.6 77.96,124.48 77.35,124.48 76.73,125.1 71.77,125.1 v1(69.72,127.14) 67.87,128.99 67.87,130.86 67.15,131.58 67.15,131.71 67.53,132.09 67.63,132.09 67.8,131.92 U11.18
  IN4 w0.117: v1(203.3,114.17) 203.57,114.17 203.67,114.07 203.67,113.86 203.53,113.73 202.43,113.73 201.11,115.05 196.78,115.05 196.34,114.62 196.34,112.95 196.21,112.82 195.73,112.82 195.62,112.94 195.62,114.72 195.32,115.02 194.76,115.02 194.46,114.72 194.46,112.94 194.35,112.82 194,112.82 193.88,112.94 193.88,114.49 193.6,114.78 193.01,114.78 192.73,114.49 192.73,112.94 192.61,112.82 192.26,112.82 192.14,112.94 192.14,114.24 191.85,114.53 191.28,114.53 190.99,114.24 190.99,112.94 190.87,112.82 185.79,112.82 185.66,112.95 185.66,118.81 184.97,119.5 180.63,119.5 178.17,121.97 169.36,121.97 167.31,124.02 163,124.02 152.92,134.1 148.75,134.1 146.75,136.11 133.8,136.11 133.52,135.82 133.52,135.22 133.39,135.09 133.06,135.09 132.93,135.22 132.93,135.82 132.64,136.11 132.01,136.11 131.72,135.82 131.72,134.99 131.59,134.87 129.73,134.87 129.62,134.98 129.62,135.97 129.32,136.26 128.76,136.26 128.46,135.97 128.46,134.98 128.35,134.87 128,134.87 127.88,134.98 127.88,135.97 127.59,136.26 127.02,136.26 126.73,135.97 126.73,134.98 126.61,134.87 126.26,134.87 126.14,134.98 126.14,135.97 125.85,136.26 125.28,136.26 124.99,135.97 124.99,134.98 124.87,134.87 124.3,134.87 124.18,134.98 124.18,135.98 123.9,136.26 123.31,136.26 123.03,135.98 123.03,134.98 122.91,134.87 122.56,134.87 122.44,134.98 122.44,135.92 122.15,136.21 121.58,136.21 121.29,135.92 121.29,134.98 121.17,134.87 120.82,134.87 120.71,134.98 120.71,135.89 120.41,136.19 119.85,136.19 119.55,135.89 119.55,135.19 119.43,135.07 119.06,135.07 118.93,135.19 118.93,135.75 118.59,136.09 118.07,136.09 115.92,138.25 103.65,138.25 103.28,137.88 98.84,137.88 95.89,134.93 91.31,134.93 89.91,136.32 87.49,136.32 87.17,136 85.41,136 85,136.42 82.37,136.42 81.96,136.02 81.96,134.51 80.98,133.53 80.98,127.04 79.64,125.7 79.4,125.7 78.22,124.51 77.95,124.51 77.8,124.66 v1(77.8,124.91)
