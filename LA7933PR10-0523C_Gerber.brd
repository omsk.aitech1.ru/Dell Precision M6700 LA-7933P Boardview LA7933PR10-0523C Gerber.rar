# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCC_GFXCORE on VCC (solid shape): 62.68,96.58 62.71,96.57 62.73,96.54 63.1,96.22 63.48,96.52 63.48,96.54 63.53,96.58 64.74,96.58 64.79,96.56 64.79,96.55 65.11,96.38 65.43,96.55 65.44,96.56 65.48,96.58 98.93,96.58 99.15,96.37 99.16,96.33 99.15,96.29 91.92,89.07 91.92,88 85.11,81.19 85.09,81.18 85.06,81.18 84.68,81.1 84.59,80.71 84.59,80.7 84.59,80.67 82.75,78.83 82.75,78.76 81.63,77.64 81.63,69.38 81.56,69.31 81.53,69.3 81.52,69.31 81.17,69.21 81.07,68.86 81.08,68.84 81.07,68.82 80.89,68.64 64.57,68.64 64.53,68.65 64.52,68.68 64.29,68.95 63.94,68.92 63.92,68.91 63.89,68.91 63.87,68.92 54.37,78.42 48.34,78.42 47.85,78.91 47.85,91.4 48.72,92.27 50.75,92.27 55.07,96.58
+VCC_GFXCORE on IN2 (solid shape): outline of 5138 points within 45.57,66.74 85.7,91.25
+VCC_PWR_SRC on TOP (solid shape): 37.02,92.42 37.02,88.34 36.93,88.25 35.15,88.25 35.03,88.38 35.03,92.06 35.95,92.99 36.45,92.99
+VCC_PWR_SRC on TOP (solid shape): 37.06,84.23 37.06,82.66 36.8,82.41 34.43,82.41 34.14,82.7 34.14,84.02 34.34,84.23 35.95,84.23 36.27,84.54 36.74,84.54
+VCC_PWR_SRC on TOP (solid shape): 37.11,78.19 37.11,76.07 36.94,75.9 35.83,75.9 35.62,75.69 34.52,75.69 34.28,75.93 34.26,75.93 34.26,77.36 34.36,77.46 36,77.46 36.08,77.53 36.08,78.22 36.28,78.42 36.88,78.42
+VCC_PWR_SRC on TOP (solid shape): outline of 336 points within 19.57,39.98 48.93,72.57
+VCC_PWR_SRC on BOTTOM (solid shape): outline of 1477 points within 29.5,46.21 50.39,91.12
+VCC_SA on TOP (solid shape): 61.45,41 61.45,38.46 61.24,38.24 57.75,38.24 57.31,38.67 57.31,41.19 57.54,41.42 61.03,41.42
+VCC_SA on BOTTOM (solid shape): 45.38,36.47 45.38,32.24 44.74,31.61 43.46,31.61 41.06,34.01 41.06,34.37 41.6,34.37 41.6,35.15 41.06,35.15 41.06,35.58 41.6,35.58 41.6,36.34 41.06,36.34 41.06,36.84 41.12,36.9 44.95,36.9
+VCC_SA on BOTTOM (solid shape): outline of 2832 points within 58.14,38.48 79.09,53.4
+VCC_SA on VCC (solid shape): outline of 448 points within 44.04,20.13 77.06,53.66
+VCC_SA on IN2 (solid shape): outline of 4918 points within 42.14,29.65 76.05,52.52
+VCCDFTERM on BOTTOM (solid shape): 30.68,97.93 30.69,97.89 30.68,97.88 30.75,97.41 31.22,97.37 31.25,97.36 31.33,97.28 31.33,96.25 30.95,95.87 28.57,95.87 28.54,95.91 28.54,96.39 28.5,96.43 28.09,96.43 28.05,96.39 28.05,95.91 28.01,95.87 27.76,95.87 27.54,96.09 27.54,97.3 28.23,97.98 30.63,97.98
+VCCSA_BT on BOTTOM (solid shape): 46.91,20.94 46.91,19.36 47.03,19.24 47.8,19.24 47.84,19.23 47.85,19.19 47.85,19.04 47.84,19 47.8,18.99 46.46,18.99 46.33,19.11 46.33,20.38 46.07,20.64 45.06,20.64 44.93,20.77 44.93,21.65 45.06,21.78 46.07,21.78
+VCCSA_BT_1 on BOTTOM (solid shape): 46.2,20.26 46.2,19.06 46.2,19.06 46.2,18.23 46.07,18.1 45.06,18.1 44.93,18.23 44.93,20.26 45.06,20.38 46.07,20.38
+VCCSA_P on BOTTOM (solid shape): 40.88,36.82 40.88,33.66 43.43,31.11 45.84,31.11 46.25,30.69 46.25,28.74 46.57,28.42 47.01,28.42 47.29,28.15 47.29,26.95 47.22,26.88 45.5,26.88 45.44,26.94 45.44,28.31 44.95,28.8 43.31,28.8 43.15,28.65 43.15,26.75 43.15,26.12 43.15,26.06 43.15,24.85 43.15,21.6 42.96,21.4 39.45,21.4 39.34,21.5 39.34,24.26 39.46,24.37 39.47,24.37 39.64,24.47 39.74,24.64 39.74,24.65 40.17,25.09 40.17,32.54 39.51,33.2 39.51,36.6 39.77,36.86 40.84,36.86
+VCCSA_PHASE on BOTTOM (solid shape): 47.98,18.61 47.98,16.57 46.42,15.01 45.71,15.01 44.99,14.3 44.42,14.3 43.31,13.19 41.87,13.19 41.66,13.4 41.63,13.41 41.47,13.64 41.23,13.7 41.15,13.73 41.12,13.81 41.12,15.43 40.87,15.69 39.22,15.69 38.96,15.94 38.96,17.84 39.34,18.23 42.9,18.23 43.28,17.84 46.07,17.84 46.46,18.23 46.46,18.61 46.58,18.73 47.85,18.73
+VCCSA_PWR_SRC on BOTTOM (solid shape): 58.77,17.46 58.77,14.8 58.39,14.42 57.25,14.42 57.25,13.96 57.24,13.92 57.2,13.91 56.92,13.91 56.88,13.92 56.87,13.96 56.87,14.42 56.11,14.42 56.11,13.96 56.09,13.92 56.06,13.91 55.78,13.91 55.74,13.92 55.73,13.96 55.73,14.42 54.84,14.42 54.08,15.18 52.04,15.18 50.9,16.32 50.9,17.67 50.91,17.7 50.95,17.72 58.52,17.72
GND on TOP (solid shape): 203.39,21.03 193.39,21.03 193.39,31.03 203.39,31.03
GND on TOP (solid shape): 272.99,82.13 265.89,82.13 265.89,87.85 268.3,89.09 271.04,90.87 272.72,92.13 272.99,92.13
GND on TOP (solid shape): 6.78,153.81 6.78,152.62 6.55,152.39 2.77,152.39 2.49,152.67 2.49,153.98 2.58,154.06 6.53,154.06
GND on TOP (solid shape): 11.26,59.96 11.26,58.59 10.9,58.22 3.53,58.22 3.06,58.69 3.06,60.2 3.2,60.34 10.88,60.34
GND on TOP (solid shape): 25.56,166.71 25.56,163.47 25.33,163.25 23.25,163.25 23.02,163.47 23.02,166.9 23.28,167.16 25.12,167.16
GND on TOP (solid shape): 41.12,78.6 41.12,67.93 40.61,67.42 37.63,67.42 37.31,67.74 37.31,78.6 37.57,78.85 40.87,78.85
GND on TOP (solid shape): 50.01,42.1 50.01,40.39 49.57,39.95 46.54,39.95 46.07,40.41 46.07,42.61 46.2,42.74 49.38,42.74
GND on TOP (solid shape): 91.1,139.44 91.1,137.15 90.78,136.83 87.53,136.83 87.25,137.11 87.25,139.5 87.39,139.64 90.9,139.64
GND on TOP (solid shape): 91.34,134.57 91.34,132.23 90.56,131.46 87.77,131.46 87.27,131.95 87.27,134.82 87.54,135.09 90.82,135.09
GND on TOP (solid shape): 93.06,88.84 93.06,85.79 92.81,85.54 89.76,85.54 89,86.3 89,88.96 89.25,89.22 92.68,89.22
GND on TOP (solid shape): 176.25,65.72 176.25,64.33 176.12,64.2 173.33,64.2 173.2,64.33 173.2,65.72 173.33,65.85 176.12,65.85
GND on TOP (solid shape): 192.12,29.66 192.12,22.54 191.87,22.29 190.47,22.29 190.09,22.67 190.09,29.53 190.35,29.78 192,29.78
GND on TOP (solid shape): 56.11,41.07 56.11,38.93 55.51,38.33 51.32,38.33 51.04,38.61 51.04,41.16 51.29,41.42 55.76,41.42
GND on TOP (solid shape): 121.77,38.09 121.77,37.49 121.47,37.2 120.34,37.2 119.57,36.42 116.72,36.42 116.53,36.61 116.53,38.28 116.71,38.46 121.4,38.46
GND on TOP (solid shape): 204.34,178.84 204.34,175.58 204.29,175.53 196.87,175.53 196.61,175.79 196.61,178.77 196.75,178.91 204.28,178.91
GND on TOP (solid shape): 21.44,66.13 21.44,63.79 19.39,61.74 16.62,61.74 16.17,62.19 16.17,63.43 16.17,63.44 16.17,64.34 18.43,66.61 20.96,66.61
GND on TOP (solid shape): 118.07,157.25 118.07,154.67 117.99,154.6 117.54,154.6 116.55,155.59 115.14,155.59 114.84,155.88 114.84,156.95 114.98,157.09 117.17,157.09 117.4,157.32 118.01,157.32
GND on TOP (solid shape): 118.68,28.02 118.68,23.79 119.89,22.58 119.89,7.96 111.89,7.96 111.89,21.09 116.18,25.38 116.18,27.81 116.53,28.17 118.53,28.17
GND on TOP (solid shape): 127.1,45.28 127.1,38.95 126.77,38.62 121.87,38.62 121.25,39.24 121.25,43.07 121.44,43.26 124.2,43.26 126.34,45.4 126.97,45.4
GND on TOP (solid shape): 209.4,5.14 209.4,1.97 208.76,1.33 202.92,1.33 202.67,1.59 202.67,2.86 201.9,3.62 201.9,5.14 202.16,5.4 209.14,5.4
GND on TOP (solid shape): 23.43,24.32 25.12,24.32 26.26,23.18 26.26,20.51 25.88,20.13 23.47,20.13 23.21,20.38 23.21,24.19 23.34,24.32
GND on TOP (solid shape): 29.97,63.43 30.44,63.43 30.61,63.61 31.03,63.61 31.2,63.44 31.2,62.72 28.87,60.39 27.38,60.39 26.98,60.79 26.98,63.25 27.39,63.65 29.75,63.65
GND on TOP (solid shape): 41.12,66.79 41.12,56.2 40.49,55.56 37.95,55.56 37.44,56.07 37.44,61.91 37.18,62.17 37.18,66.91 37.44,67.17 40.74,67.17
GND on TOP (solid shape): 51.79,53.2 51.79,49.77 51.54,49.52 40.74,49.52 40.36,49.9 40.36,50.6 40.07,50.89 38.73,50.89 38.56,51.06 38.56,53.08 38.81,53.33 51.66,53.33
GND on TOP (solid shape): 116.86,69.58 116.86,69.13 116.71,68.97 116.71,67.78 116.51,67.58 113.61,67.58 113.13,68.06 113.13,69.55 113.45,69.86 114.87,69.86 114.88,69.87 116.58,69.87
GND on TOP (solid shape): 124.8,102.64 124.8,102.01 124.5,101.7 124.5,100.66 124.55,100.61 124.55,100.23 124.39,100.08 122.85,100.08 122.53,100.39 122.53,102.25 122.64,102.36 123.63,102.36 124,102.73 124.71,102.73
GND on TOP (solid shape): 124.83,75.27 124.83,73.6 122.22,70.99 121.09,70.99 120.19,71.9 117.97,71.9 117.4,72.47 117.4,74.07 117.77,74.44 117.77,75.5 117.98,75.72 124.38,75.72
GND on TOP (solid shape): 14.02,70.92 14.02,68.97 14.74,68.25 14.74,66.69 14.15,66.09 13.12,66.09 12.27,66.94 5.32,66.94 5.21,67.06 5.21,72.26 5.23,72.29 12.65,72.29
GND on TOP (solid shape): 78.9,145.5 78.9,142.78 78.81,142.69 77.19,142.69 77.06,142.81 77.06,144.81 77.26,145 77.6,145 78.25,145.66 78.74,145.66
GND on TOP (solid shape): 117.97,54.19 117.97,53.33 115.72,51.08 114.31,51.08 112.02,48.79 108.49,48.79 107.65,49.63 107.65,51.06 107.96,51.37 109.96,51.37 112.72,54.14 117.22,54.14 117.33,54.25 117.91,54.25
GND on TOP (solid shape): 197.1,51.85 197.1,50.69 196.14,49.72 195.46,49.72 195.25,49.51 195.25,48.81 195.15,48.71 193.72,48.71 193.72,48.7 193.58,48.7 192.42,49.85 192.42,51.29 193.27,52.13 196.82,52.13
GND on TOP (solid shape): 280.93,6.41 280.93,5.72 281.1,5.55 281.74,5.55 281.91,5.37 281.91,3.42 281.52,3.02 279.95,3.02 278.99,3.98 276.59,3.98 276.38,4.19 276.38,6.4 276.55,6.57 280.77,6.57
GND on TOP (solid shape): 10.5,78.31 10.5,77.44 10.4,77.34 9.88,77.34 9.82,77.28 8.1,77.28 7.97,77.15 7.97,75.59 7.85,75.47 5.31,75.47 5.18,75.6 5.18,77.48 5.18,77.48 5.18,77.92 5.69,78.42 9.8,78.42 9.81,78.42 10.38,78.42
GND on TOP (solid shape): 127.94,70.08 127.94,67.17 125.8,65.03 125.1,65.03 122.31,62.24 113.66,62.24 113.1,62.8 113.1,64.3 113.56,64.75 120.15,64.75 120.15,64.76 121.56,64.76 122.95,66.14 122.95,69.6 123.49,70.14 127.87,70.14
GND on TOP (solid shape): 219.22,102.42 219.25,102.38 220.73,100 221.24,99.26 223.49,96.48 225.19,94.7 226.13,93.82 226.72,93.28 226.95,93.08 226.97,93.05 226.72,93.05 226.72,93.05 207.78,93.05 207.78,103.05 218.87,103.05
GND on TOP (solid shape): 172.06,37.02 172.19,36.89 172.19,36.13 172.06,36.01 171.68,36.01 171.68,35.95 171.67,35.95 171.67,35.55 171.65,35.51 171.62,35.5 171.49,35.5 171.45,35.51 171.43,35.55 171.43,35.95 171.42,35.95 171.42,36.01 171.04,36.01 170.92,36.13 170.92,36.89 171.04,37.02 171.74,37.02
GND on TOP (solid shape): 30.39,88.65 30.39,87.12 30.14,86.87 28.48,86.87 28.42,86.93 28.42,87.25 28.48,87.31 29.37,87.31 29.5,87.44 29.51,87.63 29.5,87.76 29.5,88.01 29.51,88.02 29.51,88.24 29.5,88.26 29.5,88.5 29.51,88.6 29.52,88.66 29.56,88.71 30.33,88.71
GND on TOP (solid shape): 63.92,157.01 63.92,155.11 63.08,154.28 63.08,154.25 63.04,154.2 63.04,151.64 62.84,151.44 61.92,151.44 61.61,151.76 61.61,153.16 61.56,153.21 60.48,153.21 60.07,153.61 60.07,155.55 60.11,155.59 60.12,155.6 60.14,155.6 60.79,155.6 60.82,155.62 60.95,155.65 61.07,155.62 61.1,155.6 61.37,155.6 61.42,155.66 61.61,155.66 61.62,155.66 61.74,155.63 61.86,155.66 61.87,155.66 61.97,155.66 62.14,155.83 62.14,157.01 62.24,157.11 63.82,157.11
GND on TOP (solid shape): 295.29,10.6 294.58,10.31 294.29,9.6 294.29,3.95 294,3.24 293.29,2.95 283.93,2.95 283.29,3.58 283.29,10.41 283.49,10.6
GND on TOP (solid shape): 299.73,169.97 299.74,169.83 299.74,169.7 298.68,167.3 296.19,166.46 293.26,166.46 293.26,169.36 293.24,169.65 293.25,169.94 293.25,172.94 293.24,172.96 293.29,173.09 293.34,173.19 293.57,173.47 293.93,173.65 294.23,173.67 299.73,173.67
GND on TOP (solid shape): 69.97,152.32 70.03,152.27 70.52,151.78 70.52,150.12 70.5,150.1 70.47,150.05 70.46,149.99 70.45,149.94 70.44,149.88 70.45,149.82 70.47,149.76 70.49,149.71 70.52,149.67 70.52,149.61 70.32,149.42 67.69,149.42 66.99,150.11 66.99,150.27 67.26,150.27 67.26,150.21 67.27,150.16 67.29,150.1 67.32,150.06 67.35,150.01 67.39,149.97 67.44,149.94 67.49,149.92 67.54,149.9 67.6,149.89 67.65,149.89 67.71,149.89 67.76,149.91 67.81,149.93 67.86,149.96 67.9,149.99 67.94,150.03 67.97,150.08 68,150.13 68.01,150.18 68.02,150.24 68.02,150.29 68.01,150.35 68,150.4 67.97,150.45 67.94,150.5 67.9,150.54 67.86,150.58 67.81,150.61 67.76,150.63 67.71,150.64 67.65,150.65 67.6,150.65 67.54,150.64 67.49,150.62 67.44,150.59 67.39,150.56 67.35,150.52 67.32,150.48 67.29,150.43 67.27,150.38 67.26,150.32 67.26,150.27 66.99,150.27 66.99,152.63 67.33,152.96 69.33,152.96
GND on TOP (solid shape): 176.9,75.57 176.93,75.55 176.95,75.51 176.95,74.42 177.07,74.3 178.92,74.3 178.98,74.23 178.98,72.39 179.04,72.33 180.2,72.33 180.23,72.31 180.25,72.28 180.25,72.12 180.23,72.09 180.2,72.07 179.11,72.07 178.98,71.95 178.98,70.17 178.92,70.1 177.14,70.1 176.95,69.91 176.95,68.82 176.93,68.79 176.9,68.77 176.81,68.77 176.77,68.79 176.76,68.82 176.76,69.91 176.57,70.1 174.85,70.1 174.79,70.17 174.79,71.95 174.66,72.07 173.51,72.07 173.47,72.09 173.46,72.12 173.46,72.21 173.47,72.25 173.51,72.26 174.53,72.26 174.73,72.45 174.73,74.23 174.79,74.3 176.69,74.3 176.76,74.36 176.76,75.51 176.77,75.55 176.81,75.57
GND on TOP (solid shape): outline of 85 points within 37.31,79.36 41.12,92.99
GND on TOP (solid shape): outline of 95 points within 65.11,62.21 75.14,63.19
GND on TOP (solid shape): outline of 102 points within 65.12,59.19 75.15,60.15
GND on TOP (solid shape): outline of 102 points within 65.11,65.2 75.14,66.17
GND on TOP (solid shape): 34.68,115.1 34.72,115.08 34.85,115 35,114.97 35.07,114.94 35.11,114.87 35.11,114.81 35.09,114.73 35.02,114.69 34.78,114.55 34.7,114.28 34.7,114.27 34.69,114.25 34.55,114.11 34.54,114.11 34.44,113.99 34.42,113.83 34.4,113.75 34.32,113.72 34.09,113.66 33.94,113.48 33.87,113.42 33.78,113.44 33.65,113.57 33.65,113.58 33.56,113.72 33.4,113.78 33.33,113.82 33.31,113.89 33.31,113.93 33.43,114.04 33.44,114.04 33.59,114.13 33.66,114.28 33.66,114.3 33.93,114.57 33.95,114.58 33.97,114.59 34.2,114.65 34.29,114.87 34.32,114.94 34.39,114.97 34.53,115 34.65,115.08
GND on TOP (solid shape): 19.44,106.23 19.51,106.2 19.68,106.12 19.86,106.12 19.94,106.11 19.99,106.05 20.02,105.96 20.09,105.89 20.1,105.88 20.11,105.85 20.34,105.62 20.34,105.61 20.41,105.49 20.51,105.41 20.56,105.34 20.54,105.25 20.48,105.11 20.5,104.96 20.5,104.88 20.43,104.82 20.34,104.79 20.27,104.73 20.19,104.69 19.89,104.83 19.59,104.69 19.51,104.73 19.41,104.8 19.28,104.83 19.25,104.84 19.13,104.96 19.12,104.99 19.06,105.18 18.85,105.3 18.84,105.33 18.84,105.65 18.85,105.68 18.87,105.7 18.99,105.81 19.03,105.97 19.05,106.05 19.12,106.08 19.26,106.12 19.37,106.2
GND on TOP (solid shape): 20.25,127.97 20.27,127.96 20.29,127.95 20.47,127.87 20.69,127.93 20.72,127.92 21,127.64 21,127.41 21,127.4 21.04,127.09 21.33,127.01 21.42,126.99 21.47,126.91 21.49,126.82 21.53,126.75 21.56,126.67 21.52,126.6 21.43,126.48 21.4,126.33 21.36,126.25 21.28,126.23 21.22,126.23 21.2,126.23 21.18,126.24 21.07,126.35 21.07,126.37 20.89,126.61 20.59,126.64 20.55,126.64 20.52,126.67 20.41,126.82 20.22,126.86 20.17,126.88 20.16,126.92 20.16,126.95 20.18,126.99 20.22,126.99 20.54,127.27 20.22,127.55 20.19,127.55 20.17,127.56 20.1,127.64 20.1,127.66 20.08,127.76 20.04,127.85 20.03,127.89 20.05,127.92 20.11,127.96 20.12,127.97
GND on TOP (solid shape): 206.29,179 206.85,178.76 207.44,177.35 208.29,177 213.34,177 213.81,176.84 214.1,176.45 214.13,176.32 214.14,176.2 214.14,172.2 213.94,171.68 213.45,171.41 211.19,171.41 210.98,171.62 210.98,175.79 210.46,176.31 194.05,176.31 193.91,176.17 153.92,176.17 153.9,176.18 153.88,176.19 153.66,176.3 153.44,176.19 153.42,176.18 153.4,176.17 143.32,176.17 141.18,174.04 141.18,169.33 138.89,167.03 134.55,167.03 133.06,168.53 133.06,175.04 131.93,176.17 125,176.17 124.92,176.21 124.9,176.29 125.16,176.79 125.69,177 192.49,177 193.34,177.35 193.93,178.76 194.49,179
GND on TOP (solid shape): outline of 164 points within 1.04,160.03 49.93,178.18
GND on TOP (solid shape): outline of 166 points within 10.26,145.61 18.64,149.54
GND on TOP (solid shape): 201.01,93.74 201.09,93.7 201.1,93.61 201.47,93.13 201.84,93.61 201.86,93.7 201.94,93.74 202.2,93.74 202.22,93.74 202.24,93.72 202.41,93.58 202.61,93.48 202.68,93.38 202.6,93.28 202.28,91.41 203.94,92.32 204,92.42 204.12,92.4 204.3,92.22 204.3,87.71 204.24,87.64 199.25,87.64 199.12,87.77 199.12,90.89 199.24,91.01 200.09,91.01 200.34,91.26 200.34,91.33 200.45,91.43 200.47,91.44 200.48,91.44 200.95,91.78 200.54,92.19 200.47,92.21 200.43,92.27 200.4,92.37 200.34,92.45 200.34,93.2 200.35,93.23 200.36,93.24 200.49,93.41 200.51,93.62 200.54,93.7 200.61,93.74
GND on TOP (solid shape): outline of 104 points within 65.1,56.2 75.13,57.19
GND on TOP (solid shape): outline of 221 points within 196.19,159.07 206.86,168.09
GND on TOP (solid shape): outline of 237 points within 1.12,121.1 8.74,136.13
GND on TOP (solid shape): outline of 97 points within 24.15,116.11 26.99,120.66
GND on TOP (solid shape): outline of 179 points within 65.1,53.21 75.15,54.17
GND on TOP (solid shape): outline of 295 points within 81.25,51.25 87.73,65.47
GND on TOP (solid shape): outline of 287 points within 73.51,68.15 77.19,88.46
GND on TOP (solid shape): outline of 105 points within 21.95,126 25.89,127.97
GND on TOP (solid shape): outline of 1340 points within 17.47,110.64 25.28,119.11
GND on TOP (solid shape): outline of 11807 points within 17.96,103.66 42.33,127.97
GND on BOTTOM (solid shape): 213.52,2.35 212.76,1.59 210.92,1.59 210.92,9.84 213.52,9.84
GND on BOTTOM (solid shape): 96.67,173.58 96.67,168.92 96.34,168.59 95.38,168.59 95.08,168.89 95.08,173.62 95.15,173.69 96.56,173.69
GND on BOTTOM (solid shape): 101.19,13.91 101.19,12.38 100.94,12.13 97.51,12.13 97.26,12.38 97.26,14.03 97.38,14.16 100.94,14.16
GND on BOTTOM (solid shape): 213.78,36.39 213.78,34.25 213.7,34.18 212.72,34.18 212.52,34.38 212.52,36.35 212.69,36.51 213.65,36.51
GND on BOTTOM (solid shape): 26.39,24.7 26.39,20.64 26.01,20.26 23.21,20.26 23.09,20.38 23.09,24.96 23.21,25.08 26.01,25.08
GND on BOTTOM (solid shape): 80.47,173.43 80.47,168.87 80.19,168.59 79.11,168.59 78.81,168.89 78.81,173.65 78.9,173.74 80.16,173.74
GND on BOTTOM (solid shape): 96.62,17.84 96.62,14.27 96.62,13.91 96.11,13.4 78.71,13.4 78.46,13.65 78.46,17.97 78.71,18.23 96.24,18.23
GND on BOTTOM (solid shape): 191.74,47.56 199.36,47.56 199.62,47.31 199.62,45.66 199.49,45.53 190.22,45.53 189.97,45.78 189.97,47.56 190.22,47.82 191.49,47.82
GND on BOTTOM (solid shape): 197.97,72.24 197.97,69.53 197.89,69.46 189.85,69.46 189.71,69.6 189.71,73.34 189.97,73.6 196.61,73.6
GND on BOTTOM (solid shape): 221.84,59.5 221.84,55.31 221.59,55.06 217.94,55.06 217.74,55.26 217.74,59.21 218.41,59.88 221.46,59.88
GND on BOTTOM (solid shape): 277.21,56.2 277.21,53.53 276.96,53.28 275.44,53.28 275.31,53.4 275.31,54.42 275.82,54.93 275.82,56.2 275.94,56.33 277.09,56.33
GND on BOTTOM (solid shape): 280.64,36.77 280.64,34.18 280.21,33.74 275.28,33.74 275.18,33.85 275.18,36.64 275.44,36.89 280.52,36.89
GND on BOTTOM (solid shape): 212.32,72.96 212.06,72.71 212.06,69.66 211.94,69.53 210.16,69.53 210.03,69.66 210.03,72.71 210.54,73.22 210.54,75.76 210.67,75.88 212.32,75.88
GND on BOTTOM (solid shape): 231.04,44.48 231.04,42.23 230.91,42.1 230.59,42.1 230.47,42.23 230.47,43.18 230.79,43.5 230.79,44.49 230.84,44.54 230.98,44.54
GND on BOTTOM (solid shape): 251.44,59.23 251.44,55.83 250.83,55.22 248.64,55.22 248,55.86 248,59.28 248.35,59.63 251.04,59.63
GND on BOTTOM (solid shape): 290.49,100.18 290.49,98.1 289.99,97.6 285.77,97.6 285.47,97.9 285.47,100.1 285.63,100.27 290.4,100.27
GND on BOTTOM (solid shape): 68.93,27.5 68.93,24.45 68.68,24.19 64.62,24.19 64.49,24.32 64.49,25.72 64.36,25.85 62.46,25.85 62.33,25.97 62.33,27.5 62.46,27.62 68.81,27.62
GND on BOTTOM (solid shape): 85.19,56.33 85.19,53.02 84.94,52.77 82.52,52.77 82.27,53.02 82.27,53.4 82.14,53.53 81.51,53.53 81.38,53.66 81.38,55.94 81.51,56.07 82.52,56.07 83.16,56.71 84.81,56.71
GND on BOTTOM (solid shape): 231.86,52.58 231.86,49.34 230.59,48.07 230.59,46.6 230.54,46.55 230.46,46.55 229.77,47.24 229.77,48.39 230.02,48.64 230.02,52.58 230.27,52.83 231.61,52.83
GND on BOTTOM (solid shape): 287.12,90.93 287.12,89.18 287.54,88.76 287.54,85.92 287.16,85.54 285.22,85.54 284.96,85.79 284.96,91.31 285.04,91.4 286.66,91.4
GND on BOTTOM (solid shape): 276.58,58.75 276.58,57.86 276.67,57.77 276.67,57.04 276.87,56.85 276.87,56.58 276.77,56.47 276.37,56.47 276.23,56.62 276.23,57.58 276.31,57.66 276.31,58.75 276.4,58.84 276.49,58.84
GND on BOTTOM (solid shape): 227.52,35.2 227.52,29.68 227.26,29.43 220.91,29.43 220.79,29.55 220.79,32.72 221.3,33.22 222.97,33.22 223.21,33.47 223.21,35.46 223.61,35.85 226.87,35.85
GND on BOTTOM (solid shape): 42.26,77.71 42.26,76.57 42.14,76.44 41.12,76.44 40.87,76.19 40.87,74.53 40.99,74.41 40.99,68.06 40.74,67.8 37.9,67.8 37.69,68.01 37.69,78.6 37.82,78.73 41.25,78.73
GND on BOTTOM (solid shape): 53.95,58.66 53.95,55.48 53.82,55.36 49.5,55.36 49.38,55.48 49.38,56.25 49.5,56.37 50.39,56.37 50.65,56.63 50.65,58.36 51.2,58.91 53.69,58.91
GND on BOTTOM (solid shape): 39.97,32.26 39.97,25.06 39.33,24.42 38.48,24.42 38.23,24.66 38.23,27.45 38.24,27.45 38.25,27.56 38.24,27.66 38.23,27.67 38.23,31.53 38.24,31.54 38.24,32.3 38.47,32.53 39.7,32.53
GND on BOTTOM (solid shape): 53.95,63.36 53.95,60.18 53.82,60.06 51.28,60.06 51.28,60.14 51.15,60.26 51.15,62.8 50.77,63.18 50.77,63.56 51.03,63.82 53.49,63.82
GND on BOTTOM (solid shape): 53.95,68.01 53.95,64.88 53.82,64.76 52.89,64.76 52.68,64.82 52.47,64.76 51.41,64.76 51.28,64.88 51.28,68.31 51.49,68.52 53.44,68.52
GND on BOTTOM (solid shape): 55.73,49.13 55.73,45.71 55.6,45.58 53.31,45.58 53.19,45.71 53.19,46.47 53.06,46.59 52.42,46.59 52.3,46.72 52.3,47.36 52.42,47.48 53.06,47.48 53.19,47.61 53.19,48.37 52.93,48.63 52.55,48.63 52.42,48.75 52.42,49.26 52.55,49.39 55.47,49.39
GND on BOTTOM (solid shape): 196.06,37.66 196.06,34.07 195.95,33.96 194.55,33.96 194.46,34.05 194.46,34.84 194.33,34.96 193.7,34.96 193.66,35 193.66,35.56 193.6,35.62 191.74,35.62 191.62,35.75 191.62,37.66 191.74,37.78 195.93,37.78
GND on BOTTOM (solid shape): 60.3,25.85 60.3,22.16 60.04,21.91 59.12,21.91 59.09,21.92 59.07,21.94 58.96,22.08 58.79,22.16 58.78,22.16 58.65,22.29 58.65,25.72 58.9,25.97 60.17,25.97
GND on BOTTOM (solid shape): 50.72,53.12 51.15,53.12 51.28,53 51.28,49.9 51.03,49.64 44.98,49.64 40.94,49.64 40.87,49.64 40.74,49.52 39.93,49.52 39.85,49.59 39.85,50.1 39.34,50.61 39.34,51.93 39.6,52.18 40.36,52.18 41.5,53.33 50.52,53.33
GND on BOTTOM (solid shape): 52.37,13.4 52.41,13.38 52.42,13.35 52.42,12.89 52.93,12.89 52.93,13.35 52.95,13.38 52.98,13.4 53.31,13.4 53.44,13.27 53.44,11.94 53.38,11.88 51.98,11.88 51.92,11.94 51.92,13.27 52.04,13.4
GND on BOTTOM (solid shape): 40.61,66.79 42.39,66.79 42.52,66.66 42.52,65.77 42.39,65.64 41.12,65.64 40.74,65.26 40.74,57.14 39.85,56.25 36.88,56.25 36.68,56.45 36.68,58.28 36.47,58.48 36.47,60.06 36.82,60.4 36.82,61.53 37.44,62.15 37.44,66.91 37.69,67.17 40.23,67.17
GND on BOTTOM (solid shape): 272.77,50.86 272.77,49.59 272.26,49.09 272.26,42.23 272.1,42.06 270.44,42.06 270.23,42.28 270.23,46.67 270.04,46.86 267.63,46.86 267.28,47.21 267.28,49.17 267.57,49.47 268.64,49.47 268.83,49.66 268.83,50.61 269.21,50.99 272.57,50.99 272.64,50.99
GND on BOTTOM (solid shape): 45.76,45.16 45.76,44.97 45.76,44.76 45.76,44.46 45.76,44.46 45.76,43.88 45.82,43.82 46.77,43.82 46.84,43.75 46.84,43.56 46.71,43.43 44.99,43.43 44.87,43.56 44.87,43.8 44.87,43.81 44.87,45.03 44.87,45.14 44.92,45.19 45.73,45.19
GND on BOTTOM (solid shape): 27.02,80.2 28.04,80.2 28.29,80.46 28.55,80.46 28.68,80.33 28.68,79.94 28.6,79.79 28.57,79.62 28.57,79.26 28.6,79.09 28.68,78.94 28.68,78.3 28.55,78.17 27.79,78.17 27.66,78.04 27.66,77.41 27.53,77.28 24.87,77.28 24.36,77.79 24.36,80.84 24.48,80.96 26.26,80.96
GND on BOTTOM (solid shape): 38.56,91.02 39.71,91.02 40.23,90.49 40.23,89.9 40.51,89.62 40.55,89.58 40.59,89.55 40.87,89.27 40.87,83.17 40.99,83.04 42.01,83.04 42.26,82.79 42.26,80.96 42.09,80.79 41.29,80.79 41.04,80.54 41.04,79.13 40.89,78.98 37.69,78.98 37.31,79.36 37.31,82.16 37.31,82.16 37.31,85.33 37.57,85.58 37.57,90.49 38.1,91.02 38.56,91.02
GND on BOTTOM (solid shape): 65.63,21.54 65.63,20.45 65.15,19.96 65.15,19.42 65.33,19.24 67.28,19.24 67.41,19.11 67.41,17.46 67.16,17.21 65.76,17.21 65.51,17.46 61.95,17.46 61.82,17.34 60.04,17.34 59.79,17.59 59.79,19.56 59.8,19.56 60.01,19.76 63.43,19.76 64.24,20.56 64.24,21.62 64.35,21.73 65.44,21.73
GND on BOTTOM (solid shape): 231.4,47.47 231.4,46.5 231.52,46.38 232.14,46.38 232.18,46.34 232.18,46.31 232.18,45.94 232.18,45.91 232.18,45.54 232.18,45.51 232.18,45.14 232.18,45.11 232.18,44.78 232.09,44.69 230.53,44.69 230.45,44.77 230.45,46.34 230.47,46.36 231.1,46.36 231.19,46.45 231.19,47.49 231.23,47.53 231.35,47.53
GND on BOTTOM (solid shape): 54.58,19.24 55.22,19.24 55.98,20 56.86,20 58.52,20 58.65,19.88 58.65,18.1 58.52,17.97 50.77,17.97 50.65,17.84 50.65,16.62 50.63,16.59 50.6,16.57 48.23,16.57 48.11,16.7 48.11,18.66 48.11,18.66 48.11,19.06 48.12,19.1 48.16,19.11 50.77,19.11 51.66,20 53.82,20
GND on BOTTOM (solid shape): 277.09,51.12 277.09,50.05 277.09,50.05 277.09,49.85 276.83,49.59 274.17,49.59 273.91,49.34 273.91,48.2 273.98,48.13 276.01,48.13 276.16,47.98 276.16,45.38 276.33,45.21 276.33,44.45 276.05,44.17 275.21,44.17 274.95,43.92 272.63,43.92 272.52,44.03 272.52,48.83 273.02,49.34 273.02,51.25 273.15,51.37 276.83,51.37
GND on BOTTOM (solid shape): 55.73,53.83 55.73,50.66 55.6,50.53 53.19,50.53 53.06,50.66 53.06,52.06 52.42,52.69 52.42,53.66 52.6,53.83 52.62,53.84 52.63,53.84 52.85,53.88 53.02,54.04 53.03,54.06 53.06,54.06 53.29,54.06 53.31,54.09 55.47,54.09
GND on BOTTOM (solid shape): 106.86,20.64 106.89,20.62 106.91,20.59 106.91,18.03 106.91,17.72 106.65,17.46 105.89,17.46 105.38,16.96 105.38,14.42 105.13,14.16 103.86,14.16 103.73,14.29 103.73,17.84 103.95,18.06 104.28,18.06 104.49,17.84 105,17.84 105.13,17.97 105.13,18.68 105.13,19.44 105.13,20.59 105.14,20.62 105.18,20.64
GND on BOTTOM (solid shape): 45.19,28.05 45.19,26.73 45.31,26.61 47.34,26.61 47.47,26.48 47.47,25.34 47.34,25.21 45.99,25.21 44.96,24.18 43.54,24.18 43.28,24.44 43.28,24.84 43.28,26.08 43.28,26.11 43.28,26.72 43.28,27.42 43.28,27.42 43.28,28.22 43.56,28.49 44.74,28.49
GND on BOTTOM (solid shape): 21.74,128.39 21.8,128.48 21.91,128.47 22.08,128.39 22.27,128.4 22.36,128.39 22.4,128.31 22.4,127.75 23.04,127.12 23.04,126.17 22.99,126.08 22.89,126.08 22.78,126.11 22.66,126.11 22.63,126.11 22.61,126.13 22.39,126.35 22.39,127.62 21.74,128.27
GND on BOTTOM (solid shape): 39.96,131.48 40.05,131.42 40.03,131.32 39.94,131.05 40.05,130.79 40.3,130.55 40.3,130.05 39.34,129.1 39.34,128 39.33,127.96 39.29,127.95 38.63,127.95 38.42,128.16 38.42,128.35 38.44,128.42 38.44,128.49 38.44,131 38.4,131.17 38.29,131.3 38.26,131.42 38.36,131.48
GND on BOTTOM (solid shape): 296.14,173.68 296.34,173.7 296.54,173.7 300.46,173.67 300.45,170.24 300.48,169.97 300.49,169.7 299.16,166.72 296.06,165.72 296.06,165.72 293.22,165.72 293.22,172.91 293.85,173.67
GND on BOTTOM (solid shape): 22.9,106.05 22.95,105.99 22.99,105.92 23.04,105.86 23.06,105.85 23.06,105.82 23.06,105.32 22.97,105.22 22.39,105.22 22.39,104.46 22.7,104.46 22.79,104.4 22.77,104.29 22.7,104.18 22.67,104.06 22.64,103.99 22.57,103.96 21.98,103.96 21.95,103.98 21.93,104.01 21.93,104.38 22.01,104.46 22.26,104.46 22.26,105.22 21.79,105.22 21.7,105.28 21.72,105.39 21.77,105.45 22.02,105.45 22.6,106.03 22.63,106.04 22.64,106.04 22.73,106.03 22.82,106.05
GND on BOTTOM (solid shape): 3.09,166.18 6.17,165.17 7.49,162.2 7.02,160.32 5.72,158.88 5.51,158.88 5.51,158.75 4.38,158.3 3.17,158.21 3.17,158.2 0.02,158.2 0.02,166.18
GND on BOTTOM (solid shape): 26.49,8.03 30.03,6.57 31.49,3.03 31.49,0.2 29.69,0.2 29.69,3.03 28.76,5.29 26.49,6.23 23.79,6.23 23.79,8.03
GND on BOTTOM (solid shape): 33.26,107.03 33.26,105.38 33.24,105.33 33.23,105.28 33.23,104.01 33.22,103.98 33.18,103.96 32.65,103.96 32.03,104.59 29.95,104.59 29.86,104.63 29.86,104.73 29.89,104.81 29.91,104.9 29.92,104.92 29.94,104.94 30.14,104.94 30.23,105.02 30.97,105.02 31.39,105.44 31.39,105.87 31.43,105.95 31.52,105.97 31.95,106.11 31.92,106.56 31.9,106.63 31.93,106.7 32.03,106.95 31.94,107.21 31.92,107.32 32.01,107.38 32.91,107.38
GND on BOTTOM (solid shape): 16.11,126.17 16.16,126.25 16.25,126.26 16.29,126.25 16.34,126.25 16.36,126.25 16.37,126.24 18.59,124.02 18.65,124.02 19.27,123.4 19.28,123.38 19.28,123.36 19.28,123.24 19.32,123.12 19.31,123.02 19.23,122.98 18.36,122.98 17.93,123.41 17.92,123.43 17.92,123.44 17.85,123.66 17.64,123.75 17.62,123.76 17.6,123.77 17.49,123.88 17.46,123.97 17.52,124.04 17.68,124.63 17.07,124.63 17,124.59 16.92,124.62 16.11,125.43
GND on BOTTOM (solid shape): 28.37,131.48 28.41,131.47 28.42,131.43 28.42,131.26 28.9,131.26 28.94,131.25 28.95,131.21 28.95,129.46 28.96,129.42 28.98,129.37 28.98,128.88 26.97,126.87 26.97,126.75 26.93,126.67 26.84,126.65 26.73,126.67 26.62,126.66 26.53,126.67 26.49,126.76 26.49,127.3 27.2,128.01 27.2,128.43 27.24,128.51 27.33,128.53 27.82,128.83 27.45,129.27 27.42,129.29 27.41,129.32 27.41,131.21 27.42,131.25 27.46,131.26 28.17,131.26 28.17,131.43 28.18,131.47 28.22,131.48
GND on BOTTOM (solid shape): 17.62,115.55 17.71,115.52 19.43,113.8 19.45,113.8 19.49,113.78 19.5,113.75 19.5,113.73 19.49,113.71 19.48,113.7 19.31,113.51 19.29,113.26 19.29,113.23 19.28,113.21 18.55,112.48 17.72,112.48 17.69,112.48 17.68,112.48 17.66,112.5 17.65,112.53 17.65,113.13 17.61,113.13 17.57,113.15 17.56,113.18 17.56,113.21 17.57,113.24 17.61,113.26 17.61,114.02 17.57,114.04 17.56,114.07 17.56,114.13 17.57,114.17 17.61,114.19 17.61,114.95 16.79,114.95 16.77,114.92 16.56,114.92 16.4,114.76 16.17,114.76 16.13,114.77 16.11,114.81 16.11,115.32 16.12,115.35 16.14,115.36 16.17,115.39 16.24,115.42 16.31,115.39 16.56,115.29 16.88,115.4 16.95,115.38 17.28,115.28 17.55,115.49
GND on BOTTOM (solid shape): 19.98,125.72 20,125.71 20.01,125.7 20.15,125.62 20.3,125.63 20.32,125.63 20.35,125.63 20.6,125.38 20.6,124.72 20.56,124.64 20.47,124.62 20.07,124.51 20.01,124.11 20,124.01 19.91,123.97 19.49,123.97 18.34,125.12 18.32,125.22 18.4,125.29 18.44,125.3 18.47,125.31 18.57,125.3 18.62,125.22 18.86,124.89 19.26,124.97 19.33,125 19.4,124.98 19.98,125.06 19.79,125.62 19.76,125.64 19.76,125.67 19.76,125.69 19.79,125.72
GND on BOTTOM (solid shape): outline of 117 points within 6.58,140.15 14.58,144.91
GND on BOTTOM (solid shape): 30.4,131.48 30.44,131.47 30.45,131.43 30.45,131.26 30.97,131.26 31.06,131.2 31.04,131.09 30.94,130.98 30.43,130.98 29.79,130.35 29.79,125.58 28.95,124.74 28.43,124.74 28.2,124.51 28.11,124.48 28.04,124.53 27.74,124.73 27.41,124.6 27.34,124.56 27.26,124.59 26.73,125.12 26.71,125.21 26.76,125.28 26.94,125.46 26.98,125.7 26.98,125.72 26.98,125.74 27.04,125.8 27.15,125.82 27.21,125.73 27.21,125.7 27.29,125.62 27.29,125.6 27.95,125.39 27.67,126.02 27.6,126.05 27.57,126.12 27.57,126.63 29.58,128.63 29.58,131.18 29.66,131.26 30.2,131.26 30.2,131.43 30.21,131.47 30.25,131.48
GND on BOTTOM (solid shape): 15.63,88.55 15.63,85.96 15.59,85.95 15.49,85.92 15.41,85.86 15.34,85.84 15.27,85.86 14.64,85.57 15.27,85.29 15.34,85.31 15.41,85.29 15.49,85.23 15.59,85.2 15.63,85.19 15.63,82.57 13.72,80.67 12.94,80.67 12.86,80.71 12.84,80.8 12.79,81.05 12.57,81.15 12.54,81.15 12.37,81.33 12.05,81.33 12.03,81.36 11.84,81.59 11.56,81.67 9.7,81.67 9.46,81.92 9.46,82.65 9.7,82.89 11.84,82.89 12.39,83.44 12.43,83.45 12.46,83.44 12.92,83.61 12.53,83.9 12.43,83.91 12.39,84 12.39,87.39 12.2,87.58 12.2,88.84 12.34,88.98 15.2,88.98
GND on BOTTOM (solid shape): 17.97,108.29 18.7,108.29 19.22,107.77 19.25,107.77 19.34,107.72 19.34,107.61 19.28,107.46 19.29,107.3 19.28,107.27 19.25,107.24 19.09,107.13 19.05,106.94 19.04,106.87 18.98,106.83 18.89,106.78 18.81,106.71 18.73,106.67 18.66,106.7 18.21,106.75 18.05,106.33 18.03,106.24 17.95,106.2 17.27,106.2 16.56,105.48 16.52,105.47 16.49,105.48 16.43,105.54 16.4,105.61 16.42,105.68 16.49,106.08 16.16,106.31 16.13,106.33 16.11,106.36 16.11,106.53 16.53,106.95 16.53,107.14 16.86,107.47 16.88,107.48 16.9,107.48 17.11,107.57 17.18,107.79 17.18,107.81 17.19,107.83 17.36,108 17.39,108.02 17.41,108.02 17.74,108.07 17.91,108.36
GND on BOTTOM (solid shape): 16.45,130.68 16.51,130.68 16.56,130.66 16.56,130.61 16.55,130.59 16.45,130.36 16.51,130.11 16.57,130.05 16.64,129.99 16.66,129.98 16.67,129.95 16.67,127.4 16.6,127.34 16.39,127.34 15.62,128.1 15.61,128.12 15.61,128.14 15.61,128.18 15.6,128.22 15.59,128.25 15.57,128.28 15.57,128.36 15.63,128.42 15.88,128.69 15.77,129.05 15.74,129.12 15.76,129.19 15.81,129.63 15.4,129.81 15.13,129.58 15.16,129.23 15.19,129.2 15.21,129.17 15.24,129.1 15.22,129.03 15.18,128.98 15.15,128.92 15.14,128.87 15.13,128.83 15.06,128.75 14.96,128.77 14.75,128.77 14.71,128.78 14.7,128.82 14.7,128.97 14.31,128.97 14.02,129.26 14.02,131.24 14.03,131.25 14.61,131.25 14.79,131.08 14.95,131.08 15.08,131.1 15.2,131.17 15.23,131.2 15.27,131.25 15.29,131.26 15.88,131.26
GND on BOTTOM (solid shape): outline of 148 points within 91.75,39.69 94.59,42.61
GND on BOTTOM (solid shape): outline of 166 points within 1.03,159.8 49.93,178.18
GND on BOTTOM (solid shape): 21.33,113.8 21.42,113.74 21.41,113.63 21.34,113.23 21.68,113 21.76,112.96 21.78,112.88 21.82,112.71 21.95,112.59 22,112.55 22.01,112.47 22,112.31 22.07,112.15 22.08,112.04 21.99,111.99 21.29,111.99 20.99,111.69 20.99,111.21 20.94,111.16 20.8,111.16 20.72,111.2 20.7,111.29 20.66,111.59 20.42,111.77 20.41,111.77 20.37,111.81 20.37,111.83 20.37,111.84 20.11,112.15 19.81,111.88 19.78,111.81 19.71,111.79 19.39,111.64 19.33,111.29 19.32,111.21 19.23,111.16 17.44,111.16 17.34,111.27 17.31,111.38 17.41,111.44 17.69,111.44 17.69,112.01 17.85,112.18 18.68,112.18 19.5,113 19.53,113.01 19.54,113 19.98,113.16 19.94,113.63 19.92,113.74 20.01,113.8
GND on BOTTOM (solid shape): outline of 200 points within 124.89,166.74 214.14,179
GND on BOTTOM (solid shape): 20.86,107.77 20.93,107.74 20.96,107.65 20.99,107.46 21.14,107.34 21.16,107.33 21.18,107.3 21.16,107.26 21.13,107.23 21.13,106.77 21.07,106.68 20.96,106.69 20.5,106.74 20.34,106.3 20.34,106.28 20.32,106.25 20.05,105.98 20.05,105.75 20.05,105.73 20.03,105.71 20.02,105.28 20.44,105.34 20.5,105.38 20.57,105.38 20.61,105.36 20.62,105.33 20.61,105.29 19.67,104.35 18.71,104.35 18.63,104.39 18.62,104.48 18.12,104.96 18.04,104.28 18.08,104.2 18.05,104.12 17.99,104.06 17.95,104.04 17.91,104.06 17.75,104.21 17.74,104.23 17.74,104.25 17.63,104.55 17.33,104.66 17.32,104.66 17.3,104.67 17.2,104.77 17.18,104.81 17.2,104.84 17.95,105.6 19.12,105.6 19.48,105.96 19.48,105.96 19.63,106.11 19.66,106.12 19.67,106.12 20.14,106.47 19.72,106.87 19.64,106.9 19.61,106.97 19.62,107.01 19.66,107.02 19.8,107.05 19.93,107.14 19.99,107.17 20.06,107.15 20.54,107.15 20.64,107.62 20.64,107.72 20.73,107.77
GND on BOTTOM (solid shape): 28.12,109.2 28.23,109.22 28.29,109.13 28.32,108.99 28.39,108.86 28.42,108.8 28.39,108.73 28.44,108.17 28.99,108.26 29.07,108.31 29.18,108.25 29.18,108.02 29.23,108.02 29.32,107.98 29.33,107.88 29.3,107.66 29.4,107.47 29.43,107.4 29.4,107.33 29.68,106.68 29.95,107.33 29.92,107.4 29.95,107.47 30.01,107.55 30.05,107.65 30.12,107.73 30.22,107.71 30.32,107.6 30.41,107.54 30.38,107.43 30.26,107.16 30.36,106.89 30.39,106.82 30.36,106.75 30.31,106.28 30.75,106.12 30.84,106.1 30.88,106.02 30.88,105.88 30.93,105.84 30.93,105.63 30.78,105.48 30.04,105.48 29.99,105.44 29.96,105.42 29.92,105.44 29.91,105.45 29.91,105.46 29.3,105.9 28.8,105.35 28.8,104.99 28.89,104.69 29.13,104.48 29.19,104.41 29.16,104.32 28.81,103.96 28.49,103.96 28.22,104.24 28.21,104.47 28.22,104.5 28.43,104.72 28.5,104.99 28.5,105.35 28.41,105.65 28.16,105.86 28.1,105.93 28.13,106.02 28.3,106.19 28.3,108.02 27.83,108.48 27.81,108.57 27.86,108.64 28.04,108.83 28.05,109.1 28.05,109.11 28.06,109.14
GND on BOTTOM (solid shape): outline of 105 points within 21.45,121.52 25.97,125.78
GND on BOTTOM (solid shape): outline of 168 points within 23.2,103.96 26.43,111.33
GND on BOTTOM (solid shape): outline of 272 points within 16.11,110.61 27.63,118.54
GND on BOTTOM (solid shape): outline of 899 points within 93.05,47.21 121.41,53.98
GND on BOTTOM (solid shape): outline of 1540 points within 93.07,63.71 119.4,77.69
GND on BOTTOM (solid shape): outline of 1902 points within 27.39,103.96 42.62,117.78
GND on BOTTOM (solid shape): outline of 3570 points within 17.67,114.75 44.26,131.48
GND on GND1 (solid shape): outline of 3808 points within 0.51,0.51 305.34,178.69
GND on IN1 (solid shape): 40.99,89.09 40.99,74.11 40.87,73.98 37.69,73.98 37.06,74.61 37.06,88.71 37.82,89.47 40.61,89.47
GND on IN1 (solid shape): 41.25,64.2 41.25,56.45 40.87,56.07 38.09,56.07 37.44,56.72 37.44,64.44 37.58,64.58 40.87,64.58
GND on IN1 (solid shape): 51.28,53.02 51.28,49.85 51.03,49.59 46.96,49.59 46.71,49.85 46.71,53.15 46.84,53.28 51.03,53.28
GND on IN1 (solid shape): 40.99,72.07 40.99,67.12 40.99,67.11 40.99,66.1 40.79,65.9 38.02,65.9 37.69,66.23 37.69,72.07 37.95,72.33 40.74,72.33
GND on IN1 (solid shape): 45.31,52.9 45.31,52.65 45.31,50.1 45.06,49.85 40.99,49.85 40.74,50.1 40.74,53.53 40.99,53.79 44.42,53.79
GND on IN1 (solid shape): outline of 4523 points within 79.22,41.21 93.7,58.99
GND on VCC (solid shape): outline of 284 points within 90.04,17.59 166.22,54.67
GND on VCC (solid shape): outline of 361 points within 277.18,87.95 304.83,172.68
GND on VCC (solid shape): outline of 486 points within 82.14,61.79 166.22,96.08
GND on IN2 (solid shape): 51.28,52.64 51.28,49.34 51.15,49.21 40.61,49.21 40.11,49.72 40.11,52.9 40.61,53.4 50.52,53.4
GND on IN2 (solid shape): 41.38,89.35 41.38,79.67 41.37,79.65 41.36,79.63 41.25,79.36 41.36,79.09 41.37,79.07 41.38,79.05 41.38,73.66 41.37,73.63 41.35,73.61 41.12,73.26 41.35,72.92 41.37,72.9 41.38,72.87 41.38,67.82 41.37,67.79 41.35,67.77 41.12,67.42 41.35,67.07 41.37,67.06 41.38,67.03 41.38,56.58 40.87,56.07 38.07,56.07 37.57,56.58 37.57,76.9 37.06,77.41 37.06,89.22 37.44,89.6 41.12,89.6
GND on IN2 (solid shape): outline of 8343 points within 84.17,62.19 166.98,95.11
GND on IN2 (solid shape): outline of 8892 points within 90.02,15.45 162.28,54.04
GND on IN3 (solid shape): 41.38,89.35 41.38,86.55 40.99,86.17 37.44,86.17 37.06,86.55 37.06,89.22 37.44,89.6 41.12,89.6
GND on IN3 (solid shape): 51.28,52.64 51.28,50.23 50.65,49.59 45.82,49.59 45.44,49.21 40.61,49.21 40.11,49.72 40.11,52.9 40.61,53.4 50.52,53.4
GND on IN3 (solid shape): 41.38,84.14 41.38,80.76 40.61,80 39.52,80 39.47,79.95 38.08,79.95 37.57,80.46 37.57,83.76 38.2,84.39 41.12,84.39
GND on IN3 (solid shape): 41.38,78.04 41.38,73.66 41.37,73.63 41.35,73.61 41.12,73.26 41.35,72.92 41.37,72.9 41.38,72.87 41.38,67.82 41.37,67.79 41.35,67.77 41.12,67.42 41.35,67.07 41.37,67.06 41.38,67.03 41.38,56.58 40.87,56.07 38.07,56.07 37.57,56.58 37.57,68.59 37.57,68.59 37.57,74.41 37.57,76.9 37.57,77.92 37.82,78.17 41.25,78.17
GND on IN3 (solid shape): outline of 1320 points within 18.77,105.22 24.87,117.67
GND on IN3 (solid shape): outline of 1903 points within 64.87,40.07 80.62,49.19
GND on GND2 (solid shape): outline of 3865 points within 0.51,0.51 305.34,178.69
GND on IN4 (solid shape): 41.38,89.35 41.38,85.47 41.18,85.28 37.31,85.28 37.06,85.54 37.06,89.22 37.44,89.6 41.12,89.6
GND on IN4 (solid shape): 41.38,63.95 41.38,56.58 40.87,56.07 38.07,56.07 37.57,56.58 37.57,63.95 38.07,64.45 40.87,64.45
GND on IN4 (solid shape): 51.28,52.59 51.28,49.34 51.15,49.21 40.61,49.21 40.11,49.72 40.11,52.9 40.61,53.4 50.47,53.4
GND on IN4 (solid shape): 41.38,69.79 41.38,67.82 41.37,67.79 41.35,67.77 41.12,67.42 41.35,67.07 41.37,67.06 41.38,67.03 41.38,66.23 40.99,65.85 37.95,65.85 37.57,66.23 37.57,69.66 37.95,70.04 41.12,70.04
GND on IN4 (solid shape): 41.38,83.88 41.38,79.67 41.37,79.65 41.36,79.63 41.25,79.36 41.36,79.09 41.37,79.07 41.38,79.05 41.38,73.66 41.37,73.63 41.35,73.61 41.12,73.26 41.35,72.92 41.37,72.9 41.38,72.87 41.38,71.95 40.99,71.57 37.82,71.57 37.57,71.82 37.57,76.9 37.06,77.41 37.06,83.63 37.57,84.14 41.12,84.14
GND on GND3 (solid shape): outline of 3881 points within 0.51,0.51 305.34,178.69
GNDA_CHG on TOP (solid shape): 171.25,35.75 171.28,35.74 171.3,35.7 171.3,35.24 171.8,35.24 171.8,35.7 171.82,35.74 171.85,35.75 172.31,35.75 172.44,35.62 172.44,35.24 174.73,32.96 177.9,32.96 178.03,32.83 178.03,28.44 178.01,28.4 177.98,28.39 177.82,28.39 177.79,28.4 177.77,28.44 177.77,29.53 177.65,29.66 177.14,29.66 177.01,29.53 177.01,28.44 177,28.4 176.96,28.39 176.81,28.39 176.77,28.4 176.76,28.44 176.76,29.78 176.63,29.91 174.98,29.91 174.85,30.04 174.85,32.32 174.47,32.7 173.46,32.7 173.33,32.83 173.33,32.96 171.93,34.35 171.42,34.35 171.17,34.61 170.91,34.61 170.79,34.74 170.79,35.62 170.92,35.75
GNDA_CHG on BOTTOM (solid shape): outline of 726 points within 167.23,24.45 185.56,40.32
GNDA_VCCSA on BOTTOM (solid shape): 52.36,14.67 53.19,14.67 53.31,14.54 53.31,13.72 53.25,13.65 52.74,13.65 52.74,13.2 52.73,13.16 52.69,13.15 52.67,13.15 52.63,13.16 52.61,13.2 52.61,13.65 52.11,13.65 52.06,13.6 52.05,13.6 51.66,13.21 50.65,13.21 50.52,13.34 50.52,16.32 50.58,16.38 50.65,16.38
VCCP on TOP (solid shape): 31.44,79.24 31.51,79.2 31.53,79.14 31.53,78.79 31.52,78.76 31.48,78.74 31.21,78.74 31.09,78.87 29.7,78.87 29.17,78.87 29.13,78.88 29.12,78.92 29.12,79.06 29.18,79.12 30.4,79.12 30.4,79.12 30.89,79.12 30.96,79.12 31.09,79.25 31.37,79.25
+BL_PWR_SRC on TOP (solid shape): 80.88,144.01 80.88,141.75 79.97,140.83 79.97,140.04 79.7,139.78 78.07,139.78 77.8,140.04 77.8,141.45 79.08,142.74 79.08,143.97 79.18,144.06 80.83,144.06
+BL_PWR_SRC on TOP (solid shape): 65.85,157.09 65.87,157.09 65.88,157.08 65.93,157.04 65.93,155.41 65.64,155.12 65.35,155.12 65.23,155 65.22,155 65.03,154.89 64.93,154.71 64.93,154.69 64.5,154.27 64.5,151.87 64.49,151.85 64.47,151.83 64.34,151.3 64.86,151.17 64.89,151.18 64.92,151.16 67.24,148.85 67.24,148.26 66.63,147.65 65.54,147.65 64.68,148.52 64.68,148.82 63.21,150.29 63.21,154.23 64.11,155.13 64.11,155.43 64.11,155.43 64.11,157.07 64.14,157.09
+BL_PWR_SRC on BOTTOM (solid shape): outline of 251 points within 63.08,137.21 81.74,149.61
+CAMERA_VDD on TOP (solid shape): 4.19,137.87 4.19,136.5 3.95,136.26 3,136.26 2.86,136.12 2.86,135.01 2.78,134.94 2.67,134.87 2.6,134.76 2.51,134.67 2.51,134.46 2.53,134.46 2.81,134.17 2.81,133.44 2.2,132.83 1.37,132.83 1.09,133.11 1.09,137.07 1.31,137.29 2.39,137.29 2.65,137.55 2.65,137.92 2.86,138.13 3.94,138.13
+CHAGER_SRC on BOTTOM (solid shape): 200.63,45.02 200.63,39.56 200.19,39.12 196.51,39.12 195.93,38.55 191.11,38.55 190.85,38.8 190.85,42.86 189.97,43.75 189.97,44.17 197.44,44.17 197.45,44.12 197.46,44.06 197.48,44.01 197.51,43.96 197.54,43.92 197.58,43.88 197.63,43.85 197.68,43.82 197.73,43.8 197.78,43.79 197.84,43.79 197.9,43.8 197.95,43.81 198,43.83 198.05,43.86 198.09,43.9 198.13,43.94 198.16,43.98 198.18,44.03 198.2,44.09 198.21,44.14 198.21,44.2 198.2,44.25 198.18,44.31 198.16,44.36 198.13,44.4 198.09,44.45 198.05,44.48 198,44.51 197.95,44.53 197.9,44.55 197.84,44.55 197.78,44.55 197.73,44.54 197.68,44.52 197.63,44.5 197.58,44.46 197.54,44.43 197.51,44.38 197.48,44.33 197.46,44.28 197.45,44.23 197.44,44.17 189.97,44.17 189.97,44.9 190.35,45.28 200.38,45.28
+CRT_VCC on TOP (solid shape): 78.03,170.69 78.03,167.12 77.79,166.88 75,166.88 74.74,167.15 74.74,170.4 75.11,170.76 77.95,170.76
+CRT_VCC on IN1 (solid shape): outline of 280 points within 61.21,168.85 76.19,173.49
+DC1_PWR_SRC on BOTTOM (solid shape): 276.07,57.84 276.03,57.8 276.03,56.73 275.98,56.68 275.98,56.55 275.69,56.26 275.69,55.06 275.18,54.55 275.18,53.28 275.31,53.15 278.48,53.15 278.74,53.4 278.74,54.67 278.87,54.8 280.01,54.8 280.14,54.67 280.14,53.02 280.01,52.9 280.01,50.1 279.75,49.85 277.47,49.85 277.21,50.1 277.21,51.25 276.96,51.5 272.9,51.5 272.52,51.12 268.96,51.12 268.58,50.74 268.58,50.1 268.45,49.98 266.17,49.98 266.04,50.1 266.04,53.47 266.95,54.38 266.95,57.67 267.51,58.23 270.36,58.23 270.74,57.85 270.74,55.06 271.25,54.55 274.17,54.55 274.67,55.06 274.67,56.2 275.82,57.34 275.82,58.74 276.07,58.74
+DC_IN on TOP (solid shape): 14.72,78.58 14.72,75.09 15.32,74.49 15.32,73.74 15.49,73.57 16.27,73.57 16.35,73.53 16.36,73.44 16.62,72.95 17.1,73.23 17.1,73.24 17.43,73.57 18.22,73.57 18.39,73.41 18.39,69.36 18.05,69.02 14.38,69.02 14.2,69.2 14.2,71.03 12.43,72.8 12.43,75.45 11.2,76.68 11.2,78.51 11.62,78.93 14.37,78.93
+DC_IN_SS on TOP (solid shape): outline of 253 points within 3.53,77.15 16.62,88.25
+DCIN on TOP (solid shape): 181.84,36.58 181.84,33.34 181.58,33.08 181.01,33.08 180.44,33.66 178.47,33.66 177.96,33.15 177.84,33.15 177.77,33.21 177.77,34.23 177.84,34.29 178.28,34.29 180.69,36.7 181.71,36.7
+DCIN_JACK on TOP (solid shape): 12.88,65.72 15.38,65.72 15.78,65.32 15.78,61.72 16.06,61.44 16.06,60.05 15.81,59.79 15.04,59.79 14.72,60.11 13.23,60.11 12.41,60.94 5.48,60.94 5.17,61.25 5.17,64.77 5.17,64.79 5.18,64.81 5.31,65.09 5.18,65.37 5.17,65.39 5.17,65.41 5.17,66.36 5.21,66.4 12.2,66.4
+DIMM2_VREF_DQ on BOTTOM (solid shape): 132.19,22.5 132.19,20.99 132.51,20.68 135.49,20.68 135.52,20.66 135.54,20.63 135.54,20.5 135.9,20.14 135.9,18.94 135.6,18.63 130.92,18.63 129.54,20.01 129.54,21.1 129.26,21.39 128.48,21.39 128.24,21.63 128.24,22.66 128.34,22.76 131.94,22.76
+DOCK_PWR_BAR on TOP (solid shape): 122.78,124.14 122.78,120.46 122.27,119.95 121.51,119.95 120.88,119.32 120.88,118.17 120.75,118.05 119.99,118.05 119.86,118.17 119.86,121.35 120.37,121.86 120.37,123.38 119.35,124.4 119.35,125.16 119.23,125.28 119.23,125.3 118.98,125.64 118.57,125.55 118.56,125.54 118.54,125.54 118.08,125.54 117.96,125.67 117.96,126.68 118.08,126.81 120.12,126.81
+DOCK_PWR_BAR on BOTTOM (solid shape): 140.47,115.53 142.09,115.53 142.47,115.15 142.47,110.43 141.83,109.79 136.75,109.79 135.61,108.65 131.93,108.65 131.42,109.16 131.42,113.48 131.55,113.6 135.1,113.6 135.41,113.91 135.41,114.63 135.23,114.81 134.19,114.81 133.77,115.23 133.77,116.13 133.88,116.24 139.76,116.24
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 615 points within 74.01,119.95 81.21,134.48
+DOCK_PWR_BAR on VCC (solid shape): outline of 246 points within 73,112.59 142.34,132.4
+DP_VCC on TOP (solid shape): 295.5,141.03 295.5,138.86 295.24,138.6 293.18,138.6 292.84,138.25 292.84,135.7 292.45,135.32 290.04,135.32 289.91,135.45 289.91,140.53 290.04,140.65 294.11,140.65 294.61,141.16 295.38,141.16
+EDPVDD on TOP (solid shape): 61.32,158.36 61.32,157.1 61.41,157.01 61.41,155.83 61.31,155.73 61.13,155.73 60.95,155.78 60.76,155.73 59.74,155.73 59.59,155.88 59.59,158.25 59.9,158.56 61.12,158.56
+LCDVDD on TOP (solid shape): 76.35,145.49 76.35,142.82 76.41,142.76 76.41,142.25 76.31,142.15 75.42,142.15 75.11,142.47 75.11,144.18 75.06,144.23 75.06,145.38 75.28,145.61 76.24,145.61
+LCDVDD on BOTTOM (solid shape): 76.39,145.85 76.39,144.35 76.19,144.15 74.83,144.15 74.18,144.79 74.18,146.23 74.31,146.36 75.88,146.36
+MXM_PWR on TOP (solid shape): outline of 545 points within 170.32,163.41 185.24,174.46
+MXM_PWR on BOTTOM (solid shape): 183.87,171.39 183.87,166.69 183.62,166.43 180.2,166.43 179.74,166.89 179.74,169.44 179.34,169.85 179.34,171.64 179.7,172 182.32,172 182.35,172.02 183.23,172.02
+MXM_PWR_SRC on TOP (solid shape): 210.65,175.88 210.65,172.68 210.31,172.35 208.54,172.35 207.28,171.08 207.28,168.62 207.07,168.41 205.5,168.41 204.89,169.03 196.86,169.03 196.53,169.35 196.53,173.9 196.67,174.04 201.14,174.04 202.2,172.99 203.83,172.99 204.89,174.04 208.32,174.04 208.83,174.37 208.74,174.97 208.74,175.95 208.88,176.09 210.44,176.09
+MXM_PWR_SRC on TOP (solid shape): outline of 210 points within 174.33,168.03 181.53,175.69
+MXM_PWR_SRC on IN2 (solid shape): outline of 1586 points within 173.67,167.32 204.82,176.09
+MXM_PWR_SRC on IN3 (solid shape): outline of 1428 points within 176.39,165.93 204.32,175.96
+MXM_PWR_SRC on IN4 (solid shape): outline of 1656 points within 174.59,166.82 204.95,176.85
+PCH_V5REF_RUN on BOTTOM (solid shape): 11.67,124.4 11.69,124.39 11.71,124.38 11.81,124.29 11.93,124.24 11.94,124.24 12.17,124.02 12.17,123.25 11.4,122.49 11.4,121.35 11.66,121.1 11.66,120.71 11.53,120.59 11.02,120.59 10.9,120.71 10.9,122.87 10.51,123.25 10.51,124.04 10.52,124.06 10.62,124.2 10.65,124.35 10.65,124.37 10.68,124.4
+PCH_V5REF_SUS on BOTTOM (solid shape): 11.66,120.33 11.66,119.71 11.64,119.69 11.63,119.68 11.39,119.27 11.74,118.95 11.77,118.93 11.78,118.9 11.78,116.27 11.67,116.16 11.31,116.16 11.23,116.2 11.22,116.3 11.26,116.4 11.26,116.5 11.13,116.76 10.87,116.85 10.8,116.88 10.77,116.96 10.77,117.66 10.78,117.69 10.81,117.71 11.12,118.08 10.81,118.46 10.78,118.47 10.77,118.51 10.77,120.33 10.9,120.46 11.53,120.46
+PWR_SRC on TOP (solid shape): 34.28,18 34.28,14.14 34.26,14.12 34.26,13.69 34.11,13.54 31.79,13.54 31.75,13.58 30.16,13.58 30,13.74 30,15.53 30.19,15.73 30.21,15.74 32.33,15.74 32.76,16.17 32.76,18 33.16,18.39 33.88,18.39
+PWR_SRC on TOP (solid shape): 36.93,55.18 36.93,54.13 37.35,53.71 37.73,53.71 37.91,53.62 38.11,53.63 38.3,53.63 38.35,53.58 38.35,51.05 38.22,50.92 37.13,50.92 36.92,51.12 34.65,51.12 34.26,51.52 34.26,55.25 34.58,55.56 36.55,55.56
+PWR_SRC on TOP (solid shape): outline of 115 points within 11.53,89.35 20.8,93.41
+PWR_SRC on TOP (solid shape): 130.73,125.03 130.73,124.54 130.64,124.45 130.64,120.65 130.22,120.23 129.93,120.23 129.93,119.57 129.89,119.48 129.79,119.47 129.31,119.33 129.38,118.84 129.42,118.76 129.38,118.68 129.31,118.19 129.79,118.04 129.89,118.04 129.93,117.95 129.93,114.73 132.28,112.38 135.77,112.38 137.74,110.41 141.97,110.41 142.47,109.92 142.47,107.34 141.96,106.83 135.44,106.83 135.39,106.78 134.26,106.78 127.43,113.61 127.43,118.15 127.43,118.17 127.45,118.18 127.56,118.45 127.45,118.71 127.43,118.78 127.45,118.85 127.56,119.15 127.41,119.42 127.39,119.44 127.39,119.46 127.39,120.73 127.05,121.07 127.05,124.65 127.51,125.11 130.66,125.11
+PWR_SRC on BOTTOM (solid shape): 215.42,32.23 215.42,28.94 215.2,28.73 211.01,28.73 210.63,29.11 210.63,32.41 210.72,32.5 215.15,32.5
+PWR_SRC on BOTTOM (solid shape): 265.69,58.4 265.69,54.76 265.1,54.17 261.72,54.17 261.59,54.29 261.59,58.48 261.97,58.87 265.22,58.87
+PWR_SRC on BOTTOM (solid shape): 201.4,38.8 201.4,35.24 201.14,34.99 199.24,34.99 198.6,34.35 198.6,33.97 198.35,33.72 196.57,33.72 196.32,33.97 196.32,38.67 196.63,38.98 201.21,38.98
+PWR_SRC on BOTTOM (solid shape): 77.98,141.36 77.98,139.99 77.77,139.79 77.14,139.79 76.96,139.97 75.04,139.97 74.98,140.03 74.98,140.48 75.61,141.1 75.61,141.8 75.72,141.91 77.43,141.91
+PWR_SRC on BOTTOM (solid shape): 62.41,14.16 62.44,14.15 62.46,14.11 62.46,13.65 63.22,13.65 63.22,14.11 63.23,14.15 63.27,14.16 63.55,14.16 63.59,14.15 63.6,14.11 63.6,13.65 64.49,13.65 64.62,13.53 64.62,11.49 64.49,11.37 61.44,11.37 61.06,11.75 61.06,13.53 61.19,13.65 62.08,13.65 62.08,14.11 62.09,14.15 62.13,14.16
