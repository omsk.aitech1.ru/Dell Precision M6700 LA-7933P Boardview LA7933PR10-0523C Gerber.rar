# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 16.5
  TOP w0.508: v1(82.8,155.03) R571.2 R573.2 v2(87.62,156.56) R572.2 R574.2
  BOTTOM w0.508: v1(82.8,155.03) 79.21,155.03 78.87,155.37 C485.2
GNDA_CHG: length 11.4
  TOP w0.508: PC928.2 v1(169.9,25.97) ; PC908.2 v1(175.61,39.69) ; PR914.2 v1(168.25,35.5) ; PC922.2 v1(173.84,25.34) ; PC935.2 v1(184.89,27.75) ; PC904.1 171.33,37.94 v1(171.42,38.04) ; PC924.2 170.3,32.29 PC923.2 v1(169.26,33.08) ; v1(174.34,38.04) 174.31,38 PC906.2 ; PC927.2 v1(168.25,33.08) ; v1(169.9,33.34) 170.41,33.85 PC909.2 ; PC916.2 v1(176.38,25.34) ; v1(184.89,30.8) PC933.1 ; PR925.2 v1(174.85,25.34) ; PC926.2 v1(172.19,28)
  vias: v1(171.55,34.61) v1(175.36,30.29) v1(175.49,32.2) v1(177.27,32.2) v1(177.39,30.29) v2(185.37,26.78)
GNDA_VCCSA:
  vias: v2(50.91,14.67)
VCC_AXG_SENSE: length 65.4
  TOP w0.254: v1(57.38,77.27) 58.16,76.48 RC85.1 59.47,76.48 RC84.2 59.54,76.43 60.08,75.88 v2(60.48,75.88) 60.76,75.88 61.75,74.89 61.75,73.27 64.56,70.45 65.1,70.45 65.21,70.56 65.21,70.82 65.37,70.98 65.73,70.98 65.9,70.81 JCPU1.AK35 ; PR702.2 25.5,86.39 PR704.2 PC703.1 25.41,87.44 24.87,87.98 24.87,88.54 25.16,88.84 25.25,88.84 v1(25.37,88.96)
  IN4 w0.267: v1(25.37,88.96) 27.97,91.56 29.54,91.56 29.88,91.22 32.45,91.22 33.08,91.85 34.08,91.85 36.2,93.97 40.19,93.97 40.88,93.28 44.36,93.28 44.71,93.64 51.94,93.64 52.68,92.9 52.68,91.34 53.93,90.09 53.93,85.59 57.02,82.5 57.02,79.25 57.33,78.94 57.33,77.31 v1(57.38,77.27)
VCC_VAL_SNESE: length 8.2
  TOP w0.089: JCPU1.AJ33 67.84,69.45 67.33,68.94 v5(67.33,68.87)
  BOTTOM w0.102: RC60.1 RC59.2 62.74,71.53 v2(63.12,71.16) 65.4,68.87 v5(67.33,68.87)
VCCP: length 3.9
  BOTTOM w0.508: PR718.1 PC723.1 29.64,78.93 v2(30.41,78.93) 30.96,78.93 31.02,78.99 v1(31.28,78.99)
VCCP_PWRCTRL: length 38.9
  TOP w0.254: v1(81.89,34.22) 81.89,34.24 81.8,34.33 81.8,34.77 81.89,34.86 RC89.2
  IN1 w0.254: v1(81.89,34.22) 81.89,34.2 81.74,34.05 81.74,33.61 76.24,28.11 57.06,28.11 56.19,27.24 53.97,27.24 v1(53.5,26.77)
  BOTTOM w0.254: PQ503.2 53.04,25.8 52.88,25.96 52.56,25.96 52.33,25.72 PC510.1 51.92,25.75 51.92,26.07 52.46,26.62 v2(52.88,26.62) 53.35,26.62 v1(53.5,26.77) 53.5,27.01 52.28,28.24 PR514.1
VCCP_PWRCTRL_R: length 5.6
  TOP w0.102: JCPU1.A19 81.89,41.44 81.89,37.73 81.55,37.39 v2(81.55,37.14) 81.55,36.44 RC89.1
VCCSA_SENSE: length 88
  TOP w0.254: v1(82.65,51.63) 80.9,51.63 79.75,50.48 79.39,50.48 79.24,50.33 78.94,50.33 78.46,49.85 78.46,49.64 78.46,49.63 78.46,49.27 78.46,49.26 78.46,49.01 JCPU1.H23
  IN3 w0.254: v1(82.65,51.63) 81.38,51.63 80.87,51.12 80.87,42.48 81.13,42.23 81.13,41.34 79.22,39.43 76.94,39.43 75.92,38.42 75.92,24.58 79.22,21.27 79.22,12.76 77.19,10.73 46.84,10.73 v1(45.69,11.88)
  BOTTOM w0.102: v1(45.69,11.88) v2(45.69,11.27)
  BOTTOM w0.254: PR611.2 45.82,12 v1(45.69,11.88)
VCCSA_VID_0: length 41.3
  TOP w0.089: JCPU1.C22 78.9,43.44 79.32,43.02 v1(79.32,42.96)
  IN1 w0.089: v1(79.32,42.96) 79.32,42.62 78.75,42.05 78.75,41.35 77.51,40.11 77.51,39.69
  IN1 w0.254: 77.51,39.69 77.47,39.66 77.47,33.85 76.2,32.58 60.68,32.58 57.25,29.15 52.4,29.15 v1(51.27,28.02)
  BOTTOM w0.127: v2(50.13,28.92) PR614.2
  BOTTOM w0.254: PR614.2 51.23,27.98 v1(51.27,28.02)
VCCSA_VID_1: length 42.3
  TOP w0.089: v1(77.39,43.98) 77.38,43.98 76.9,43.5 JCPU1.C24
  IN1 w0.089: 76.88,39.69 76.88,40.32 77.91,41.35 77.91,43.29 77.39,43.82 v1(77.39,43.98)
  IN1 w0.254: v3(51.08,27.27) 50.96,27.27 50.66,27.57 50.66,28.33 52.03,29.71 57.02,29.71 60.45,33.14 75.97,33.14 76.88,34.05 76.88,39.69
  BOTTOM w0.254: PR613.2 50.77,26.96 v3(51.08,27.27)
VCCSAPWROK: length 46.8
  TOP w0.127: U50.2 27.02,14.73 27.21,14.92 28.21,14.92 v1(28.46,15.18)
  IN1 w0.254: v1(28.46,15.18) 28.98,15.7 28.98,18.05 28.21,18.83 28.21,21.32 27.79,21.74 27.79,24.02 27.25,24.55 27.25,27.15 28.09,27.99 28.09,32.67 28.64,33.21 29.96,33.21 29.96,33.21 35.53,33.21 36.63,34.3 40.05,34.3 41.64,32.71 41.64,31.09 45.82,26.91 v3(48.03,26.91)
  BOTTOM w0.254: v3(48.03,26.91) 48.29,26.66 PR603.1
VCCSENSE: length 92.2
  TOP w0.254: v1(57.83,72.14) 57.94,72.14 58.2,72.4 58.5,72.4 RC66.1 58.52,72.99 58.49,73.03 RC67.2 58.52,73.44 RC68.2 ; v1(25.83,69.85) v2(26.53,69.85) 27.06,69.85 27.33,70.12 27.33,71.04 PC749.1 27.4,71.48 27.13,71.75 PR744.2 27.15,72.11 28.06,73.02 PR748.2
  IN4 w0.267: v1(25.83,69.85) 25.37,69.85 24.87,69.34 24.87,65.19 31.63,58.43 31.63,54.53 38.58,47.57 38.58,45.53 40.3,43.82 40.3,43.37 42.01,41.66 56.04,41.66 59.89,45.5 59.89,69.94 58.93,70.9 57.58,70.9 57.28,71.21 57.28,71.68 57.73,72.14 v1(57.83,72.14)
VCCSENSE_R: length 7.6
  TOP w0.254: RC68.1 59.86,72.16 v2(60.49,72.16) 60.69,72.16 63.32,69.53 64.54,69.53 64.61,69.46 65.89,69.46 JCPU1.AJ35
VDD_1.5V: length 7.4
  BOTTOM w0.102: PR204.2 v2(233.26,37.22)
  BOTTOM w0.203: PU201.11 232.1,43.63 232.68,43.05
  BOTTOM w0.508: 232.68,43.05 232.57,42.95 PR202.1 233.09,41.49 PC211.1 233.09,39.78 233.26,39.61 PR204.2
VDD_PWRGD: length 2.7
  TOP w0.102: R389.2 146.9,158.81 146.33,159.39 145.73,159.39 145.54,159.58 U18.18
VDDPWRGOOD: length 5.8
  TOP w0.102: RC4.2 92.81,82.91 93.94,84.03 UC1.4 ; RC4.2 RC5.1 RC7.1 ; RC4.2 v2(91.41,82.83)
VDDPWRGOOD_R: length 28
  TOP w0.089: JCPU1.V8 92.9,58.39 v1(92.43,57.92)
  TOP w0.102: v1(93.78,80.68) 93.83,80.73 RC5.2
  BOTTOM w0.102: v1(93.78,80.68) 93.66,80.8 92.98,80.8 91.98,79.81 v2(91.98,78.74) 91.98,73.6 91.79,73.41 91.21,73.41 90.89,73.09 90.89,58.69 91.11,58.47 91.87,58.47 v1(92.43,57.92)
VSS_AXG_SENSE: length 72.1
  TOP w0.203: v1(24.27,82.75) 24.34,82.68 24.76,82.68 25.67,81.78 PU702.39
  TOP w0.254: JCPU1.AK34 66.41,69.96 64.44,69.96 61.31,73.09 61.31,74.68 v2(61.18,74.81) 60.54,75.45 59.55,75.45 RC86.1 59.47,75.54 RC85.2 58.49,75.54 57.38,76.65 v1(57.25,76.65)
  IN1 w0.267: v1(24.27,82.75) 24.27,82.79 23.94,83.12 23.94,83.77 25.37,85.2 v1(25.37,88.33)
  IN4 w0.267: v1(25.37,88.33) 25.49,88.45 25.59,88.45 25.89,88.75 25.89,88.84 28.16,91.12 29.35,91.12 29.69,90.77 32.63,90.77 33.26,91.4 34.26,91.4 36.38,93.52 39.99,93.52 40.68,92.84 44.54,92.84 44.9,93.19 51.76,93.19 52.23,92.72 52.23,91.15 53.48,89.9 53.48,85.41 56.58,82.31 56.58,79.06 56.86,78.77 56.86,77.48 56.68,77.3 56.68,76.77 56.81,76.65 v1(57.25,76.65)
  BOTTOM w0.254: PC706.2 24.74,81.67 24.29,82.12 24.29,82.73 v1(24.27,82.75)
VSS_NCTF_1: length 0.6
  TOP w0.254: 17.49,105.56 17.86,105.93 UH4.A4
VSS_NCTF_2: length 1
  TOP w0.254: 16.91,125.75 17.63,125.75 UH4.A44
VSS_NCTF_3: length 0.9
  TOP w0.254: 16.91,126.13 UH4.A45
VSS_NCTF_4: length 0.9
  TOP w0.254: 16.91,126.73 UH4.A46
VSS_NCTF_5: length 1
  TOP w0.254: 17.14,105.91 17.79,106.57 UH4.A5
VSS_NCTF_6: length 1.4
  TOP w0.254: UH4.A6 17.82,107.17 16.85,106.2
VSS_NCTF_7: length 0.7
  TOP w0.254: UH4.B3 18.37,105.45 17.89,104.96
VSS_NCTF_8: length 0.6
  TOP w0.254: UH4.B47 17.8,127.25
VSS_NCTF_9: length 0.6
  TOP w0.254: UH4.BD1 38.85,104.45 39.22,104.08
VSS_NCTF_10: length 1
  TOP w0.254: UH4.BD49 38.85,128.22 39.52,128.89
VSS_NCTF_11: length 0.6
  TOP w0.254: UH4.BE1 39.45,104.49 39.86,104.08
VSS_NCTF_12: length 0.8
  TOP w0.254: 39.98,128.7 39.45,128.18 UH4.BE49
VSS_NCTF_13: length 0.7
  TOP w0.254: UH4.BF1 40.05,104.52 40.56,104.02
VSS_NCTF_14: length 0.9
  TOP w0.254: 40.68,128.76 40.08,128.16 UH4.BF49
VSS_NCTF_15: length 0.8
  TOP w0.254: UH4.BG2 40.51,104.99 41.08,104.42
VSS_NCTF_16: length 0.8
  TOP w0.254: 41.06,128.26 40.51,127.71 UH4.BG48
VSS_NCTF_17: length 0.5
  TOP w0.254: UH4.BH3 40.99,105.45 41.36,105.08
VSS_NCTF_18: length 0.8
  TOP w0.254: 41.5,127.81 40.97,127.28 UH4.BH47
VSS_NCTF_19: length 0.5
  TOP w0.254: 41.88,105.59 41.5,105.97 UH4.BJ4
VSS_NCTF_20: length 0.6
  TOP w0.254: UH4.BJ44 41.48,125.56 41.86,125.93
VSS_NCTF_21: length 0.7
  TOP w0.254: 41.95,126.61 41.48,126.14 UH4.BJ45
VSS_NCTF_22: length 0.7
  TOP w0.254: UH4.BJ46 41.5,126.73 42.01,127.24
VSS_NCTF_23: length 0.5
  TOP w0.254: UH4.BJ5 41.8,106.25
VSS_NCTF_24: length 0.5
  TOP w0.254: 41.81,106.82 41.48,107.14 UH4.BJ6
VSS_NCTF_25: length 0.9
  TOP w0.254: 18.55,104.22 18.82,104.48 18.82,104.99 UH4.C2
VSS_NCTF_26: length 0.8
  TOP w0.254: UH4.C48 18.71,127.82 18.07,127.82
VSS_NCTF_27: length 0.8
  TOP w0.254: UH4.D1 19.29,104.41 18.82,103.95
VSS_NCTF_28: length 0.9
  TOP w0.254: UH4.D49 19.22,128.23 18.39,128.23
VSS_NCTF_29: length 1.2
  TOP w0.254: UH4.E1 19.89,104.47 19.09,103.68
VSS_NCTF_30: length 3
  TOP w0.254: 17.08,128.61 19.44,128.61 UH4.E49
VSS_NCTF_31: length 0.9
  TOP w0.254: 19.83,103.88 20.27,104.31 20.27,104.32 UH4.F1
VSS_NCTF_32: length 3.6
  TOP w0.254: 17.24,129.05 19.6,129.05 UH4.F49
VSS_VAL_SNESE: length 10.8
  TOP w0.089: JCPU1.AH33 67.9,68.43 68.35,67.98 v1(68.35,67.97)
  BOTTOM w0.102: RC61.2 59.88,71.76 RC60.2 61.75,69.89 v2(63.24,69.89) 63.96,69.89 65.4,68.44 67.89,68.44 68.35,67.98 v1(68.35,67.97)
VSSAXG_VAL_SENSE: length 15.1
  TOP w0.254: v5(70.38,68.92) 69.91,68.45 JCPU1.AH31
  BOTTOM w0.254: RC56.2 59.54,73.94 60.01,74.41 RC55.2 60.64,74.87 66.17,69.34 67.6,69.34 68.02,68.92 v2(69.8,68.92) v5(70.38,68.92)
VSSIO_SENSE_R: length 48.9
  TOP w0.081: v2(92.96,35.62) 92.48,35.62 92.05,36.06 RC72.1 92.05,37.1 91.65,37.49 v1(91.65,38.44) 91.65,38.6 90.9,39.35 JCPU1.A10
  IN1 w0.089: v1(91.65,38.44) 91.65,38.62 91.22,39.05 88.5,39.05 77.28,27.84 57.24,27.84 56.13,26.73 v1(55.98,26.73)
  BOTTOM w0.081: PR510.2 v1(55.98,26.73)
VSSSENSE: length 99.4
  TOP w0.203: v1(26.77,74.64) 26.87,74.64 27.27,75.03 PU702.16
  TOP w0.254: v2(57.08,71.55) 57.17,71.47 v1(57.79,71.47) RC66.2 58.52,70.89 58.49,70.85 RC71.1 59.03,70.42 59.07,70.46 RC69.2
  IN4 w0.267: v1(57.79,71.47) 57.81,71.49 58.97,71.49 60.35,70.11 60.35,45.33 56.23,41.21 41.82,41.21 39.85,43.18 39.85,43.63 38.08,45.4 38.08,47.44 31.14,54.38 31.14,58.29 24.41,65.02 24.41,69.81 25,70.4 26.05,70.4 26.53,70.88 26.53,72.76 27.05,73.28 27.05,74.36 v1(26.77,74.64)
  BOTTOM w0.254: v1(26.77,74.64) 26.6,74.64 25.63,75.62 25.63,76.54 25.93,76.84 PC753.1
VSSSENSE_R: length 8.8
  TOP w0.254: JCPU1.AJ34 66.46,69.01 64.45,69.01 64.36,69.1 63.14,69.1 v2(61.2,71.04) 60.51,71.73 59.86,71.73 RC69.1
3D_ON: length 83.4
  TOP w0.102: Q85.2 101.29,158.67 101.69,159.07 v1(101.69,160.5) ; U627.4 42.81,169.01 43.5,169.7 45.29,169.7 v1(46.11,168.87)
  IN1 w0.109: v1(47.28,157.43) 48.35,156.36 60.17,156.36 60.65,155.88 66.46,155.88 68.9,153.44 70.94,153.44 71.54,154.04 73.86,154.04 77.42,150.48 80.49,150.48 81.42,149.55 92.86,149.55 97.31,154 97.31,156.81 101,160.5 v1(101.69,160.5)
  BOTTOM w0.102: v1(47.28,157.43) 47.28,163.93 v2(47.2,164.01) 47.2,167.78 v1(46.11,168.87)
3301_ACAV_IN_NB: length 2.2
  TOP w0.254: PU1001.24 v2(176.37,76.34) 176.37,77.3 PR1019.1
3301_DC_IN_SS: length 2.4
  TOP w0.254: PR1010.2 172.63,70.93 v2(172.72,70.84) 173.01,70.84 173.35,71.18 PU1001.34
3301_PWRSRC: length 5
  TOP w0.102: PR1029.1 182.58,72.38 184,72.38 v2(184.3,72.68)
  TOP w0.254: PR1029.1 181.71,72.68 181.08,72.68 181.07,72.67 180.65,72.67 180.64,72.68 PU1001.15
+A_ENABLE: length 11.8
  TOP w0.508: Q58.3 137.34,149.6 137.08,149.86 137.08,150.58 137.44,150.94 C770.1 R917.2 R1617.1 137.56,152.97 v2(136.4,154.14) 133.2,154.14 132.55,154.79 Q306.3
+ADDR_XEN: length 3.9
  TOP w0.102: R393.1 139.01,154.86 v2(138.68,155.18)
  TOP w0.254: U18.3 139.57,155.53 139.46,155.41 139.46,154.44 R393.1
+AUX_EN: length 13
  TOP w0.457: v1(177.35,109.55) 177.35,109.07 177.91,108.51 177.91,107.85 177.25,107.19 177.25,106.99 176.4,106.14 v2(176.4,105.18) 176.4,104.46 v1(176.69,104.17)
  BOTTOM w0.381: v1(177.35,109.55) 176.97,109.93 Q310.3
  BOTTOM w0.508: Q38.3 176.06,105.08 176.63,105.65 R720.2 R1620.1 C632.1 177.27,104.68 176.76,104.17 v1(176.69,104.17)
+BL_PWR_SRC:
  vias: v1(65.07,148.46) v1(65.9,149.05) v1(66.53,149.05) v1(79.45,142.14) v1(79.45,141.5) v1(80.08,142.14) v1(80.08,141.5) v4(63.57,143.7)
+CAMERA_VDD: length 1
  BOTTOM w0.508: Q24.1 2.28,135.47 v1(2.59,135.17)
  vias: v2(1.32,137.11)
+CAP_LDO: length 5.2
  IN2 w0.508: v1(238.15,76.09) 238.15,78.6 v3(238,78.75)
  BOTTOM w0.33: U46.B46 238.33,76.27 v1(238.15,76.09)
  BOTTOM w0.508: v3(238,78.75) 238,80.23 C714.1
+CHAGER_SRC:
  vias: v2(200.33,44.39)
+CHGR_DC_IN: length 51.6
  TOP w0.102: v2(184.08,67.81) 184.39,68.11 v1(184.39,68.56)
  TOP w0.254: v1(172.69,70.3) 173.05,70.3 173.43,70.68 PU1001.35
  TOP w0.508: PR909.1 v1(184.12,35.88)
  IN1 w0.254: v1(184.39,68.56) 184.39,66.45 183.06,65.11 183.06,62.27 181.11,60.33 181.11,52.86 181.96,52.01 181.96,50.27 181.63,49.94 181.63,45.99 183.68,43.94 183.68,36.32 v1(184.12,35.88)
  IN4 w0.254: v1(184.39,68.56) 183.93,68.1 178.59,68.1 177.38,69.3 173.68,69.3 v1(172.69,70.3)
+COINCELL: length 3.9
  BOTTOM w0.102: PR1.1 49.47,100.36 v2(50.14,101.03)
  BOTTOM w0.508: PR1.1 49.61,99.75 JRTC1.1
+CRT_VCC: length 1.5
  TOP w0.508: v1(66.85,170.27) 66.94,170.19 C14.1
  BOTTOM w0.102: v1(75.03,170.16) v4(75.69,170.16)
  vias: v1(75.06,169.48)
+DC1_PWR_SRC:
  vias: v2(271.99,53.51)
+DC_IN: length 376.6
  TOP w0.508: PR1011.1 172.07,65.13 172.07,64.25 173.09,63.23 v1(175.47,63.23)
  IN1 w0.508: v1(164.18,17.21) 164.18,17.29 164.35,17.45 164.35,24.14 163.87,24.63 163.87,39.9 174.98,51.01 174.98,62.1 175.47,62.6 v1(175.47,63.23)
  IN2 w0.508: v1(164.18,17.21) 163.21,18.19 159.43,18.19 159.34,18.1 157.2,18.1 155.42,16.32 153.02,16.32 150.91,14.21 132.77,14.21 132.25,14.73 130.2,14.73 129.61,15.32 127.44,15.32 127.44,15.32 125.23,15.32 125.23,15.32 122.5,15.32 122.12,15.7 119.96,15.7 118.6,17.06 118.14,17.06 117.91,17.29 113.45,17.29 110.84,14.68 110.42,14.68 109.56,14.68 108.65,13.77 108.42,13.77 105.14,13.77 104.66,13.28 104.65,13.28 103.92,12.56 103.92,12.55 101.92,10.54 36.61,10.54 32.98,14.17 32.98,21.61 33.34,21.96 33.34,35.46 33.63,35.75 33.63,45.41 32.87,46.17 32.87,46.17 32.49,46.55 32.49,47.56 29.31,50.74 29.31,58.23 21.11,66.43 18.02,69.53 v1(18.02,73.29) ; v1(207.82,23.52) 207.82,44.45 204.68,47.59 203.19,47.59 201.06,49.71 197.05,49.71 196.49,49.14 196.49,48.7 195.98,48.2 195.54,48.2 195.53,48.18 192.33,48.18 191.88,48.63 187.09,48.63 186.03,47.56 186.03,46.88 183.58,44.43 v1(180.44,44.43)
  IN4 w0.508: v1(164.18,17.21) 164.26,17.29 164.41,17.29 166.6,19.47 166.6,23.69 165.78,24.5 165.78,34.05 167.41,35.67 167.41,39.44 172.4,44.43 v1(180.44,44.43)
  BOTTOM w0.102: v4(18.13,72.58) 18.02,72.7 v1(18.02,73.29) ; v1(180.44,44.43) v4(181.16,44.43)
  BOTTOM w0.508: v1(207.82,23.52) 208.47,22.87 226.74,22.87 v4(227.25,23.38) PR932.1
+DC_IN_SS: length 338.1
  TOP w0.508: v1(25.8,41.92) 25.8,41.96 26.78,42.94 26.78,44.2 25.75,45.23 25.75,56.71 24.83,57.63 3.1,57.63 2.34,58.4 2.34,66.03 1.29,67.07 1.29,70.83 3.88,73.41 PR18.1 ; PR1010.1 v1(170.15,70.93)
  IN1 w0.508: v1(184.14,35.1) 183.82,35.1 183.13,35.79 183.13,43.81 181.1,45.84 181.1,50.17 181.48,50.55 181.48,51.73 180.63,52.58 180.63,60.77 182.47,62.61 182.47,65.22 183.74,66.49 v1(183.74,69.77)
  IN2 w0.508: v1(184.14,35.1) 181.32,32.28 181.32,31.18 180.95,30.81 180.95,22.8 178.28,20.13 178.28,15.94 179.68,14.54 179.68,12.8 178.63,11.75 157.68,11.75 157.4,11.47 154.8,11.47 154.68,11.59 132.4,11.59 131.48,10.67 125.87,10.67 125.77,10.77 122.32,10.77 120.02,8.47 119.73,8.47 108.9,8.47 107.64,7.21 106.77,7.21 105.85,6.3 34.27,6.3 33.54,5.56 32.17,5.56 30.62,7.11 27.79,7.11 27.74,7.14 27.72,7.14 26.8,8.07 26.8,11.23 25.06,12.97 25.06,19.24 25.42,19.61 25.86,19.61 26.6,20.36 26.6,22.46 26.6,22.47 26.6,23.23 26.5,23.33 26.5,23.36 25.56,24.3 24.64,24.3 23.3,25.63 23.3,40.2 25.03,41.92 v1(25.8,41.92)
  IN4 w0.508: v1(183.74,69.77) 182.55,68.58 178.81,68.58 176.21,71.18 170.69,71.18 170.43,70.93 v1(170.15,70.93)
  BOTTOM w0.127: v1(25.8,41.92) 24.97,41.09 v4(24.97,40.63)
  BOTTOM w0.508: PD902.3 v1(184.14,35.1)
+DCIN: length 1.1
  BOTTOM w0.508: PD902.1 v1(180.19,35.75)
  vias: v2(180.06,34.76)
+DCIN_JACK: length 7.8
  TOP w0.102: v4(15.43,58.33) 15.17,58.59 15.17,60.29 ; 13.07,60.39 13.07,59.04 v4(12.89,58.87) ; 15.53,65.27 17.56,67.3 v4(17.56,68.54)
+DDR_CHG: length 3.4
  BOTTOM w0.102: v2(233.64,52.83) R927.2
  BOTTOM w0.508: R927.2 235.91,53.96 Q72.1
+DIMM0_1_CA_CPU: length 55.1
  TOP w0.381: 100.9,39.33 101.64,40.07 101.64,43.28 100.91,44.01 100.34,44.01 99.9,44.45 JCPU1.D1
  TOP w0.508: 100.9,39.33 99.92,38.35 RC88.2 99.29,36.1 v2(98.96,36.43) 98.69,36.7 v1(98.22,36.7) ; v1(121.68,19.95) 121.72,19.99 121.73,19.99 122.09,20.35 RD6.1 122.59,20.66 QD2.3
  IN4 w0.508: v1(121.68,19.95) 121.68,19.98 121.73,20.03 121.73,21.77 121.15,22.35 121.15,29.47 121.39,29.71 121.39,33.12 121.07,33.44 121.07,35.05 119.81,36.31 107.44,36.31 105.31,38.45 99.96,38.45 v1(98.22,36.7)
+DIMM0_1_VREF_CPU: length 60.1
  TOP w0.254: 97.48,39.69 97.42,39.75 97.42,41.94 96.91,42.45 JCPU1.B4
  TOP w0.508: RD5.1 122.33,14.82 QD1.3 123.85,15.67 123.24,16.28 123.24,16.56 v1(123.21,16.59) ; v1(98.28,35.84) 98.02,36.1 RC87.2 97.13,36.54 97.48,36.89 97.48,39.69
  BOTTOM w0.508: v1(98.28,35.84) v2(101.92,39.47) 109.49,39.47 118.45,30.51 121.91,30.51 123.02,29.4 123.02,28.3 121.24,26.51 121.24,25.16 119.21,23.14 119.21,17.83 120.82,16.22 122.91,16.22 123.21,16.52 v1(123.21,16.59)
+DIMM1_VREF_CA: length 8.9
  TOP w0.102: RD7.1 130.66,63.56 131.29,64.2 v2(131.29,64.62)
  TOP w0.356: JDIMM1.126 133.62,60.4 133.26,60.76 132.53,60.76 132,61.29 132,61.43 131.94,61.5
  TOP w0.508: 131.94,61.5 131.47,61.02 CD16.1 CD15.1 RD7.1
+DIMM1_VREF_DQ: length 40.1
  TOP w0.356: v1(145.91,20.85) 145.34,20.27 144.61,20.27 144.39,20.5 JDIMM1.1
  TOP w0.508: v1(128.74,17.15) 128.7,17.11 128.7,16.24 v2(128.81,16.13) RD1.2 RD2.2 129.85,14.75 CD1.1 130.67,14.76 CD6.1
  BOTTOM w0.508: v1(145.91,20.85) 144.79,19.72 144.79,15.61 141.25,12.08 132.15,12.08 131.61,11.53 128.68,11.53 127.56,12.65 127.56,15.96 v1(128.74,17.15)
+DIMM2_VREF_CA: length 22.3
  IN4 w0.508: v1(145.13,60.9) 145.13,61.48 144.61,62 141.62,62 141.54,61.93 137.51,61.93 137.15,62.29 132.76,62.29 131.55,63.51 v1(131.55,63.59)
  BOTTOM w0.102: CD42.1 v2(131.53,61.02)
  BOTTOM w0.254: JDIMM2.126 144.12,60.4 144.26,60.26 144.75,60.26 145.13,60.64 v1(145.13,60.9)
  BOTTOM w0.508: v1(131.55,63.59) 130.6,63.59 RD16.1 130.62,63.04 130.86,62.81 CD41.1 130.86,61.82 130.62,61.58 CD42.1
+DIMM2_VREF_DQ: length 1
  BOTTOM w0.127: RD14.2 v2(127.65,22.45)
+DIMM3_VREF_CA: length 24.9
  TOP w0.102: v2(161.68,64.11) RD25.1
  TOP w0.254: v1(145.79,60.9) 145.79,60.49 146.27,60.02 147.04,60.02 147.42,60.4 JDIMM3.126
  TOP w0.508: v1(160.97,63.06) RD25.1 161.69,63.04 CD63.1 161.68,61.77 CD64.1
  IN4 w0.508: v1(145.79,60.9) 145.79,61.28 146.34,61.82 153.95,61.82 154.29,61.48 157.91,61.48 158.82,62.4 160.31,62.4 v1(160.97,63.06)
+DIMM3_VREF_DQ: length 10.3
  TOP w0.127: v2(165.62,22.66) 165.41,22.45 RD23.2
  TOP w0.356: JDIMM3.1 158.42,20.5 158.8,20.12 158.8,20.02
  TOP w0.508: RD23.2 RD24.2 CD45.1 CD49.1 161.4,21.32 160.2,20.12 158.9,20.12 158.8,20.02
+DIMM4_VREF_CA: length 7.9
  BOTTOM w0.127: v2(161.68,63.92) RD34.1
  BOTTOM w0.356: CD86.1 161.56,60.4 JDIMM4.126
  BOTTOM w0.508: CD86.1 161.69,60.53 CD85.1 161.68,61.8 RD34.1
+DIMM4_VREF_DQ: length 22.7
  BOTTOM w0.127: RD32.2 165.41,22.45 v2(165.61,22.64)
  BOTTOM w0.508: JDIMM4.1 149.67,20.5 151.53,18.63 151.53,17.01 151.84,16.7 157.53,16.7 160.35,19.52 160.35,21.45 CD68.1 161.43,22.45 CD67.1 RD33.2 RD32.2
+DOCK_PWR_BAR: length 148.2
  TOP w0.508: PR1007.1 v1(170.15,71.95)
  IN1 w0.508: v1(182.23,36.4) 182.23,43.84 180.47,45.61 180.47,50.58 180.87,50.98 180.87,51.44 180.02,52.29 180.02,61.24 181.66,62.88 181.66,65.43 183.07,66.84 183.07,74.76 181.91,75.92 v1(181.91,77.2)
  IN2 w0.508: v1(158.18,121.34) 158.46,121.06 158.46,120.04 153.5,115.09 140.7,115.09 v1(140.64,115.02)
  BOTTOM w0.508: PD902.2 v1(182.23,36.4) ; v1(158.18,121.34) 159.45,120.07 159.45,112.12 157.3,109.97 157.3,100.08 154.67,97.45 v2(154.67,96.33) 154.81,96.19 154.81,93.83 155.51,93.13 155.51,91.06 159.17,87.4 167.94,87.4 168.46,86.89 171.14,86.89 171.14,86.88 173.25,86.88 176.74,83.39 177.17,83.39 181.91,78.65 v1(181.91,77.2) 180.21,75.5 174.26,75.5 173.8,75.04 173.8,72.63 173.11,71.95 v1(170.15,71.95)
  vias: v1(77.91,128.68) v1(78.55,128.68) v1(79.18,128.68) v1(79.82,128.68) v1(120.53,118.49) v1(134.2,115.88) v1(134.2,115.24) v1(134.83,115.88) v1(134.83,115.24) v1(135.47,115.88) v1(135.47,115.24) v1(136.1,115.88) v1(136.1,115.24) v1(136.74,115.88) v1(136.74,115.24) v1(137.37,115.88) v1(137.37,115.24) v1(138.01,115.88) v1(138.01,115.24) v1(138.64,115.88) v1(138.64,115.24) v1(139.34,115.86) v1(139.34,115.23) v1(139.98,115.23)
+DP_VCC: length 1
  TOP w0.102: C313.1 v2(290.39,141.28)
+EDPVDD: length 21
  TOP w0.508: C305.1 68.57,153.67 67.75,154.48 67.75,157.73 66.95,158.53 v1(66.95,158.61)
  IN2 w0.508: v1(66.95,158.61) 66.42,159.14 64.31,159.14 63.66,159.79 62.42,159.79 60.93,158.31 v1(60.51,158.31)
  BOTTOM w0.508: Q12.4 67.27,158.3 v1(66.95,158.61) 66.7,158.86 66.7,159.33 v2(66.78,159.41) 66.78,160.57 67.44,161.23 69.43,161.23 69.98,161.78 R161.1
  vias: v1(60.51,157.67)
+ENAB_3VLAN: length 6.4
  TOP w0.102: v2(137.04,144.13) C477.1
  TOP w0.508: Q34.3 136.14,143 136.21,143.07 C477.1 R1638.1 R564.2 137.04,140.6 136.86,140.42 Q297.3
+LCDVDD: length 13.3
  TOP w0.508: C298.1 77.15,140.4 77.15,142.01 76.82,142.34 76.17,142.34 76.03,142.48
  IN3 w0.508: v1(76,145.38) v1(75.36,145.38) 74.92,145.38 72.71,147.59 71.44,147.59 70.69,148.34 70.69,149.25 70.83,149.39 v1(70.83,149.9)
  BOTTOM w0.508: R413.1 71.95,149.67 71.05,149.67 v1(70.83,149.9)
  vias: v1(75.36,144.74) v1(76,144.74) v4(75.88,145.99)
+LCVDVDD_CHG: length 1.5
  BOTTOM w0.254: R413.2 72.49,151.11 71.67,150.29 Q19.6
+LOM_VCT: length 4.7
  TOP w0.102: v2(113.54,126.34) C701.1
  TOP w0.508: v1(112.63,125.4) 112.63,126.32 C701.1
  BOTTOM w0.254: JDOCK1.116 112.24,125.8 v1(112.63,125.4) 112.75,125.52 112.75,126.69 JDOCK1.118
+MISC_PWREN: length 7.2
  TOP w0.102: v2(158.07,158.61) Q44.3
  TOP w0.254: R1628.1 R731.2 C651.1 158.9,156.82 158.69,156.6 158.18,156.6 158.11,156.67 Q312.3 157.77,156.85 156.75,157.86 Q44.3
+MXM_PWR:
  vias: v1(182.31,170.71) v1(182.31,170.08) v1(182.33,169.42) v1(182.33,168.78) v1(182.33,168.15) v1(182.33,167.51) v1(182.32,166.8) v1(182.94,170.71) v1(182.94,170.08) v1(182.98,169.36) v1(182.98,168.72) v1(182.98,168.09) v1(182.98,167.45) v1(182.98,166.82) v1(183.58,170.08) v1(183.62,169.36) v1(183.62,168.72) v1(183.62,168.09) v1(183.62,167.45) v1(183.67,166.76) v4(182.73,166.05)
+MXM_PWR_R: length 4.2
  TOP w0.254: PR14.2 170.94,174.3 PC6.2 170.6,174.32 170.18,173.9 v3(169.95,173.9) U59.4
  BOTTOM w0.254: v3(169.95,173.9) 169.94,173.9 169.79,173.75 R2180.1
+MXM_PWR_SRC: length 2.8
  BOTTOM w0.102: v1(178.66,174.69) v4(178.66,174.09)
  BOTTOM w0.508: v1(176.67,173.32) 176.34,172.99 C776.1 v1(177.49,172.43)
  vias: v1(176.73,173.95) v1(177.39,175.32) v1(177.39,174.69) v1(177.37,173.95) v1(177.34,173.3) v1(178.03,175.32) v1(178.03,174.69) v1(178.03,173.98) v1(178.03,173.29) v1(178.66,175.32) v1(178.7,173.3) v1(179.3,175.32) v1(179.3,174.69) v1(179.31,173.98) v1(179.35,173.32) v1(179.93,175.32) v1(179.93,174.69) v1(180.57,175.32) v1(180.57,174.69) v1(181.27,175.34) v1(200.43,171.2) v1(200.53,173.23) v1(200.51,172.53) v1(200.51,171.9) v1(201.1,171.2) v1(201.17,173.23) v1(201.14,172.53) v1(201.14,171.9) v1(201.78,172.53) v1(201.78,171.9) v1(201.78,171.26) v1(202.41,172.53) v1(202.41,171.9) v1(202.41,171.26) v1(203.05,172.53) v1(203.05,171.9) v1(203.05,171.26) v1(203.73,172.52) v1(203.73,171.88) v1(203.73,171.25)
+MXM_PWR_SRC_A0: length 4
  TOP w0.102: R2185.1 v2(153.66,176.02)
  TOP w0.254: U60.7 154.86,174.17 154.82,174.13 R2187.2 R2185.1
+MXM_PWR_SRC_A1: length 4.2
  TOP w0.102: v2(153.66,171.16) R2186.2
  TOP w0.254: R2186.2 R2184.1 154.07,173.52 U60.8
+MXM_PWR_SRC_R: length 6.1
  TOP w0.254: U59.5 v1(169.85,174.55) 170.05,174.55 170.34,174.84 171.31,174.84 PC6.1 171.84,174.31 PR24.2
  BOTTOM w0.102: v2(169.92,175.4) 169.85,175.32 v1(169.85,174.55)
  BOTTOM w0.254: v1(169.85,174.55) 169.72,174.68 R2181.1
+MXM_SRC_EN#: length 11.1
  BOTTOM w0.102: C774.1 v2(186.68,173.33)
  BOTTOM w0.508: Q186.4 184.87,167.83 184.36,168.34 184.36,172.01 184.94,172.58 185.32,172.58 185.77,173.04 C774.1 R940.2 184.47,173.33 184,173.8 Q87.1
+NBDOCK_DC_IN_SS: length 121.9
  TOP w0.508: v1(149.78,109.63) 149.07,109.63 148.56,109.12 v2(148.56,105.41) 148.56,103.51 148.92,103.15 148.92,95.57 149.5,94.98 149.57,94.98 149.91,94.64 v1(150.57,94.64) ; PR1024.2 179.42,80.24 v1(179.16,80.51)
  IN2 w0.508: v1(179.16,80.51) 179.16,82.46 173.8,87.82 173.8,88.62 171.65,90.77 155.47,90.77 151.6,94.64 v1(150.57,94.64) ; v1(149.78,109.63) 149.77,109.61 129.69,109.61 128.37,110.94 107.74,110.94 104.67,114 104.67,117.25 103.02,118.9 96.59,118.9 94.8,120.69 v1(92.04,120.69)
  BOTTOM w0.254: v1(92.04,120.69) 92.04,120.13 91.74,119.83 JDOCK1.41
+NVRAM_PWREN: length 7.2
  TOP w0.508: R737.2 17.53,150.56 R1629.1 ; 16.03,150.32 16.03,151.05 C652.1 R1629.1 ; 16.03,150.32 15.69,149.99 14.87,149.99 14.51,150.35 Q46.3 ; 16.03,150.32 v2(16.03,150.25) ; Q313.3 17.95,151.78 17.39,151.23 R1629.1
+PCH_V5REF_RUN: length 15.6
  TOP w0.254: UH4.P34 24.64,121.1 24.73,121.18 24.73,121.65 v1(24.75,121.68)
  IN1 w0.508: v1(24.75,121.68) 24.75,121.26 24.11,120.63 18.71,120.63 17.82,121.51 14.67,121.51 13.12,123.06 12.41,123.06 12.04,123.43 12.04,123.48 v1(11.99,123.53)
  vias: v2(12.05,124.08)
+PCH_V5REF_SUS: length 15.4
  TOP w0.254: UH4.M26 23.22,116.85 23.01,117.06 23.01,117.29 v1(22.99,117.31)
  IN1 w0.381: v1(22.99,117.31) 22.86,117.19 22.86,117.08 22.54,116.76 18.37,116.76 17.85,116.23 16.09,116.23 15.97,116.36 14.24,116.36 13.75,116.84 11.9,116.84 v1(11.52,116.46)
  BOTTOM w0.102: RH208.2 10.74,120.46 9.99,120.46 9.36,121.1 v2(9.36,121.11)
+PCH_VCCDSW: length 1.6
  TOP w0.254: UH4.V12 26.46,109.7 v1(26.67,109.7)
  BOTTOM w0.508: v1(26.67,109.7) 26.38,109.7 25.99,109.3 CH57.1
+PECI_VREF: length 6.5
  TOP w0.305: U54.B51 171.56,151.13 171.91,151.47
  TOP w0.508: R862.1 C737.1 174.88,153.99 v2(174.69,153.8) 174.69,153.81 172.85,151.97 172.4,151.97 171.91,151.47
+PWR_SRC: length 67.6
  TOP w0.508: v1(150.11,108.12) 150.44,108.44 C258.2 ; C257.2 164.37,96.65 v1(164.25,96.52) ; PR1029.2 v1(183.81,72.96)
  IN4 w0.508: 252.97,53.71 252.96,53.7 252.96,44.77 253.59,44.13 257.66,44.13 262.74,39.05 285.47,39.05 286.74,40.32 286.74,49.34 284.96,51.12 v1(284.96,54.67)
  BOTTOM w0.508: C260.1 33.83,15.23 v1(33.98,15.38) ; PD100.1 283.44,56.2 v1(284.96,54.67)
  vias: v1(17.3,91.55) v1(17.28,90.87) v1(18.01,92.27) v1(18.01,91.63) v1(18.01,91) v1(18.01,90.36) v1(18.64,92.01) v1(18.64,91.38) v1(18.64,90.74) v1(19.28,92.01) v1(19.28,91.38) v1(19.66,90.87) v1(19.91,92.01) v1(20.04,91.38) v1(20.55,92.01) v1(23.67,147.35) v1(23.68,146.7) v1(24.32,146.72) v1(24.34,147.36) v1(33.98,17.83) v1(34,16.92) v1(33.97,16.02) v1(36.82,53.47) v1(36.84,52.78) v1(36.84,52.13) v1(36.84,51.49) v1(37.49,53.35) v1(37.5,52.67) v1(37.5,52.02) v1(37.5,51.36) v1(38.14,52.02) v1(38.14,51.37) v1(38.15,53.34) v1(38.15,52.65) v1(62.08,13.02) v1(62.71,13.02) v1(63.35,13.02) v1(63.98,13.02) v1(75.87,141.69) v1(75.87,141.06) v1(76.5,141.69) v1(76.5,141.06) v1(136.47,108.83) v1(136.5,108.14) v1(137.11,108.83) v1(137.13,108.14) v1(137.74,108.83) v1(137.77,108.14) v1(138.61,108.83) v1(138.63,108.14) v1(139.39,108.78) v1(139.39,108.14) v1(140.03,108.78) v1(140.03,108.14) v1(140.66,108.78) v1(140.66,108.14) v1(141.3,108.78) v1(141.3,108.14) v1(182.5,48.45) v1(182.5,47.75) v1(182.48,47.09) v1(182.51,46.43) v1(182.47,25.08) v1(182.47,24.19) v1(182.47,23.43) v1(182.47,22.67) v1(183.04,49.09) v1(183.15,48.43) v1(183.15,47.79) v1(183.15,47.16) v1(183.15,46.52) v1(183.23,25.08) v1(183.23,24.19) v1(183.23,23.43) v1(183.23,22.67) v1(183.81,49.09) v1(183.81,48.45) v1(183.81,47.82) v1(183.81,47.18) v1(183.81,46.55) v1(184,25.08) v1(184,24.19) v1(184,23.43) v1(184,22.67) v1(184.5,48.45) v1(184.5,47.82) v1(184.5,47.18) v1(184.76,25.08) v1(184.76,24.19) v1(184.76,23.43) v1(184.76,22.67) v1(185.27,48.45) v1(185.27,47.82) v1(185.27,47.18) v1(196.82,38.55) v1(196.82,37.78) v1(196.82,37.02) v1(196.82,36.26) v1(196.82,35.5) v1(197.2,34.74) v1(197.2,34.1) v1(197.71,35.5) v1(197.97,34.74) v1(197.97,34.1) v1(211.92,29.44) v1(212.56,29.44) v1(213.19,29.44) v1(213.83,29.44) v1(214.46,29.44) v1(261.97,58.36) v1(261.97,57.6) v1(261.97,56.83) v1(261.97,56.07) v1(261.97,55.31) v1(261.97,54.55) v1(262.61,58.36) v1(262.61,57.6) v1(262.61,56.83) v1(262.61,56.07) v1(262.61,55.31) v1(262.61,54.55) v4(201.18,35.54)
+PWR_SRC_MXM: length 6.8
  BOTTOM w0.508: R940.1 184.76,175.25 185.25,175.74 186.12,175.74 187.22,174.64 187.22,172.02 v1(187.26,171.98)
  vias: v1(184.76,51.88) v1(185.39,51.88) v1(186.03,51.82) v1(186.19,52.45) v1(186.7,51.82) v1(186.92,53.07) v1(186.92,52.44) v1(187.27,171.3) v1(187.26,170.63) v1(187.26,169.99) v1(187.26,169.36) v1(187.26,168.72) v1(187.31,168.06) v1(187.68,53.07) v1(187.68,52.44) v1(187.89,171.98) v1(187.91,171.3) v1(187.89,170.63) v1(187.89,169.99) v1(187.89,169.36) v1(187.89,168.72) v1(188,168.03) v1(188.53,170.63) v1(188.53,169.99) v1(188.53,169.36) v1(188.53,168.72) v1(188.44,53.07) v1(188.44,52.44) v1(188.54,171.3) v1(188.63,168.03) v1(189.2,53.07) v1(189.2,52.44) v1(189.97,53.07) v1(189.97,52.44) v1(190.73,53.02) v2(188.43,171.86)
+PWR_SRC_S: length 988.1
  TOP w0.508: v1(139.72,152.48) 139.72,152.38 139.3,151.96 R917.1 ; v1(28.42,15.94) 28,15.94 27.68,15.62 R515.1 ; v1(162.42,160.53) 162.42,160.24 161.3,159.12 160.72,159.12 160.12,158.52 R731.1 ; RC73.1 119.84,50.36 120.64,49.56 120.64,47.56 119.04,45.96 114.3,45.96 114.01,46.25 113.43,46.25 109.83,42.65 109.83,24.45 107.73,22.35 v1(107.73,21.29) ; v1(129.32,139.81) 129.32,138.43 128.61,137.72 128.61,133.97 130.53,132.06 130.53,128.59 132.55,126.57 v1(132.88,126.57) 132.88,126.58 133.22,126.92 135.55,126.92 135.99,126.48 135.99,120.23 135.7,119.94 133.79,119.94 133.5,119.65 PC8.1 130.94,118.94 PQ4.1 130.91,119.86 v1(131.15,120.1) ; R499.1 185.77,55.94 v1(185.39,55.56) ; R564.1 138.63,141.03 v1(138.73,141.14) ; v1(202.27,66.54) 202.27,66.42 203.9,64.8 203.9,57.48 205.4,55.98 v1(205.78,55.98) ; v1(71.74,153.24) 72.24,152.74 75.33,152.74 78.23,155.64 78.23,159.8 76.39,161.65 74.93,161.65 v1(73.94,162.64) ; R722.1 v1(104.42,131.64) ; R737.1 18.86,152.33 v1(18.93,152.4) ; R275.1 v1(193.9,170.17) ; R930.1 46.84,128.36 47.27,127.93 v1(48.51,127.93) ; v1(170.15,114.03) 172.35,114.03 173.68,112.7 173.68,112.7 176.21,110.18 176.21,107.47 v1(175.96,107.22) ; v1(130.02,29.5) 130.01,29.49 130.01,29.36 129.67,29.02 R911.1 ; RH357.2 6.49,120.75 v1(6.09,121.15)
  IN1 w0.508: v1(205.52,52.22) 205.62,52.32 205.62,55.83 v1(205.78,55.98) ; v1(6.09,121.15) 6.77,121.82 6.77,134.48 8.73,136.44 8.98,136.44 10.01,137.47 v1(10.01,138.37) 10.4,138.37 12.56,140.53 12.56,142.39 13.65,143.49 14.58,143.49 16.13,145.03 16.13,149.54 18.93,152.35 v1(18.93,152.4) ; v1(293,53.1) 297.61,48.49 297.61,23 295.4,20.79 278.82,20.79 273.3,26.3 213.46,26.3 206.6,33.16 206.6,39.47 v1(205.51,40.56)
  IN2 w0.508: v1(178.29,57.34) 178.94,56.69 184.91,56.69 185.39,56.21 v1(185.39,55.56) 185.77,55.94 190.31,55.94 191.47,54.78 193.21,54.78 193.99,54 204.34,54 205.54,52.81 205.54,52.24 v1(205.52,52.22) ; v1(125.32,126.56) 125.58,126.81 129.3,126.81 130.11,126 132.31,126 v1(132.88,126.57) ; v1(28.92,8.45) 28.92,8.03 28.68,7.79 27.98,7.79 27.52,8.24 27.52,15.42 28.04,15.94 v1(28.42,15.94) ; v1(131.15,120.1) 132.01,119.24 132.01,116.23 132.14,116.1 132.14,115.3 132.9,114.54 132.9,114.35 133.26,114 155.13,114 157.07,115.94 165.63,115.94 167.33,114.24 169.95,114.24 v1(170.15,114.03) ; v1(37.31,154.81) 37.22,154.9 31.62,154.9 29.16,152.44 18.97,152.44 v1(18.93,152.4) ; v1(140,145.85) 139.08,146.77 130.13,146.77 128.45,148.45 117.56,148.45 116.46,147.35 116.46,146.86 115.92,146.32 105.65,146.32 104.47,147.5 92.3,147.5 91.86,147.95 81.04,147.95 80.68,148.3 78.31,148.3 75.61,150.99 73.43,150.99 72.87,151.55 72.87,152.11 v1(71.74,153.24) 71.72,153.26 68.85,153.26 67.03,151.45 v1(66.33,151.45) 66.33,152 64.99,153.34 47.63,153.34 47.58,153.29 47.55,153.29 47.35,153.09 47.34,153.09 45.91,151.65 42.49,151.65 42.07,152.07 40.07,152.07 39.5,151.5 37.41,151.5 v1(35.93,150.01) ; v1(156.42,157.25) 155.82,156.65 155.82,154.61 155.1,153.89 153.25,153.89 152.08,152.72 147.4,152.72 146.38,153.73 144.46,153.73 143.53,152.81 141.83,152.81 141.46,153.18 140.04,153.18 139.72,152.86 v1(139.72,152.48)
  IN3 w0.508: v1(42.96,12.54) 40.42,12.54 39.21,11.32 34.35,11.32 33.12,10.1 30.57,10.1 v1(28.92,8.45) ; v1(14.95,131.46) 14.64,131.46 13.52,132.58 13.52,135.89 11.05,138.37 v1(10.01,138.37) ; v1(199.16,76.62) 199.16,69.53 202.27,66.42 v1(202.27,66.54) ; v1(37.31,154.81) 35.91,153.42 35.91,150.03 v1(35.93,150.01) 35.36,149.44 v1(35.36,144.89) ; v1(205.51,40.56) 204.81,41.26 204.81,49.14 205.94,50.27 205.94,51.79 205.52,52.21 v1(205.52,52.22) ; v1(35.39,140.65) 35.39,140.42 39.65,136.17 39.65,136.08 44.58,131.15 44.58,130.34 46.99,127.93 v1(48.51,127.93) ; v1(178.29,57.34) 176.44,59.2 176.44,64.91 173.53,67.82 173.53,75.36 172.19,76.71 172.19,79.48 172.77,80.06 172.77,91.33 173.01,91.57 173.01,92.48 173.51,92.98 173.76,92.98 v1(173.85,93.07)
  IN4 w0.508: 161.24,159.35 v1(162.42,160.53) ; 161.24,159.35 158.53,159.35 v1(156.42,157.25) ; 161.24,159.35 164.6,159.35 164.84,159.6 165.34,159.6 166,160.26 166,161.13 167.31,162.45 169.65,162.45 170.48,161.61 170.48,161.2 171.92,159.77 175.66,159.77 177.14,161.24 177.14,162.17 177.95,162.98 177.95,163.47 178.87,164.39 190.93,164.39 191.35,163.97 v1(191.35,163.75) ; v1(130.02,29.5) 130.02,29.31 130.5,28.83 132.87,28.83 133.1,29.06 135.44,29.06 136.81,30.43 148.54,30.43 149.58,31.47 149.58,35.49 151.34,37.25 156.49,37.25 157.17,37.94 157.17,40.58 159.49,42.89 160.54,42.89 161.65,44.01 161.65,48.66 164.89,51.89 164.89,52.36 165.94,53.4 168.67,53.4 172.47,57.2 178.15,57.2 v1(178.29,57.34) ; v1(42.96,12.54) 42.98,12.54 43.72,13.28 56.89,13.28 58.74,11.43 91.16,11.43 96.53,16.8 96.53,20.02 98.7,22.19 106.83,22.19 v1(107.73,21.29) 107.73,21.05 107.61,20.93 107.61,14.55 107.97,14.19 109.07,14.19 113.46,18.58 121.79,18.58 123.07,17.3 123.4,17.3 v1(123.59,17.11) ; v1(129.32,139.81) 133.91,139.81 135.23,141.14 v1(138.73,141.14)
  BOTTOM w0.102: v4(29.04,15.47) 28.57,15.94 v1(28.42,15.94)
  BOTTOM w0.508: v1(293,53.1) 292.55,52.66 R920.1 ; v1(139.72,152.48) 139.72,152.35 139.23,151.85 139.23,150.05 140,149.28 v1(140,145.85) 140,142.79 138.73,141.52 v1(138.73,141.14) ; R412.1 66.93,152.04 v1(66.33,151.45) ; v1(73.94,162.64) 73.2,161.9 R158.1 ; v1(35.36,144.89) 35.36,144.77 36,144.12 36,141.26 v1(35.39,140.65) ; R905.1 14.77,131.64 14.95,131.46 v1(14.95,131.46) ; v1(123.59,17.11) 123.59,17.23 122.66,18.17 122.66,21.82 124.57,23.73 124.57,23.74 126.13,25.3 126.13,27.54 128.1,29.5 v1(130.02,29.5) ; v1(191.35,163.75) 191.37,163.78 193.38,163.78 193.75,164.15 193.75,166.8 193.51,167.04 193.51,169.77 v1(193.9,170.17) ; v1(205.52,52.22) 205.57,52.22 206.09,52.74 R906.1 ; R269.1 197.97,77.61 198.96,76.62 v1(199.16,76.62) ; v1(104.42,131.64) 104.96,131.09 121.42,131.09 125.28,127.23 125.28,126.59 v1(125.32,126.56) ; v1(173.85,93.07) 173.9,93.12 174.31,93.52 174.31,99.45 172.97,100.79 172.03,100.79 170.43,102.39 170.43,104.14 172.01,105.72 175.49,105.72 176,106.22 176,107.19 v1(175.96,107.22) R720.1
+RSVD_VCC3P3_1: length 6.5
  TOP w0.102: R553.2 v2(118.69,168.28)
  TOP w0.203: U31.1 120.61,163.05 120.38,163.27 120.38,164.78 119.26,165.9 119.26,166.62 R553.2
+RSVD_VCC3P3_2: length 4.8
  TOP w0.203: U31.2 120.58,162.65 119.99,163.23 v2(119.99,163.7) 119.99,164.72 118.69,166.02 R554.2
+RTC_CELL: length 519.3
  TOP w0.254: v1(16.52,114.38) 16.52,114.53 16.86,114.86 UH4.A22 ; U18.21 146.09,161.08 146.47,160.71 147.06,160.71 C336.1
  TOP w0.381: U10.5 144.01,167.75 144.25,167.51 144.65,167.51 C287.1
  TOP w0.508: v1(11.83,112.66) 11.83,112.45 12.34,111.95 12.96,111.95 RH127.2 ; RH11.1 9.85,117.41 v1(9.6,117.67) ; C287.1 v1(146,167.99) ; v1(146.49,161.7) 146.49,161.48 147.13,160.85 C336.1 ; v1(159.89,156.13) 160.8,155.22 R1156.2 ; v1(154.99,154.75) 154.99,154.15 155.64,153.51 157.26,153.51 R819.1 ; v1(9.12,111.3) 9.14,111.3 9.17,111.28 9.75,111.28 RH38.1 ; v1(143.38,166.4) R390.2
  IN1 w0.508: v1(159.89,156.13) 159.85,156.13 158.79,155.07 156.25,155.07 155.84,154.66 155.08,154.66 v1(154.99,154.75)
  IN2 w0.508: v1(143.38,166.4) 143.38,167.77 143.6,167.99 v1(146,167.99) ; v1(11.83,112.66) 11.83,112 11.62,111.79 10.53,111.79 10.04,111.3 v1(9.12,111.3) ; v1(204.63,104.26) 205.42,105.05 205.42,118.61 204.43,119.6 204.43,127.79 203.33,128.89 203.33,131.28 204.43,132.39 204.43,135.81 202.78,137.47 201.93,137.47 201.52,137.87 201.52,139.74 202.22,140.44 202.22,144.37 199.57,147.03 199.57,153.62 197.31,155.88 196.01,155.88 195.65,156.24 190.94,156.24 189.51,157.67 185.2,157.67 184.96,157.43 178.82,157.43 178.58,157.67 167.6,157.67 165.91,159.36 161.24,159.36 160.58,158.7 160.58,158.17 161.8,156.95 161.8,156.85 v1(161.92,156.72) ; v1(21.6,97.61) 21.6,97.41 22.24,96.77 23.43,96.77 23.95,96.25 26.72,96.25 27.42,95.56 27.42,94.49 27.65,94.26 29.59,94.26 30.02,94.69 32.52,94.69 32.6,94.62 36.08,94.62 36.22,94.48 37.35,94.48 37.85,94.97 37.86,94.97 38.82,95.92 42.28,95.92 42.56,95.64 43.25,95.64 43.42,95.81 v1(45.22,95.81) 45.39,95.97 50.67,95.97 51.46,96.76 58.91,96.76 59.93,95.74 59.93,94.92 60.3,94.55 63.17,94.55 63.56,94.93 64.81,94.93 65.29,95.42 65.83,95.42 66.25,95 75.66,95 77.28,96.62 83.06,96.62 83.3,96.86 108.49,96.86 111.03,94.32 130.4,94.32 135.27,99.2 148.91,99.2 150.84,97.27 156.65,97.27 156.88,97.5 170.71,97.5 171.51,96.69 171.51,95.78 171.84,95.45 171.84,93.17 173.09,91.92 173.09,90.25 173.91,89.42 175.56,89.42 182.81,82.17 182.81,74.16 183.07,73.91 183.07,62.73 184.24,61.56 184.84,61.56 184.95,61.44 186.93,61.44 188.7,63.21 193.24,63.21 194.16,62.29 197.9,62.29 198.83,63.22 v1(198.83,63.28)
  IN3 w0.254: 205.51,97.77 204.8,97.05 202.61,97.05 202.57,97.01 202.45,97.01 201.69,96.25 201.69,96.25 202.07,95.87 204.86,95.87 205.51,96.52 205.51,97.77 ; 205.51,97.77 205.47,97.8
  IN3 w0.381: v1(12.48,115.61) 12.48,115.57 12.51,115.54 12.51,113.74 12.11,113.35 12.11,113.07 11.83,112.79 v1(11.83,112.66)
  IN3 w0.508: 7.75,109.91 7.75,109.87 7.45,109.58 7.07,109.58 6.86,109.37 6.32,109.37 6.03,109.08 6.03,105.88 v1(7.33,104.59) ; 7.75,109.91 7.55,109.91 6.81,110.65 6.15,110.65 5.78,111.02 5.78,115.85 7.87,117.95 7.95,118.07 8.76,118.87 10.96,118.87 11.59,118.24 12.68,118.24 v1(12.69,118.24) ; 7.75,109.91 7.75,110.55 8.42,111.23 9.05,111.23 v1(9.12,111.3) ; 205.47,97.8 205.47,99.8 205.08,100.19 203.29,100.19 202.67,100.82 202.67,100.91 202.14,101.43 202.14,102.16 202.08,102.22 202.08,103.23 202.61,103.76 204.13,103.76 v1(204.63,104.26) ; v1(198.83,63.28) 198.8,63.31 198.79,63.31 198.08,64.02 198.08,68.34 198.02,68.4 198.02,78.42 198.74,79.15 198.74,84.01 197.53,85.22 197.53,89.96 197.6,90.03 197.6,93.54 198.46,94.41 198.46,94.85 198.81,95.2 200.9,95.2 201.82,96.12 ; v1(143.38,166.4) 143.2,166.4 141.9,165.1 141.9,164.03 144.19,161.74 146.45,161.74 v1(146.49,161.7)
  IN4 w0.508: v1(165.34,156.64) 165.31,156.62 165.31,156.4 164.94,156.03 164.42,156.03 163.73,156.72 v1(161.92,156.72) 161.26,156.72 161.23,156.74 160.56,156.74 159.95,156.13 v1(159.89,156.13) ; v1(146.49,161.7) 146.63,161.56 147.29,161.56 148.06,160.8 148.06,157.48 148.42,157.11 149.31,157.11 152.88,153.54 154.52,153.54 154.99,154.01 v1(154.99,154.75) ; v1(12.69,118.24) 12.66,118.24 12.63,118.21 11.83,118.21 10.98,117.36 9.92,117.36 9.62,117.67 v1(9.6,117.67)
  BOTTOM w0.508: v1(21.6,97.61) 21.6,97.68 20.41,98.87 19.56,98.87 19.28,98.59 19.28,98.16 16.88,95.76 16.88,94.36 15.86,93.35 13.03,93.35 11.82,94.55 9.76,94.55 8.76,95.56 8.76,98.67 8.39,99.04 8.39,103.02 v2(7.85,103.57) 7.85,104.06 v1(7.33,104.59) ; v1(45.22,95.81) 45.19,95.85 45.19,98.48 PD1.1 44.12,98.97 43.47,98.32 PC2.1 ; v1(154.99,154.75) 154.99,154.62 154.86,154.5 154.86,153.52 155.74,152.64 R810.1 ; RH23.1 15.56,117.22 14.64,117.22 13.68,118.19 12.74,118.19 v1(12.69,118.24) ; v1(12.48,115.61) 13.38,115.61 13.53,115.76 14.36,115.76 14.62,115.5 14.62,115.5 14.99,115.13 15.02,115.13 15.82,114.33 RH22.1 15.89,114.38 v1(16.52,114.38) 16.71,114.57 CH88.1 CH90.1 17.2,112.79 CH89.1 ; R870.1 164.95,156.04 165.3,156.39 165.3,156.51 165.31,156.52 165.31,156.62 v1(165.34,156.64) ; v1(161.92,156.72) 162.24,156.72 162.66,156.3 R1156.2
+RTC_CELL_VBAT: length 6
  TOP w0.305: v1(165.09,150.85) 165.09,151.09 164.72,151.45 U54.B64
  BOTTOM w0.508: R815.2 C745.1 163.68,153.76 v2(164.25,153.19) 164.98,152.45 164.98,150.95 v1(165.09,150.85)
+SDC_IN: length 311.9
  TOP w0.508: PC901.1 5.51,100.85 5.34,101.02 5.27,101.02 5.27,101.03 3.61,101.03 3.43,100.85 3.08,100.85 2.73,100.49 2.73,94.02 3.83,92.91 v1(4,92.91) ; PR1015.1 177.9,65.68 178.29,65.29 v1(178.41,65.29) ; PR913.2 169.26,35.65 168.39,36.53 v1(164.98,36.53)
  IN1 w0.508: v1(165.57,16.66) 165.57,17.12 166.6,18.15 166.6,23.89 165.26,25.22 165.26,36.25 v1(164.98,36.53) 164.98,39.47 176.12,50.61 176.12,61.54 177.02,62.45 177.02,63.98 178.33,65.29 v1(178.41,65.29)
  IN2 w0.508: v1(129.32,13.08) 129.32,13.82 129.04,14.1 125.73,14.1 125.73,14.1 121.73,14.1 121.35,14.48 119.46,14.48 118.09,15.84 117.63,15.84 117.41,16.07 113.95,16.07 111.35,13.46 110.28,13.46 109.37,12.55 107.92,12.55 107.2,12.55 103.98,9.32 35.8,9.32 34.68,10.44 31.94,10.44 31.88,10.5 31.85,10.5 31.08,11.28 31.08,11.3 31.04,11.34 31.04,35.76 31.53,36.26 31.53,44.95 28.09,48.39 28.09,57.4 22.98,62.51 13.13,62.51 6.79,68.85 6.79,78.78 6.48,79.1 6.48,84.87 4.81,86.54 4.81,89.14 5.18,89.51 v1(5.45,89.51) ; v1(165.57,16.66) 165.54,16.64 165.38,16.64 164.6,15.86 162.03,15.86 161.89,15.72 158.09,15.72 155.61,13.25 v1(155.61,13.07)
  IN3 w0.508: v1(129.32,13.08) 129.32,13.58 129.61,13.86 130.17,13.86 130.17,13.86 130.97,13.86 131.48,13.35 152.86,13.35 153.19,13.02 155.56,13.02 v1(155.61,13.07)
  vias: v2(4.57,88.91)
+SIM_PWR: length 351.8
  IN1 w0.508: v1(254.1,80.51) 254.1,80.52 256.58,83 273.71,83 276.54,85.83 280.72,85.83 281.11,86.22 286.09,86.22 292.75,79.57 292.75,66.52 290.69,64.47 290.69,57.8 292.21,56.27 292.21,52.9 296.06,49.05 296.06,23.53 295.13,22.61 278.72,22.61 274.1,27.23 274.1,31.12 270.94,34.28 v1(269.07,34.28) 268.16,33.36 263.89,33.36 v1(263.07,32.54)
  IN2 w0.508: v1(102.44,138.32) 102.64,138.11 104.3,138.11 104.46,138.27 105.61,138.27 106.31,137.57 113.42,137.57 114.44,136.55 150.98,136.55 151.83,137.4 152.86,137.4 154.87,135.38 155.92,135.38 157.61,133.69 158.59,133.69 161.8,130.48 169.62,130.48 171.96,128.14 173.51,128.14 178.78,122.87 178.78,120.84 181.55,118.06 182.04,118.06 182.76,117.34 183.27,117.34 184.75,115.86 184.75,110.8 185.94,109.6 187.02,109.6 188.43,108.19 188.43,106.34 190.8,103.96 190.8,99.51 191.77,98.55 191.77,97.47 196.73,92.51 196.73,91.47 198.86,89.35 201.26,89.35 202.32,88.28 206.89,88.28 208.59,86.57 215.58,86.57 216.22,85.93 216.22,85.8 217.58,84.44 217.66,84.44 218.79,83.31 220.42,83.31 220.9,83.8 222.36,83.8 223.28,82.88 223.28,82.12 225.58,79.82 226.88,79.82 v1(227.19,80.12)
  BOTTOM w0.508: v1(102.44,138.32) 102.44,139.92 105.57,143.05 JMINI1.8 ; v1(254.1,80.51) 254.1,80.52 253.4,81.22 250.14,81.22 248.39,82.97 238.84,82.97 235.88,85.93 234.67,85.93 233.88,86.72 230.77,86.72 v2(230,85.95) 228.26,84.21 228.26,81.96 227.37,81.07 227.37,80.31 v1(227.19,80.12) ; v1(263.07,32.54) C616.1 263.07,31.08 263.56,30.59 JSIM1.1 ; v1(269.07,34.28) 268.82,34.02 U40.5
+SUS_ENABLE: length 6.1
  TOP w0.102: Q303.3 127.55,26.67 v2(127.43,26.78)
  TOP w0.508: Q303.3 128.4,26.75 R1618.1 R911.2 C767.1 128.34,29.97 Q54.3
+TRM_CT1: length 4.7
  BOTTOM w0.508: C479.1 v2(91.79,144.17) 91.79,144.81 91.48,145.12 91.48,146.03 91.67,146.22 91.67,147.53
+TRM_CT2: length 4.8
  BOTTOM w0.508: T156.4 90.4,146.04 90.56,145.87 v2(90.56,145.57) 90.56,143.56 C480.1
+TRM_CT3: length 4.8
  BOTTOM w0.508: C484.1 84.48,143.32 v2(84.48,144.27) 84.31,144.44 84.31,145.72 84.05,145.99 84.05,147.53
+TRM_CT4: length 4.9
  BOTTOM w0.508: T156.10 82.78,145.54 82.08,144.84 v2(82.08,144.74) 82.08,144.04 82.4,143.73 C486.1
+USB1_REPEATER_VDD: length 65.9
  TOP w0.508: v1(269.09,68.5) 269.78,67.81 271.42,67.81 v1(272.13,68.52) 272.13,70.17 v1(273.15,71.18)
  IN2 w0.508: v1(273.15,71.18) 265.28,71.18 263.63,72.84 v1(263.63,76.26) 263.63,77.53 266.55,80.46 v1(267.31,80.46) 268.16,81.31 269.76,81.31 270.36,80.71 v1(270.36,80.46)
  IN4 w0.508: v1(260.96,65.98) 262.11,67.13 264.65,67.13 265.02,67.5 v1(265.02,68.47) 265.02,74.87 v1(263.63,76.26)
  BOTTOM w0.127: v2(265.33,67.62) 265.02,67.92 v1(265.02,68.47)
  BOTTOM w0.254: U625.1 267.58,76.85 266.51,77.92 265.06,77.92 C450.1 ; U625.13 270.08,71.71 270.61,71.18 272.1,71.18 C453.1
  BOTTOM w0.508: v1(269.09,68.5) R23.1 R22.1 ; v1(265.02,68.47) R25.1 R24.1 ; R18.1 R16.1 v1(267.31,80.46) ; C450.1 263.63,78.08 v1(263.63,76.26) ; v1(270.36,80.46) R15.1 R21.1 ; C453.1 v1(273.15,71.18) ; R12.1 v1(272.13,68.52)
+USB2_REPEATER_VDD: length 46.8
  TOP w0.508: v1(262.1,69.66) 261.35,69.66 v1(260.2,68.5) 259.57,67.88 258.72,67.88 v1(258.16,68.44) 252.58,74.03 252.58,74.99 v1(250.29,77.28) 250.29,78.04 251.05,78.8 253.47,78.8 v1(255.12,80.46) 255.76,81.1 257.77,81.1 v1(258.42,80.46)
  BOTTOM w0.254: U626.1 255.14,77.13 254.35,77.92 252.86,77.92 C455.1 ; C451.1 260.5,70.84 259.94,70.84 259.34,71.44 257.91,71.44 257.64,71.71 U626.13
  BOTTOM w0.508: v1(250.29,77.28) 250.29,77.92 251.09,78.71 C455.1 ; v1(255.12,80.46) R28.1 R29.1 ; R32.1 R31.1 v1(258.16,68.44) ; v1(258.42,80.46) 258.16,80.2 R27.1 R30.1 ; R26.1 v1(260.2,68.5) ; C451.1 261.63,70.13 v1(262.1,69.66)
  vias: v2(257.99,67.81)
+V_DDR_REF: length 240.9
  TOP w0.508: v1(130,13.09) 129.96,13.13 129.96,13.34 129.83,13.46 RD2.1 ; RD24.1 163.42,24.13 162.33,25.22 160.33,25.22 158.97,26.58 v1(158.77,26.58) ; v1(132.68,24.41) 132.65,24.41 130.07,21.82 v1(130.07,17.17) ; v1(130.78,64.4) 130.06,64.4 129.67,64.02 RD7.2 ; RD25.2 v1(163.36,63.06)
  IN1 w0.508: v1(158.77,26.58) 158.61,26.58 158.06,26.03 158.06,23.67 160.18,21.55 v1(160.18,16.36)
  IN2 w0.508: v1(163.36,63.06) 166.9,63.06 171.93,58.03 178.52,58.03 179.2,57.35 189.75,57.35 190.65,56.45 192.56,56.45 194.4,54.61 205.59,54.61 208.9,57.93 223.1,57.93 223.8,57.23 224.86,57.23 225.63,57.99 227.37,57.99 228.43,59.06 230.45,59.06 232.05,57.46 232.05,49.47 v1(232.62,48.9)
  IN3 w0.508: v1(158.77,26.58) 158.36,26.58 157.81,27.13 157.81,30.64 159.76,32.59 159.76,47.02 166.71,53.97 166.71,61.74 165.75,62.71 163.71,62.71 v1(163.36,63.06)
  IN4 w0.508: v1(160.18,16.36) 160.07,16.24 158.95,16.24 158.37,15.66 155.17,15.66 155.08,15.57 153.49,15.57 151.71,13.79 130.44,13.79 130,13.35 v1(130,13.09) ; v1(130.78,64.4) 131,64.62 134.09,64.62 135.04,63.67 143.97,63.67 144.64,62.99 149.64,62.99 150.25,63.6 157.41,63.6 159.04,65.23 161.94,65.23 163.36,63.81 v1(163.36,63.06)
  BOTTOM w0.508: v1(158.77,26.58) 158.97,26.58 160.76,24.79 162.14,24.79 163.42,23.5 RD24.1 ; RD7.2 129.67,63.93 130.15,64.4 v1(130.78,64.4) ; v1(130.07,17.17) 129.94,17.05 129.94,13.35 129.96,13.34 129.96,13.13 v1(130,13.09) ; v1(132.68,24.41) 132.17,24.92 130.98,24.92 129.64,23.57 RD15.1 ; v1(163.36,63.06) 163.1,62.8 RD34.2
  vias: v4(232.22,48.43)
+V_DDR_REFA_M3: length 25.7
  TOP w0.102: v2(126.31,11.93) 126.22,11.93 125.41,12.74 QD1.1
  TOP w0.508: RD1.1 128.81,13.56 128.69,13.44 v1(128.69,13.14) ; QD1.1 123.89,12.74 v1(123.89,12.75) 123.89,13.18 123.26,13.81 RD5.2
  IN4 w0.508: v1(123.89,12.75) 123.89,12.87 124.42,13.4 128.48,13.4 128.68,13.2 128.68,13.15 v1(128.69,13.14)
  BOTTOM w0.508: RD14.1 128,23.4 127.64,23.04 124.91,23.04 124.31,22.44 124.31,21.66 124.31,21.65 124.31,17.44 124.31,17.44 124.31,16.26 123.93,15.88 123.93,12.79 v1(123.89,12.75)
+V_DDR_REFB_M3: length 56.6
  TOP w0.508: v1(123.4,19.34) 123.39,19.34 123.33,19.4 RD6.2 123.09,18.58 QD2.1 ; v1(161.56,26.02) 162.86,26.02 v2(163.81,25.08) 164.69,24.19 RD23.1
  IN4 w0.508: v1(161.56,26.02) 161.54,26.02 159.95,24.44 159.95,23.65 156.5,20.19 152.03,20.19 148.35,16.51 134.01,16.51 131.11,19.4 123.5,19.4 123.44,19.34 v1(123.4,19.34)
  BOTTOM w0.508: RD23.1 164.67,23.4 162.16,25.91 161.67,25.91 v1(161.56,26.02)
+V_DDR_SMREF: length 6.6
  TOP w0.102: v2(118.97,77.79) QC4.1
  TOP w0.508: RC74.1 RC78.2 RC80.1 117.23,77.78 QC4.1
+V_SM_VREF_CNT: length 22.7
  TOP w0.254: JCPU1.AL1 100.21,71.45 100.55,71.78 101.13,71.78
  TOP w0.305: RC81.1 115.89,72.27 RC75.2
  TOP w0.508: 101.13,71.78 102.87,73.52 v2(113.37,73.52) 114.12,72.77 114.41,72.77 114.86,73.22 RC81.1 RC74.2 114.53,74.23 114.01,74.75 114.01,76.01 114.82,76.82 QC4.3
+VCHGR: length 7.2
  TOP w0.254: v1(188.44,27.02) 181.93,27.02 PR926.2
  vias: v2(187.97,22.75)
+VCHGR_B: length 5.3
  TOP w0.762: v1(186.03,38.8) 184.89,38.8 184.38,39.31 PC910.2 PR919.1
  vias: v1(186.03,39.56) v1(186.79,41.09) v1(186.79,40.32) v1(186.79,39.56) v1(186.79,38.8) v1(187.55,41.09) v1(187.55,40.32) v1(187.55,39.56) v1(187.55,38.8) v1(188.31,41.09) v1(188.31,40.32) v1(188.31,39.56) v1(188.31,38.8) v2(186.02,36.37)
+VCHGR_L: length 2.3
  TOP w0.102: PR923.4 191.58,31.79 192.06,32.27 v2(192.91,32.27)
+VDISPLAY_VCC: length 1.2
  TOP w0.508: v1(35.85,166.32) 36.19,165.98 C337.1
  vias: v1(36.57,162.46) v1(36.57,161.81) v2(35.66,160.02)
+VR_CAP: length 4.3
  TOP w0.305: v1(163.52,146.14) 163.52,145.91 163.18,145.57 162.57,145.57 162.51,145.63 U54.B12
  BOTTOM w0.102: v2(164.13,146.8) 164.13,146.75 v1(163.52,146.14)
  BOTTOM w0.508: C740.1 163.52,145.77 v1(163.52,146.14)
+WWAN_PWREN: length 13.1
  TOP w0.406: Q311.3 107.4,132.03 v1(107.67,132.3)
  TOP w0.508: v1(102.51,134.81) 102.75,134.57 C644.1 ; C644.1 R1625.1 R722.2 ; C644.1 102.68,133.6 Q40.3
  IN2 w0.508: v1(102.51,134.81) 103.01,134.32 106.13,134.32 107.67,132.78 v1(107.67,132.3)
  BOTTOM w0.102: v1(102.51,134.81) v2(102.51,134.18)
A_ON_3.3V#: length 22.2
  TOP w0.102: v1(137.08,152.45) 137.08,152.3 136.74,151.96 R918.2 133.2,151.99 Q306.5 133.2,153.57 133.34,153.71 133.72,153.71 133.85,153.58 Q306.6 ; v1(147.17,153.85) 148.07,154.75 Q60.2
  IN2 w0.127: v1(137.08,152.45) 137.13,152.45 138.5,153.82 142.1,153.82 142.41,153.51 143.56,153.51 144.16,154.1 144.16,154.33 144.87,155.04 145.72,155.04 146.91,153.85 v1(147.17,153.85)
  BOTTOM w0.102: v1(147.17,153.85) v2(147.17,154.65)
A_PRE0: length 4
  BOTTOM w0.102: R42.2 215.03,81.48 R88.1 215.03,83.39 v2(214.82,83.6) 214.58,83.85 214.58,84.02 214.2,84.4 U26.9
A_PRE1: length 5.9
  BOTTOM w0.102: v2(205.19,84.2) 205.4,84.4 R89.1 205.87,85.62 206.83,85.62 207.3,85.15 R40.2 207.58,85.4 U26.19
