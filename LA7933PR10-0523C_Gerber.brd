# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_CHG: length 4.2
  BOTTOM w0.102: v2(286.52,55.39) R929.2
  BOTTOM w0.508: R929.2 288.77,55.39 288.97,55.18 289.79,55.18 290.17,55.56 Q69.1
+3.3V_RUN_ENABLE: length 7.5
  BOTTOM w0.102: v2(295.74,53.56) R1631.1
  BOTTOM w0.508: R1631.1 294.59,54 294.6,54.01 Q59.1 293.72,54 293.72,52.87 293.5,52.64 R920.2 293.5,52.15 293.95,51.71 C777.1 293.85,51.28 Q56.4
+3.3V_RUN_R1: length 0.8
  BOTTOM w0.102: 208.8,82.26 208.96,82.26 v2(209.42,81.8)
+3.3V_RUN_R2: length 1.9
  BOTTOM w0.102: R91.1 216.44,86.25 217.07,85.62 v2(217.63,85.62)
+3.3V_RUN_REP: length 3.2
  BOTTOM w0.102: R83.1 214.26,81.64 214.26,83.8 214.16,83.9 U26.10
+3.3V_RUN_TPM: length 3.3
  BOTTOM w0.127: v2(173.37,107.8) 173.46,107.8 173.65,107.61 v1(173.65,107)
  BOTTOM w0.508: R2189.1 167.71,104.45 167.74,104.42
  vias: v1(167.5,108.5) v1(168.04,108.05) v1(169.12,93.92) v1(169.76,93.92) v1(172.21,96.7) v1(172.69,96.17) v1(174.24,107.26)
+3.3V_RUN_VCC_CLKF33: length 21.3
  TOP w0.254: UH4.T38 24.93,123.03 v1(24.76,123.03)
  IN2 w0.254: 25.3,126.8 25.24,126.8 25.2,126.76 25.2,125.92 25.23,125.88 25.23,124.18 25.22,124.17 25.22,123.91 25.21,123.91 25.21,123.82 24.76,123.36 v1(24.76,123.03) 25,122.78 25.58,122.78 26.37,123.57 26.37,124.9 26.08,125.18 26.08,125.92 26.19,126.02 26.19,126.66 25.89,126.96 25.89,127.11
  IN2 w0.508: 25.3,126.8 25.61,127.11 25.89,127.11 27.01,128.23 30.49,128.23 v1(30.67,128.41)
  BOTTOM w0.508: RH215.2 v2(31.57,128.08) 31,128.08 v1(30.67,128.41) ; CH73.1 24.51,123.03 v1(24.76,123.03) 24.77,123.02 CH74.1
+3.3V_SB3V: length 7.4
  TOP w0.127: v2(167.51,93.69) 167.51,94.88 166.98,95.42 C45.1
  TOP w0.381: U39.5 U37.5 168.91,96.31 168.86,96.25
  TOP w0.508: 168.86,96.25 168.86,95.69 R873.2 C48.1 C45.1
+3.3V_SPI: length 28.2
  TOP w0.508: v1(49.99,106.43) 49.99,106.17 49.76,105.94 48.89,105.94 U52.8 48.07,105.86 46.91,104.7 C787.1 46.28,104.95 45.69,105.54 45.68,105.54 45.48,105.73 R891.1 R890.1 ; C788.1 46.92,99.12 v2(47.31,99.51) U53.8 49.54,99.51 51.45,101.42 51.45,103.1 51.17,103.39 51.1,103.39 v1(51.07,103.43)
  IN2 w0.508: v1(53.15,108.95) 52.51,108.95 v1(49.99,106.43) 49.99,104.51 v1(51.07,103.43)
  BOTTOM w0.305: RH350.2 51.03,109.32 49.91,109.32 49.85,109.26 JSPI1.11
  BOTTOM w0.508: v1(53.15,108.95) 52.18,109.92 RH350.2
+3.3V_SUS: length 330.2
  TOP w0.356: JIO1.82 37.26,21.55 v1(37.59,21.22) 37.32,20.95 JIO1.84
  TOP w0.508: v1(185.66,135.73) 185.66,138.43 185.82,138.6 185.82,150.33 183.86,152.3 182.83,152.3 181.11,154.01 181.11,157.25 179.82,158.55 173.43,158.55 172.21,157.32 R914.1 172.06,155.22 ; R589.1 172.06,155.22 ; 172.06,155.22 173.3,153.98 173.3,153.38 172.55,152.63 v1(171.87,152.63) ; v1(191.87,91.76) 191.87,91.77 192.04,91.94 192.04,100.31 194.12,102.39 v1(194.16,102.39)
  IN2 w0.508: v1(185.66,135.73) 185.66,133.4 186.06,133 186.76,133 187.48,132.28 187.48,118.66 188.75,117.39 188.75,110.2 190.14,108.81 190.14,108.78 190.47,108.78 191.5,107.75 191.5,105.92 193.19,104.23 193.19,103.35 v1(194.16,102.39)
  IN3 w0.508: v1(178.08,62.99) 177.73,63.34 177.73,65.61 177.3,66.04 177.3,67.46 175.98,68.78 175.98,74.93 175.17,75.74 175.17,76.73 174.73,77.18 174.73,83.36 176.07,84.71 188.61,84.71 190.93,87.03 190.93,88.95 191.95,89.97 191.95,91.68 v1(191.87,91.76)
  IN4 w0.508: v1(178.08,62.99) 178.05,63.02 177.14,63.02 168.16,54.04 165.43,54.04 163.73,52.34 163.73,52.2 163.12,51.59 136.02,51.59 133.44,49.01 118.25,49.01 114.1,44.86 v1(114.04,44.86) ; v1(37.59,21.22) 36.79,20.42 36.79,16.17 36.93,16.03 36.93,15.93 38.66,14.2 41.17,14.2 41.44,13.93 57.29,13.93 59.11,12.12 87.77,12.12 98.45,22.8 105.86,22.8 107.2,24.14 107.2,24.71 110.89,28.4 116.63,28.4 v1(119.39,31.17)
  BOTTOM w0.127: v4(34.54,22.44) 35.6,22.44 C725.1
  BOTTOM w0.508: v1(114.04,44.86) 113.77,44.58 113.77,38.21 117.83,34.15 117.83,32.73 v1(119.39,31.17) ; v1(171.87,152.63) 171.65,152.85 R585.1 ; v1(37.59,21.22) 37.41,21.4 C725.1
+3.3V_SUS_CHG: length 2.6
  TOP w0.508: Q65.1 129.89,32.83 130.22,32.5 v2(130.22,32.02) 129.35,31.15 R922.2
+3.3V_WLAN: length 11.9
  TOP w0.381: v1(182.08,93.93) 182.73,94.58 Q124.2 ; v1(183.8,95.83) 183.55,95.83 183.3,96.08 182.98,96.08 182.73,96.33 Q124.5
  TOP w0.508: R718.2 R705.2 v1(182.73,100.41)
  IN1 w0.508: v1(183.8,95.83) 183.8,99.33 v1(182.73,100.41)
  BOTTOM w0.102: C606.2 201.51,102.92 v4(201.51,103.75)
+3V_ALW_PCH_ENABLE: length 6.7
  BOTTOM w0.356: R905.2 13.42,131.72 Q305.3
  BOTTOM w0.508: Q49.3 v2(11.49,129.67) 11.92,129.67 12.22,129.38 13.11,129.38 C762.1 R1619.1 R905.2
+3VM_THRM: length 10.3
  TOP w0.254: C348.1 140.05,154.86 140.24,155.05 v2(140.24,155.16) 140.24,155.35 140.07,155.52 U18.4
  TOP w0.508: C348.1 C341.1 R289.1 v1(142.73,154.21) ; v1(138.53,154.65) 138.53,154.61 138.06,154.14 R393.2
  IN2 w0.508: v1(142.73,154.21) 142.23,154.71 138.59,154.71 v1(138.53,154.65)
+3VMXM_D: length 2.8
  TOP w0.102: v2(146,170.75) R268.2
  TOP w0.508: Q48.1 147.17,170.8 R268.2
+3VMXM_GATE: length 7.7
  BOTTOM w0.102: C352.1 200.32,79.77 v2(200.49,79.59)
  BOTTOM w0.508: Q294.3 196.92,79.75 R305.1 R269.2 197.98,79.77 C352.1 199.24,81.22 199.49,81.47 Q25.4
+5V_ALW: length 446.4
  TOP w0.508: PR720.1 PR740.1 v1(22.2,70.97) 22.21,70.98 PR726.1 ; v1(173.33,78.93) PR1012.2 ; v1(277.77,84.62) 277.77,85.31 279.06,86.59 279.06,87.88 277.49,89.45 JPB1.2 ; v1(251.18,40.07) 249.72,40.07 245.27,44.51 245.27,51.45 244.31,52.41 244.31,57.46 244.8,57.95 v1(244.94,57.95) ; v1(251.18,39.05) 247.42,35.29 v1(233.23,35.29) ; v1(3.78,121.04) 3.31,121.04 2.5,120.23 1.74,120.23 1.29,120.68 1.29,123.5 1.51,123.71 v1(1.55,123.71) ; v1(55.89,12.61) 54.13,12.61 51.48,15.25 51.48,22.68 v1(52.36,23.56) 52.56,23.76 52.56,27.74 53.39,28.56 57.28,28.56 59.18,30.47 59.18,35.99 57.75,37.43 51.2,37.43 50.65,37.99 v1(50.65,42.99) ; QH4.1 10.96,123.55 10.31,124.19 10.31,124.3 10.25,124.36 v1(10.27,124.36) ; v1(67.37,159.11) 68.36,158.12 68.36,154.75 69.58,153.53 C256.1
  IN1 w0.508: v1(278.42,77.88) 278.42,78.08 277.29,79.21 277.29,82.22 277.09,82.42 277.09,84.32 277.46,84.68 277.71,84.68 v1(277.77,84.62) ; v1(231.93,42.93) 231.93,36.6 v1(233.23,35.29) ; v1(1.55,123.71) 1.51,123.71 1.27,123.47 1.27,93.27 3.92,90.62 6.16,90.62 v1(7.64,89.13) 7.64,86.61 3.69,82.66 3.69,75.3 4.3,74.69 4.63,74.69 v1(4.74,74.59) 6.26,73.06 6.26,71.17 4.1,69.01 v1(4.1,67.72) ; v1(25.54,83.35) 25.54,81.53 24.53,80.53 24.53,77.78 23.66,76.9 22.36,76.9 21.7,76.24 21.7,73.09 22.2,72.59 v1(22.2,70.97)
  IN1 w0.762: v1(3.91,150.75) 4.14,150.98 4.14,152.27 3.22,153.19 3.22,155.13 6.46,158.37 6.46,159.45 7.21,160.2 11.53,160.2
  IN2 w0.508: v1(32.7,87.87) 32.7,87.81 32.36,87.47 30.55,87.47 30.17,87.08 28.65,87.08 27.38,85.81 26.66,85.81 25.94,85.1 ; v1(226.11,56.52) v1(227.8,56.52) 227.81,56.52 228.7,57.4 229.5,57.4 230.11,58.01 v1(230.11,58.34) ; 25.94,85.1 25.37,84.53 25.37,83.52 v1(25.54,83.35) ; 25.94,85.1 25.27,85.1 24.2,86.17 22.45,86.17 22.07,86.55 18.06,86.55 16.98,87.63 9.14,87.63 v1(7.64,89.13)
  IN3 w0.508: v1(63.98,24.89) 62.81,26.06 54.86,26.06 v1(52.36,23.56) ; v1(3.78,121.04) 7.38,124.64 8.41,124.64 9.03,124.02 10,124.02 10.25,124.27 10.25,124.33 v1(10.27,124.36) ; v1(41.45,43.14) 41.67,42.93 41.76,42.93 42.33,42.36 46.32,42.36 46.83,42.86 47.22,42.86 47.28,42.93 50.58,42.93 v1(50.65,42.99) ; v1(189.63,60.49) 188.62,60.49 187.84,61.27 181.34,61.27 180.25,62.36 177.81,62.36 177.44,62.73 177.44,62.75 177.09,63.11 177.09,65.13 174.14,68.07 174.14,75.96 173.28,76.82 173.28,78.88 v1(173.33,78.93) ; v1(176.88,27.75) 177.14,27.5 177.14,24.93 175.73,23.52 175.73,22.5 178.09,20.14 v1(207.1,20.14)
  IN4 w0.508: v1(230.11,58.34) 231.2,57.25 240.56,57.25 241.79,58.48 244.65,58.48 244.94,58.19 v1(244.94,57.95)
  IN4 w0.762: v1(3.91,150.75) 3.47,150.75 1.46,148.74 1.46,134.09 1.18,133.81 1.18,124.09 v1(1.55,123.71)
  BOTTOM w0.203: v1(231.93,42.93) 231.7,43.15 PU201.12
  BOTTOM w0.254: C715.1 277.58,78.58 277.28,78.28 277.05,78.28 276.82,78.51 U2.5
  BOTTOM w0.356: PU1.5 3.4,73.56 3.83,73.13 4.75,73.13 5.26,72.63 PD7.3
  BOTTOM w0.508: v1(52.36,23.56) 52.31,23.61 PR605.2 51.65,23.15 PC602.2 ; Q75.3 230.59,57.86 v1(230.11,58.34) ; R1614.2 276.17,83.93 276.86,84.62 v1(277.77,84.62) ; PU2.8 174.46,174.97 v1(175.01,175.53) 175.2,175.72 PC18.1 175.8,174.76 PR31.2 ; PC208.2 231.72,39.64 231.84,39.52 PR204.1 231.84,36.69 v1(233.23,35.29) ; R816.2 288.93,60.46 v1(288.72,60.25) ; v1(4.74,74.59) 5.8,73.52 PD7.3 ; PR718.2 27.56,80.96 26.27,82.25 26,82.25 25.54,82.7 v1(25.54,83.35) ; PR931.2 239.1,17.93 v1(239,17.83) 238.57,17.4 PU902.8 236.65,17.4 236.27,17.02 236.27,16.16 PC936.1 PC937.1 235.69,14.99 235.48,15.19 v1(235.48,15.57) ; v1(278.42,77.88) 278.42,78.08 277.92,78.58 C715.1 ; Q86.3 228.05,56.77 v1(227.8,56.52) ; PR715.2 50.3,42.64 v1(50.65,42.99) ; v1(4.1,67.72) 4.1,66.94 2.93,65.77 PR11.1 ; Q79.3 225.51,57.11 v1(226.11,56.52) ; PC21.1 v1(175.84,167.08)
  vias: v1(11.85,159.88) v1(11.85,159.25) v1(12.51,160.63) v1(12.48,159.88) v1(12.48,159.25) v1(28.51,27.15) v1(28.66,22.64) v1(29.56,20.51) v1(29.56,19.88) v1(32.23,18.86) v1(32.23,18.23) v1(32.31,21.22) v1(32.32,20.03) v1(32.28,17.59) v1(32.29,16.96) v1(32.29,16.32) v1(55.88,11.96) v1(56.53,12.61) v1(56.54,11.96) v1(75.32,162.93) v1(75.32,162.29) v1(75.96,162.93) v1(75.96,162.29) v1(105.17,12.04) v1(105.81,12.07) v1(189.33,175.2) v1(189.33,174.56) v1(189.6,61.27) v1(189.97,175.2) v1(189.97,174.56) v1(189.97,61.84) v1(190.6,174.56) v1(190.71,61.85) v1(197.27,48.96) v1(197.27,48.07) v1(198.09,48.96) v1(198.09,48.07) v1(198.98,48.96) v1(198.98,48.07) v1(250.04,21.02) v1(251.22,21.06) v1(251.22,19.79) v1(252.2,40.07) v1(252.2,39.05) v1(252.23,21.06) v1(252.23,19.79) v1(253.21,40.07) v1(253.21,39.05) v1(253.63,21.06) v1(253.63,19.79) v1(254.23,40.07) v1(254.23,39.05) v1(255.15,21.06) v1(255.15,19.79) v1(255.37,40.07) v1(255.37,39.05) v1(256.39,40.07) v1(256.39,39.05) v1(256.35,21.07) v1(256.35,19.8) v1(257.4,40.07) v1(257.4,39.05) v1(257.36,21.07) v1(257.36,19.8) v1(258.42,40.07) v1(258.42,39.05) v1(258.38,21.07) v1(258.38,19.8) v1(259.65,21.07) v1(259.65,19.8) v1(260.7,21.02) v1(287.12,58.62) v1(287.12,57.99) v1(287.76,58.62) v1(287.76,57.99) v1(293.88,56.54) v1(293.88,55.91) v1(294.51,56.54) v1(294.51,55.91) v4(188.31,173.8) v4(252.2,33.85) v4(255.41,37)
+5V_ALW2: length 11.2
  TOP w0.508: v1(268.07,60.77) 268.16,60.68 273.34,60.68 275.21,58.81 275.21,57.43 v1(274.42,56.64)
  BOTTOM w0.508: v1(268.07,60.77) PR117.2
  vias: v2(275.09,57.02)
+5V_ALW_ESATA: length 1.9
  TOP w0.102: 14.64,159.16 v2(14.64,157.21)
+5V_ALW_FUSE: length 2.8
  BOTTOM w0.102: 289.69,57.84 289.69,56.81 289.89,56.6 291.06,56.6 v4(291.29,56.38)
+5V_ALW_PCH: length 272.4
  TOP w0.508: v1(186.49,147.74) 186.49,150.6 182.08,155 182.08,157.42 180.08,159.41 177.24,159.41 175.87,160.78 v1(175.87,162.36) ; v1(7.86,122.67) 8.13,122.4 8.86,122.4 QH4.3
  IN1 w0.508: v1(183.96,146.37) 183.96,145.69 182.66,144.39 v1(182.66,142.18)
  IN3 w0.508: v1(160.36,168.01) 161.35,168.01 164.23,165.13 171.08,165.13 173.39,162.81 174.65,162.81 175.11,162.36 v1(175.87,162.36)
  IN4 w0.508: v1(7.86,122.67) 7.71,122.67 7.3,123.08 7.3,126.2 10.65,129.55 11.65,129.55 11.87,129.32 13.5,129.32 14.16,129.98 14.16,131.56 14.69,132.09 14.78,132.09 15.71,133.03 15.71,133.65 15.57,133.8 15.57,134.29 16.29,135.01 16.29,137.59 16.69,137.99 16.69,149.3 16.41,149.58 16.41,150.08 16.19,150.29 16.19,153.24 15.07,154.36 15.07,158.19 17.66,160.78 20.27,160.78 22.31,162.83 33.73,162.83 35.77,160.78 44.09,160.78 45.5,162.19 51.15,162.19 51.31,162.34 62.32,162.34 64.95,159.72 66.69,159.72 67.27,160.3 73.99,160.3 75.51,158.78 75.51,154.36 v1(77.32,152.55)
  BOTTOM w0.508: RH208.1 9.75,119.95 8.99,120.71 CH98.1 RH278.1 7.94,122.06 7.86,122.14 v1(7.86,122.67) ; v1(183.96,146.37) 183.96,147.07 184.63,147.74 v1(186.49,147.74) ; v1(182.66,142.18) 182.6,142.11 R2159.1 ; v1(77.32,152.55) 77.2,152.44 77.2,151.78 77.78,151.2 85.33,151.2 86.46,152.34 95.11,152.34 96.98,154.2 96.98,158.39 96.72,158.65 96.72,159.44 97.51,160.22 97.51,167.13 100.18,169.8 v2(113.99,169.8) 129.67,169.8 134.01,165.47 141.55,165.47 143.25,167.17 144.28,167.17 146.72,169.61 158.76,169.61 v1(160.36,168.01)
+5V_ALW_PCH_ENBLE: length 12.1
  TOP w0.381: QH4.2 8.86,123.9 8.15,124.61 8.07,124.61 8.04,124.58 7.57,124.58 7.21,124.22 RH357.1
  TOP w0.508: QH4.2 9.42,123.9 9.61,124.09 9.61,124.6 v1(9.43,124.78) 9.43,125.43 9.19,125.67 QH6.1
  BOTTOM w0.102: v2(6.82,126.31) 8.04,126.31 8.56,125.79 CH8.1
  BOTTOM w0.508: RH32.1 9.37,124.84 v1(9.43,124.78) 9.43,125.49 9.13,125.79 CH8.1
+5V_ALW_PCH_R: length 6.5
  BOTTOM w0.254: U4.1 181.03,142.13 R2159.2 182.21,143.28 183.15,143.28 v2(183.61,143.75) 183.96,144.1 C290.1
+5V_ALWP: length 82.5
  IN1 w0.254: v1(248.5,49.72) 247.58,49.72 246.35,50.95 246.35,57.4 252.13,63.18 272.77,63.18 273.34,62.61 v1(273.34,62.12) ; v1(248.5,48.96) 247.58,48.96 245.97,50.57 245.97,57.68 251.92,63.63 v1(273.44,63.63)
  BOTTOM w0.254: v1(273.34,62.12) 273.34,61.79 273.61,61.51 PU101.24
  BOTTOM w0.508: v1(273.44,63.63) PR102.2 PC121.1
  vias: v2(258.61,44.74)
+5V_ESATA_PWR: length 1.6
  TOP w0.508: C668.1 16.94,166.91 16.95,166.89
  vias: v2(20.85,161.23)
+5V_HDD: length 98.3
  TOP w0.127: v2(86.32,35.32) 87.05,35.32 C409.1
  IN4 w2.032: 124.57,27.27 124.57,32.29 124.58,32.29 124.58,34.77 120.98,38.36 108.73,38.36 107.28,39.82 99.36,39.82 95.58,36.04 95.58,33.27 93.75,31.45 89.3,31.45 ; 163.68,43.5 163.68,43.02 160.51,39.85 160.51,37.05 159.5,36.03 158.26,36.03 157.24,35.02 157.24,27.33 ; 169.77,49.47 169.95,49.47 175.89,55.41 178.78,55.41 181.65,58.28 190.46,58.28 190.69,58.51
  BOTTOM w0.508: v1(86.6,30.21) 86.6,31.34 C498.1 87.23,31.34 v1(87.23,30.21)
  vias: v1(86.94,29.58) v1(86.94,28.89) v1(192.31,59.59) v1(192.31,58.95) v1(192.95,59.59) v1(192.95,58.95)
+5V_HDMI_DDC: length 5.5
  TOP w0.127: v2(37.4,162.23) D70.1
  TOP w0.254: R1169.2 39.15,166.15 R460.1
  TOP w0.508: R460.1 R461.1 37.18,164.77 37.4,164.55 D70.1
+5V_MOD:
  vias: v1(25.87,27.31) v1(25.98,29.05) v1(25.98,28.41) v1(26.14,25.77) v1(26.62,29.05) v1(26.62,28.41) v1(27.25,29.05) v1(27.25,28.41) v2(24.47,27.62)
+5V_MXM: length 5.6
  TOP w0.508: R274.1 191.57,169.53 191.21,169.89 191.21,170.61 191.8,171.2 194.52,171.2 v1(194.52,171.2)
  vias: v1(194.94,162.6) v1(195.58,162.6) v1(195.58,161.96) v1(196.21,162.6) v1(196.21,161.96) v4(200.04,169.53)
+5V_RUN: length 540.4
  TOP w0.356: JIO1.125 31.83,8.35 v1(32.32,7.86) 32.21,7.75 JIO1.127 ; JIO1.131 32.29,6.55 v1(32.6,6.24) 32.31,5.95 JIO1.133 ; C763.1 27.5,8.11 28.46,7.15 JIO1.129
  TOP w0.381: C365.1 108.53,150.91 107.86,150.24 107.86,149.97 108.02,149.81 U21.5
  TOP w0.457: v1(58.05,155.38) 58.61,155.38 59.04,154.94 59.04,153.96
  TOP w0.508: C365.1 108.54,150.95 v1(109.64,150.95) ; v1(15.51,128.78) 15.43,128.7 QH7.2 ; v1(86.5,136.5) 86.5,136.2 85.79,135.48 85.79,132.55 86.96,131.38 86.96,130.41 88.37,129 88.37,122.25 88.75,121.87 88.75,118.63 85.75,115.63 JKB1.12 JKB1.11 85.75,110.05 85.44,109.75 C758.1 ; JCAM1.8 2.27,128.2 2.79,127.67 2.79,126.86 v1(2.77,126.84) 2.5,126.84 2.14,127.2 JCAM1.6 ; JUSH1.14 121.51,30.3 122.02,29.79 v1(122.02,29.21) 122.55,29.21 122.78,28.98 C56.1 ; v1(58.66,149.97) 58.66,149.73 59.03,149.37 59.85,149.37 60.31,149.82 C1182.1 60.31,152.69 59.04,153.96 ; v1(177.39,144.34) R851.2 R845.2 ; C763.1 v1(28.28,8.45) ; v1(106.67,139.13) 106.68,139.13 106.81,139 R1537.1 ; R1169.1 39.22,163.93 D70.2 39.94,164.07 v1(40.7,164.07)
  IN1 w0.508: v1(109.64,150.95) 109.51,150.95 109,150.44 109,147.5 108.49,146.99 108.39,146.99 107.85,146.44 107.85,146.43 106.46,145.05 106.43,145.05 105.89,144.5 105.89,143.4 107.83,141.45 107.83,139.66 107.3,139.13 v1(106.67,139.13) ; v1(12.67,130.66) 12.69,130.66 12.72,130.62 13.04,130.62 15.04,128.63 15.35,128.63 v1(15.51,128.78)
  IN2 w0.508: v1(288.54,64.29) 287.92,64.91 287.92,67.4 287.48,67.84 277.67,67.84 276.59,66.76 273.59,66.76 272.91,67.45 264.56,67.45 263.96,66.84 263.96,63.48 261.07,60.59 249.01,60.59 247.72,61.88 247.72,63.09 247.08,63.74 246.05,63.74 245.3,64.49 v1(242.3,64.49) 240.84,63.03 231.6,63.03 230.57,62 225.87,62 225.75,62.12 204.58,62.12 202.77,60.3 v1(202.36,60.3)
  IN3 w0.254: 160.88,142.94 159.36,142.94 158.85,143.45 157.35,143.45 158.98,141.82 159.74,141.82 159.76,141.8 161.01,141.8 162.15,140.65 162.16,140.67 162.16,141.66 160.88,142.94
  IN3 w0.508: v1(173.4,145.1) 172.78,144.48 172.78,142.48 173.42,141.85 173.42,139.61 172.53,138.72 162.65,138.72 162.15,139.22 162.15,140.65 ; 108.19,157.05 110.26,159.12 116.44,159.12 118.39,157.18 118.39,151.12 119.71,149.8 132.56,149.8 134.34,148.02 140.82,148.02 144.88,143.96 149.45,143.96 149.96,143.45 157.35,143.45 ; 108.19,157.05 104.05,157.05 102.94,155.94 102.94,153.72 100.48,151.26 100.48,149.43 99.57,148.51 82.29,148.51 80.43,150.38 77.87,150.38 73.72,154.53 72.85,154.53 72.43,154.95 71.39,154.95 70.8,155.54 69.26,155.54 v1(69.01,155.79) 68.6,156.2 58.87,156.2 v1(58.05,155.38) ; 108.19,157.05 108.19,152.69 109.64,151.24 v1(109.64,150.95) ; v1(2.82,130.66) 3.08,130.39 6.81,130.39 7.95,129.25 9.33,129.25 9.93,129.85 11.4,129.85 12.22,130.66 v1(12.67,130.66)
  IN4 w0.508: v1(226.52,80.82) 225.4,80.82 222.22,84 220.74,84 219.66,85.08 v1(219.66,85.18) ; v1(15.51,128.78) 15.35,128.63 14.67,128.63 14.18,128.14 14.18,121.9 13.12,120.84 11.38,120.84 v1(10.49,121.74) ; v1(177.39,144.34) 177.29,144.34 176.45,145.17 176.45,145.59 175.35,146.7 174.43,146.7 173.4,145.67 v1(173.4,145.1)
  BOTTOM w0.203: v1(58.05,155.38) 59.08,155.38 U19.29 ; U19.21 58.77,152.19 58.6,152.01 58.6,151.08 58.52,151 58.52,150.11 v1(58.66,149.97)
  BOTTOM w0.508: R2193.1 v1(288.54,64.29) ; JFAN2.1 226.52,80.43 v1(226.52,80.82) ; v1(86.5,136.5) 95.35,136.5 96.32,135.53 96.32,134.91 96.72,134.51 96.72,130.98 98.34,129.36 101.14,129.36 106.67,134.89 v1(106.67,139.13) ; v1(202.36,60.3) 202.32,60.26 202.32,60.06 201.95,59.69 201.95,57.02 201.52,56.59 ; RH213.1 10.49,121.16 v1(10.49,121.74) ; v1(32.32,7.86) 48.27,7.86 48.72,8.31 103.97,8.31 106.46,10.8 107.27,10.8 110.06,13.58 110.06,14.62 112.51,17.07 112.51,17.55 120.43,25.48 120.43,27.1 122.02,28.69 v1(122.02,29.21) ; v1(2.77,126.84) 2.47,126.84 1.96,127.35 C311.1 ; v1(173.4,145.1) R852.2 R846.2 ; v1(242.3,64.49) Q80.3 ; v1(40.7,164.07) 40.7,162.54 45.69,157.54 R2153.1
  vias: v1(5.48,88.68) v1(6.15,88.68) v1(24.71,162.13) v1(25.36,162.13) v1(25.78,31.8) v1(25.78,31.17) v1(26.39,32.45) v1(26.41,31.8) v1(26.41,31.17) v1(27.02,32.45) v1(27.05,31.8) v1(27.05,31.17) v1(66.52,162.62) v1(67.28,162.62) v1(194.4,55.87) v1(195.05,55.88) v1(195.69,55.87) v1(196.35,55.88) v1(198.41,87.02) v1(198.77,86.49) v1(199.1,87.03) v1(199.45,86.47) v1(199.86,87.03) v1(219.23,85.66) v4(200.28,56.76)
+5V_RUN_CHG: length 2.2
  BOTTOM w0.102: Q67.1 v2(215.02,90.74)
  BOTTOM w0.508: R923.2 216.18,90.19 Q67.1
+5V_RUN_CRT: length 6.3
  TOP w0.508: R50.1 71.03,166.98 v1(71.31,166.7) ; v1(65.64,166.03) 65.61,166.03 65.12,166.51 R52.1
  BOTTOM w0.508: R47.1 66.24,166.62 v1(65.64,166.03) ; v1(68.2,166.1) 68.36,166.27 v2(68.36,166.73) 68.36,167.17 67.89,167.64 R48.1
  vias: v1(71.99,166.7)
+5V_RUN_ENABLE: length 7.9
  BOTTOM w0.508: Q61.1 207.85,54.06 207.85,54.79 207.54,55.09 v2(207.06,55.09) 206.49,55.09 206.09,54.7 R906.2 C769.1 205.08,54.93 204.64,55.36 203.86,55.36 203.68,55.18 Q51.4
+5V_RUN_HDMI:
  vias: v2(25.69,157.63)
+5V_USB_PWR1:
  vias: v1(290.04,106.27) v1(290.04,105.64) v1(290.04,104.92) v1(290.04,104.19) v1(291.45,114.49) v1(292.09,114.49) v1(296.29,59.67) v1(296.29,59.03) v1(296.92,59.67) v1(296.92,59.03) v4(295.67,59.8)
+5V_USB_PWR2:
  vias: v1(290.36,86.17) v1(290.36,85.54) v1(290.99,86.17) v1(290.99,85.54) v1(296.29,58.22) v1(296.29,57.58) v1(296.92,58.22) v1(296.92,57.58) v4(295.67,57.58)
+5VMXM_D: length 2.9
  TOP w0.102: v2(190.14,170.02) R274.2
  TOP w0.508: Q50.1 190.09,168.67 R274.2
+5VMXM_GATE: length 7.7
  TOP w0.102: v2(194.71,166.88) 194.23,167.36 v1(194.23,167.58)
  TOP w0.508: Q36.1 R278.1 R275.2 193.92,168.48 193.92,167.89 v1(194.23,167.58) 194.88,167.58 195.17,167.87 C355.1
  BOTTOM w0.508: Q76.4 v1(194.23,167.58)
+V1.05S_VCCPP_B+: length 1.2
  BOTTOM w0.102: PC502.1 59.59,16.78 v2(59.28,17.08)
+V1.05SP_B+:
  vias: v2(12.9,146.14)
+VCC_CORE: length 104.1
  TOP w0.254: PL703.1 v1(48.49,66.41) ; v1(30.97,71.53) 30.97,71.22 30.81,71.06 29.89,71.06 PR742.2 PR747.2 ; v1(31.05,65.7) 30.08,65.7 PR759.2 PR762.2 ; PL701.1 v1(48.49,59.29) ; v1(48.49,73.52) PL702.1 ; PR719.2 PR723.2 25.55,64.94 26.06,64.43 30.11,64.43 v1(30.24,64.55)
  TOP w0.508: PC1121.2 v1(79.98,59.88) ; v1(57.08,74.66) 57.54,74.21 RC67.1 ; PC1123.2 v1(79.86,62.04) ; v1(76.17,65.22) PC1163.2
  IN4 w0.254: v1(48.49,59.29) 48.36,59.42 48.36,59.7 47.67,60.39 46.58,60.39 45.82,59.63 45.82,56.2 45.31,55.69 36.42,55.69 35.66,54.93 34.39,54.93 33.76,55.56 33.76,59.37 31.86,61.27 31.86,63.6 31.05,64.41 30.38,64.41 v1(30.24,64.55) ; v1(30.97,71.53) 31.95,70.55 47.09,70.55 48.36,71.82 48.36,73.39 v1(48.49,73.52) ; v1(31.05,65.7) 31.23,65.52 35.1,65.52 35.4,65.22 44.8,65.22 46.5,66.91 47.98,66.91 v1(48.49,66.41)
  IN4 w0.508: v5(63.77,67.91) 63.08,68.59 v1(63.08,70.57)
  BOTTOM w0.254: v1(30.24,64.55) 30.14,64.45 28.31,64.45 27.41,65.36 27.41,66.06 PR728.1
  BOTTOM w0.305: v1(31.05,65.7) 31.44,66.09 PR763.1 ; PR751.1 31.41,71.09 v1(30.97,71.53)
  BOTTOM w0.508: RC59.1 63.09,70.58 63.09,70.57 v1(63.08,70.57)
  vias: v1(49,71.36) v1(49,69.33) v1(49.12,74.28) v1(49.12,57.6) v1(49.25,76.82) v1(49.25,72.25) v1(49.5,75.42) v1(49.5,56.88) v1(49.63,70.34) v1(49.76,64.58) v1(49.76,62.72) v1(49.76,61.02) v1(50.01,69.33) v1(50.14,71.36) v1(50.14,61.91) v1(50.14,57.6) v1(50.27,77.46) v1(50.27,76.19) v1(50.27,63.61) v1(50.27,56.83) v1(50.52,61.02) v1(50.65,64.58) v1(50.65,62.68) v1(50.9,70.34) v1(51.03,69.33) v1(51.15,75.3) v1(51.28,77.46) v1(51.41,71.49) v1(51.54,64.37) v1(51.66,76.19) v1(51.92,70.47) v1(51.92,69.28) v1(52.17,75.3) v1(52.3,77.46) v1(52.55,64.37) v1(52.68,54.21) v1(52.68,51.42) v1(52.68,50.15) v1(52.68,48.12) v1(52.93,76.19) v1(52.93,71.49) v1(53.19,59.68) v1(53.44,77.58) v1(53.44,74.49) v1(53.44,73.52) v1(53.44,72.25) v1(53.57,50.15) v1(53.69,75.3) v1(54.14,54.98) v1(54.2,76.14) v1(54.2,64.44) v1(54.2,59.68) v1(54.33,58.48) v1(54.33,57.47) v1(54.46,74.28) v1(54.46,73.01) v1(54.46,50.15) v1(56.63,46.85) v1(57,64.88) v1(57,62.34) v1(57,60.31) v1(57,57.77) v1(57,55.48) v1(57,53.2) v1(57,51.04) v1(57.15,66.59) v1(57.26,49.12) v1(58.98,54.01) v1(59.03,53.33) v1(59.02,51.75) v1(59.03,51.04) v1(59.03,49.53) v1(59.04,48.83) v1(59.07,47.23) v1(59.07,46.33) v1(61.02,66.79) v1(61.01,65.86) v1(61.02,64.76) v1(61.03,63.6) v1(61.03,62.32) v1(61.02,61.15) v1(61.02,60.18) v1(61.02,58.93) v1(61.02,57.9) v1(61.03,56.46) v1(62.53,50.84) v1(62.47,50.19) v1(62.58,55.87) v1(62.58,54.47) v1(62.56,53) v1(62.58,52.31) v1(62.56,51.5) v1(62.67,64.47) v1(62.69,61.25) v1(62.65,58.27) v1(62.71,55.19) v1(62.98,53.81) v1(63.35,55.48) v1(63.35,54.47) v1(63.6,64.47) v1(63.64,61.24) v1(63.61,58.24) v1(64.49,67.5) v1(64.49,66.74) v1(64.58,64.47) v1(64.57,61.25) v1(64.55,58.27) v1(65.42,53.02) v1(76.05,52.26) v1(76.17,66.99) v1(76.17,63.06) v1(76.17,60.9) v1(76.17,58.74) v1(76.17,56.58) v1(76.17,54.42) v1(78.4,67.76) v1(78.4,66.1) v1(78.4,64.2) v1(78.4,61.91) v1(78.4,59.88) v1(78.4,57.72) v1(78.4,55.56) v1(78.4,53.28) v1(79.87,64.1) v1(79.98,57.72) v1(79.98,55.56) v1(81,54.17) v1(81.63,53.15) v1(81.89,62.8) v1(81.89,58.99) v1(81.89,56.58) v1(83.03,65.09) v1(83.92,57.72) v1(84.61,62.71) v1(84.68,62.04) v1(84.68,61.15) v1(84.68,60.43) v1(84.64,58.53) v4(55.51,71.25) v5(65.3,67.9) v5(65.3,66.94) v5(65.26,64.97) v5(65.3,64.01) v5(65.29,61.99) v5(65.28,61) v5(65.3,58.98) v5(65.3,57.99) v5(65.31,56) v5(65.31,54.99) v5(66.32,67.97) v5(66.32,66.95) v5(66.32,64.96) v5(66.32,63.96) v5(66.33,61.95) v5(66.33,60.95) v5(66.33,58.94) v5(66.33,57.95) v5(66.31,55.95) v5(66.39,54.95) v5(67.33,68.03) v5(67.32,65.02) v5(67.32,62.01) v5(67.34,59.02) v5(67.33,56.04) v5(67.39,66.95) v5(67.39,63.95) v5(67.39,60.95) v5(67.39,57.95) v5(67.39,54.95) v5(68.4,66.94) v5(68.38,65.02) v5(68.39,63.95) v5(68.39,62.01) v5(68.39,60.95) v5(68.4,59.02) v5(68.4,57.95) v5(68.39,56.04) v5(68.4,54.94) v5(69.39,67.97) v5(69.39,66.95) v5(69.39,64.97) v5(69.39,63.95) v5(69.39,62.01) v5(69.39,60.95) v5(69.39,58.99) v5(69.39,57.95) v5(69.39,56.02) v5(69.4,54.95) v5(70.38,67.96) v5(70.4,66.94) v5(70.38,64.98) v5(70.39,63.95) v5(70.38,61.99) v5(70.39,60.95) v5(70.38,59) v5(70.39,57.95) v5(70.38,56) v5(70.4,54.95) v5(71.4,67.95) v5(71.4,66.95) v5(71.38,64.98) v5(71.39,63.95) v5(71.38,61.98) v5(71.4,60.95) v5(71.37,58.97) v5(71.39,57.95) v5(71.39,55.99) v5(71.41,54.95) v5(72.4,67.95) v5(72.4,66.94) v5(72.38,64.97) v5(72.39,63.95) v5(72.4,61.95) v5(72.4,60.95) v5(72.4,58.97) v5(72.4,57.95) v5(72.4,55.98) v5(72.4,54.94) v5(73.41,67.96) v5(73.41,66.95) v5(73.39,64.97) v5(73.41,63.95) v5(73.4,61.95) v5(73.4,60.95) v5(73.4,58.97) v5(73.4,57.95) v5(73.4,55.98) v5(74.41,67.95) v5(74.39,66.94) v5(74.38,64.97) v5(74.41,63.95) v5(74.4,61.95) v5(74.4,60.95) v5(74.4,58.96) v5(74.4,57.95) v5(74.4,55.98) v5(74.4,54.95)
+VCC_GFXCORE: length 87
  TOP w0.254: PR773.1 23.47,87.44 v1(23.6,87.57) ; PL705.1 v1(48.11,80.88) ; v1(21.82,87.44) 21.18,86.81 21.18,86.64 PR768.2 ; PL704.1 v1(48.11,88.25)
  TOP w0.508: PC1112.1 v1(82.02,67.37) ; v1(83.49,67.21) 83.92,66.78 PC1113.1 ; v1(58.79,77.88) 59.16,77.5 RC84.1
  IN1 w0.254: v1(23.6,87.57) 23.6,88.58 24.99,89.98 27.41,89.98 29.56,92.14 35.72,92.14 36.1,92.52 45.06,92.52 46.73,90.84 46.73,88.05 47.09,87.69 47.55,87.69 v1(48.11,88.25)
  IN3 w0.254: v1(21.82,87.44) 21.82,87.69 22.2,88.08 22.83,88.08 24.36,89.61 24.36,92.02 24.76,92.42 26.11,92.42 26.62,91.91 35.51,91.91 36.55,90.87 39.2,90.87 39.58,91.25 v1(39.58,91.42)
  IN4 w0.254: v1(48.11,80.88) 48.11,81.33 47.9,81.54 47.9,82.56 44.5,85.97 43.66,85.97 42.14,87.49 42.14,89.73 40.74,91.12 39.88,91.12 v1(39.58,91.42)
  BOTTOM w0.254: v1(21.82,87.44) 21.18,86.81 21.18,86.64 PR768.2 ; v1(23.6,87.57) 23.47,87.44 PR773.1
  BOTTOM w0.508: v1(58.79,77.88) 58.86,77.88 59.96,76.78 RC54.1 ; PC1112.1 v1(82.02,67.37)
  vias: v1(48.61,79.06) v1(48.74,86.76) v1(48.78,85.54) v1(48.86,83.65) v1(49,84.44) v1(49,82.79) v1(49,81.6) v1(49.12,86.22) v1(49.2,88.94) v1(49.19,87.45) v1(49.25,79.69) v1(49.25,79.06) v1(49.41,86.81) v1(49.38,85.33) v1(49.38,82.23) v1(49.49,83.45) v1(49.69,84.44) v1(49.81,86.22) v1(49.88,82.79) v1(50.04,85.33) v1(50.01,79.06) v1(50.06,83.8) v1(50.39,84.41) v1(50.47,86.21) v1(50.63,83.52) v1(50.7,85.29) v1(50.77,82.79) v1(50.77,79.06) v1(51.13,86.21) v1(51.1,84.45) v1(51.27,83.6) v1(51.36,85.29) v1(51.41,82.79) v1(51.54,79.06) v1(51.89,86.21) v1(51.9,83.93) v1(51.92,83.2) v1(51.99,85.33) v1(51.95,84.65) v1(52.3,79.06) v1(53.06,80.33) v1(53.06,79.69) v1(53.06,79.06) v1(63.83,79.02) v1(76.39,73.95) v1(80.49,78.45) v1(81.01,89.37) v1(81.34,89.95) v1(81.41,88.84) v1(81.63,90.51) v1(81.84,89.33) v1(81.98,89.97) v1(86.9,85.08) v1(87.18,85.67) v1(87.58,85.13) v1(87.65,86.13) v4(85.77,85.64) v5(76.17,79.06) v5(76.39,75.95) v5(76.39,74.97) v5(76.38,72.99) v5(76.38,71.96) v5(76.39,70.96) v5(76.39,69.94) v5(76.39,68.95) v5(77.39,75.97) v5(77.4,74.96) v5(77.4,73.95) v5(77.4,72.95) v5(77.39,71.95) v5(77.4,70.96) v5(77.4,69.95) v5(77.4,68.95) v5(78.33,79.06) v5(78.46,80.84) v5(79.39,75.96) v5(79.39,74.97) v5(79.39,73.95) v5(79.39,72.97) v5(79.39,71.97) v5(79.39,70.97) v5(79.39,69.95) v5(79.39,68.97) v5(80.43,75.97) v5(80.4,74.96) v5(80.4,73.94) v5(80.4,72.95) v5(80.4,71.96) v5(80.4,70.96) v5(80.4,69.95) v5(80.4,68.95) v5(80.74,80.84) v5(80.74,79.06) v5(82.41,75.98) v5(82.41,74.95) v5(82.4,73.95) v5(82.41,72.95) v5(82.4,71.95) v5(82.4,70.95) v5(82.4,69.94) v5(82.4,68.95) v5(82.78,80.84) v5(82.78,79.06) v5(83.4,76.99) v5(83.41,75.98) v5(83.41,74.95) v5(83.41,73.95) v5(83.41,72.95) v5(83.41,71.95) v5(83.41,70.95) v5(83.41,69.94) v5(83.41,68.95) v5(84.94,80.84)
+VCC_PWR_SRC:
  vias: v1(32.62,63.17) v1(32.66,62.54) v1(32.65,61.85) v1(33.31,63.18) v1(33.32,62.51) v1(33.37,61.84) v1(34.38,83.95) v1(34.4,66.21) v1(34.38,60.22) v1(34.42,58.38) v1(34.43,57.75) v1(34.48,77.14) v1(34.45,72.12) v1(35.01,83.95) v1(35.04,66.18) v1(35.03,60.22) v1(35.09,72.11) v1(35.15,77.13) v1(35.36,89.88) v1(35.38,89.17) v1(35.41,88.5) v1(35.66,83.93) v1(35.69,71.79) v1(35.67,66.15) v1(35.69,60.25) v1(35.8,77.15) v1(38.1,49.84) v1(38.34,49.23) v1(38.95,48.96) v1(39.6,48.95) v1(40.36,47.86) v1(41.25,47.86) v1(42.14,47.86) v1(47.23,47.87) v1(47.86,47.88) v1(48.53,47.88) v2(33.18,60.85)
+VCC_SA: length 6.2
  TOP w0.356: JCPU1.M26 74.83,52.45 v1(74.38,52) ; v1(74.38,52) 74.9,51.48 JCPU1.L26 ; v1(74.38,52) 73.93,52.45 JCPU1.M27 ; JCPU1.J24 JCPU1.J25 75.9,49.65 75.58,49.97 v1(75.58,49.99) 75.56,49.97 75.35,49.97 74.9,49.51 JCPU1.J26 ; JCPU1.H25 75.9,48.56 v1(75.53,48.94) 75.04,48.45 JCPU1.H26
  vias: v1(44.28,35.17) v1(44.28,34.52) v1(44.3,33.88) v1(44.31,33.24) v1(44.32,32.59) v1(44.33,31.95) v1(44.56,35.76) v1(45.11,36.13) v1(60.44,39.27) v1(60.44,38.62) v1(61.07,39.28) v1(65.19,43.21) v4(61.38,42.41)
+VCCA_USBSUS: length 2.3
  TOP w0.203: v1(32.94,114.71) 32.95,114.71 UH4.AN23
  BOTTOM w0.102: v2(34.65,114.76) CH62.1
  BOTTOM w0.508: CH62.1 33,114.76 v1(32.94,114.71)
+VCCACLK: length 6.8
  TOP w0.102: RH200.2 32.36,131.17 32.98,130.54 v2(33.04,130.54)
  TOP w0.254: 31.43,131.22 31.36,131.22 30.88,130.75 30.72,130.75 30.28,130.3 30.19,130.3 29.17,129.29 UH4.AD49
  TOP w0.508: 31.43,131.22 31.89,131.69 RH200.2
+VCCADAC: length 17.9
  TOP w0.254: v1(25.51,128.73) 25.6,128.64 25.6,127.82 UH4.U48
  IN3 w0.508: v1(25.51,128.73) 25.86,128.73 27.13,130 27.13,131.85 28.8,133.53 28.8,135.37 28.29,135.88 27.62,135.88 v1(27.58,135.92)
  BOTTOM w0.127: CH37.1 23.82,134 v2(24,133.82)
  BOTTOM w0.508: CH34.1 CH35.1 25.27,128.97 v1(25.51,128.73) ; v1(27.58,135.92) 27.27,135.92 26.8,135.45 LH1.2 26.73,135.24 CH36.1 24.79,135.24 24.5,134.95 CH37.1
+VCCAFDI_VRM: length 108
  TOP w0.254: v1(27.44,128.89) 27.44,128.81 27.2,128.57 27.2,128.17 UH4.Y49 ; v1(34.29,112.42) 34.33,112.42 34.7,112.05 UH4.AT16 34.63,111.82 34.12,111.82 UH4.AP16 ; v1(30.63,109.02) 30.47,109.02 30.2,109.29 UH4.AF11
  TOP w0.508: v1(48.5,112.76) 58.99,112.76 64.9,118.67 64.9,128.45 v1(64.78,128.56)
  IN2 w0.254: v1(30.63,109.02) 31.11,108.54 31.11,108.05 31.46,107.71 32.87,107.71 33.21,108.05 33.21,108.52 v1(33.69,109) ; v1(48.5,112.76) 48.32,112.59 43.93,112.59 42.81,111.47 41.84,111.47 40.94,112.37 40.52,112.37 39.62,113.27 35.79,113.27 35,112.48 34.35,112.48 v1(34.29,112.42)
  IN3 w0.508: v1(54.98,130.96) 55.09,130.85 55.09,130.76 55.54,130.32 64.13,130.32 64.36,130.09 64.36,129.71 64.3,129.64 64.3,129.05 v1(64.78,128.56)
  IN4 w0.508: v1(36.24,133.74) 34.99,132.49 31.58,132.49 30.85,131.75 29.6,131.75 27.44,129.59 v1(27.44,128.89)
  BOTTOM w0.254: v1(30.63,109.02) 30.63,109.01 30.14,108.52 30.14,108.12 30.42,107.83 30.64,107.83 31.12,107.35 31.12,106.95 31.11,106.94 31.11,105.98 31.16,105.94 31.16,105.54 30.87,105.25 30.13,105.25 30.05,105.17 RH211.1 ; v1(34.29,112.42) 34.29,112.13 35.21,111.21 35.21,110.85 35.06,110.71 35.06,110.08 34.67,109.69 34.38,109.69 v1(33.69,109)
  BOTTOM w0.508: v1(36.24,133.74) 36.66,133.33 v2(38.26,133.33) 46.37,133.33 47.97,134.93 51.22,134.93 51.65,134.49 51.65,132.82 53.5,130.96 v1(54.98,130.96)
+VCCAPLL_CPY_PCH: length 8.3
  TOP w0.254: 42.71,117.03 41.86,116.18 41.86,115.7 41.53,115.36 UH4.BH23
  TOP w0.508: LH3.2 47.38,116.65 46.4,116.65 CH58.1 45.93,117.12 44.26,117.12 44.17,117.03 v2(43.43,117.03) 42.71,117.03
+VCCAPLL_FDI: length 8.5
  TOP w0.254: v1(39.53,106.49) 40.14,106.49 UH4.BG6
  TOP w0.508: RH195.2 40.38,101.71 v1(40.11,101.99)
  IN3 w0.508: v1(40.11,101.99) 40.11,102.32 39.05,103.38 39.05,106.15 39.39,106.49 v1(39.53,106.49)
  BOTTOM w0.102: v2(40.11,101.38) v1(40.11,101.99)
+VCCAPLLEXP: length 7.8
  TOP w0.254: 44.69,116.42 42.67,116.42 42.22,115.97 42.22,115.54 41.55,114.86 UH4.BJ22
  TOP w0.508: 44.69,116.42 v2(45.05,116.42) 46.14,115.33 CH40.1 47.66,115.33 RH247.2
+VCCDFTERM: length 56.2
  TOP w0.254: v1(31.35,112.34) 31.75,111.93 UH4.AJ16 ; v1(31.35,112.34) UH4.AG16 ; v1(31.35,112.34) 30.99,112.69 UH4.AG17 31.34,113.09 v1(31.34,113.15) 31.35,113.15 31.75,112.75 UH4.AJ17
  TOP w0.508: v1(38.84,101.97) 39.22,101.59 RH149.1
  IN3 w0.254: v1(31.34,113.15) 31.42,113.15 33.16,111.4 33.16,110.3 33.18,110.27 33.18,105.02 32.47,105.02 32.05,105.44 32.05,106.02 32.17,106.13 32.17,111.16 31.35,111.98 v1(31.35,112.34)
  IN3 w0.508: 33.62,102.01 31.25,99.64 30.01,99.64 29.35,98.98 29.35,98.11 29.64,97.82 v1(29.64,97.47) ; 33.62,102.01 35.81,102.01 36.35,102.54 38.48,102.54 38.84,102.18 v1(38.84,101.97) ; 33.62,102.01 33.08,102.01 32.5,102.59 32.5,103.76 33.18,104.45 33.18,105.02
  IN4 w0.254: v1(31.35,112.34) 31.35,112.31 30.14,111.1 30.14,108.12 30.62,107.63 30.84,107.63 31.16,107.32 31.16,104.26 31.3,104.12 31.3,101.91 30.44,101.04 30.44,100.18 30.53,100.09 30.53,98.35 v1(29.64,97.47)
  BOTTOM w0.508: CH52.1 32.02,112.31 31.37,112.31 v1(31.35,112.34)
  vias: v2(30.45,97.84)
+VCCDSW3_3: length 27
  TOP w0.254: UH4.T16 25.25,111.96 25.65,112.36 25.65,112.38 v1(25.66,112.38)
  TOP w0.508: RH201.2 RH253.2 30.83,97.51 v1(31.01,97.69)
  IN1 w0.508: v1(31.01,97.69) 30.59,98.11 29.23,98.11 29.2,98.07 28.25,98.07 27.82,97.64 26.03,97.64 25.04,98.63 24.6,98.63 v1(24.6,98.63)
  IN4 w0.254: v1(25.66,112.38) 25.98,112.38 27.18,111.19 27.18,110.76 27.18,110.76 27.18,107.9 27.18,107.9 27.18,105.44 26.9,105.16 26.9,101.36 25.3,99.76 25.3,99.32 v1(24.6,98.63)
  BOTTOM w0.102: v2(26.34,111.44) CH55.1
  BOTTOM w0.508: v1(25.66,112.38) 25.69,112.35 CH55.1
+VCCRTCEXT: length 2.1
  TOP w0.254: UH4.N16 23.95,111.87 23.56,111.47 v3(23.56,111.4)
  BOTTOM w0.508: v3(23.56,111.4) 23.56,111.65 24.01,112.1 CH78.1
+VCCSA_BT:
  vias: v2(46.76,20.93)
+VCCSA_EN: length 6
  BOTTOM w0.102: v2(46.2,24.54) 46.2,23.22 45.69,22.71 PR606.1
  BOTTOM w0.254: PU601.13 48.13,20.32 47.91,20.54 47.79,20.54 46,22.33 46,22.4 PR606.1
+VCCSA_P: length 18.1
  TOP w0.508: v1(46.35,11.95) 46.35,22.77 45.44,23.69 45.43,23.69 44.94,24.18 44.94,26.41 v1(46.49,27.97)
  BOTTOM w0.508: PR610.1 46.84,12.4 46.39,11.95 v1(46.35,11.95)
  vias: v4(42.48,30)
+VCCSA_PHASE:
  vias: v2(44.69,14.59)
+VCCSA_PWR_SRC:
  vias: v2(52.88,15.57)
+VCCSA_PWRGD: length 7.9
  BOTTOM w0.102: v2(50.25,25.54) 49.73,25.54 49.23,25.03 PR602.2
  BOTTOM w0.254: PU601.16 49.63,20.9 48.36,22.16 48.36,24.93 PR603.2 PR602.2
+VCCSA_SNUB: length 3.3
  BOTTOM w0.102: PC616.1 37.27,14.33 v2(36.76,14.84)
  BOTTOM w0.508: PC616.1 38.8,14.33 39.1,14.03 PR608.2
+VCCSATAPLL: length 5.9
  TOP w0.254: 33.16,101.91 v2(32.97,102.1) 32.66,102.4 32.66,104.02 UH4.AK1
  TOP w0.508: LH5.1 35.62,101.11 CH80.1 33.88,101.12 33.16,101.84 33.16,101.91
+VCCSPI: length 6.7
  TOP w0.254: UH4.V1 26.48,104.26 26.48,103.19
  TOP w0.508: 26.48,103.19 27.28,102.39 v2(27.28,102.13) CH54.1 28.53,101.12 RH204.2 RH202.2
+VCCSST: length 1.4
  TOP w0.254: UH4.V16 26.01,111.93 25.69,111.61 25.69,111.58 v1(25.67,111.57)
  BOTTOM w0.508: v1(25.67,111.57) 25.42,111.31 CH84.1
+VCCSUS1: length 3.4
  TOP w0.203: v1(32.97,115.51) 32.94,115.54 32.94,115.57 UH4.AL24
  BOTTOM w0.102: v2(32.62,117.51) 32.62,117.3 33.56,116.36 CH61.1
  BOTTOM w0.508: CH61.1 33.56,115.91 33.16,115.51 v1(32.97,115.51)
GND: length 2777.5
  TOP w0.102: v4(188.06,91.38) 188.39,91.71 v1(188.39,92.15) ; v1(31.75,136.94) v4(31.75,137.58) ; v1(111.85,112.88) v4(111.85,112.09) ; v1(189.23,96.84) v4(189.23,97.57) ; v1(186.54,62.08) v4(186.54,62.93) ; v1(42.4,95.01) v4(42.4,95.68) ; v1(192.1,73.15) v4(192.1,73.83) ; v1(124.13,85.5) 124.13,84.89 v4(123.85,84.61) ; v1(101.38,146) v4(100.71,146) ; v1(66.2,91.35) v4(66.88,91.35) ; v1(182.12,87.3) v4(182.84,87.3)
  TOP w0.203: v1(16.52,125.4) 16.67,125.25 17.4,125.25 17.51,125.14 18.27,125.14 UH4.B43 ; U9.43 40.17,141.81 40.09,141.73 v1(40.09,141.68) ; v1(40.65,151.09) 40.65,150.41 40.97,150.09 U9.26 ; v1(41.78,144.91) 41.57,145.11 U9.38 ; v1(41.68,146.19) 41.56,146.31 U9.35
  TOP w0.254: v1(69.86,135.17) 69.61,135.42 U11.11 ; C788.2 45.35,99.19 C764.2 ; v1(27.15,150.97) 27.19,150.93 27.25,150.93 27.82,150.36 U12.10 ; U18.6 141.07,155.69 v1(140.77,155.39) 140.57,155.58 U18.5 ; JEDP1.19 58.24,156.98 58.46,157.2 v1(58.46,157.42) ; v1(87.27,41.99) 87.27,41.95 87.77,42.45 JCPU1.B13 ; v1(64.21,144.74) 64.24,144.71 JLVDS1.37 ; JEDP1.28 53.74,157.26 53.55,157.44 v1(52.72,157.44) 52.55,157.44 52.24,157.13 JEDP1.31 ; JCPU1.AH30 JCPU1.AH29 ; U12.1 32.32,151.08 v1(32.22,151.18) ; v1(48,157.39) 48,157.34 47.74,157.08 JEDP1.40 ; v1(72.44,47.83) 72.44,47.66 72.22,47.45 71.9,47.45 JCPU1.G29 JCPU1.F29 ; UH4.Y46 27.19,126.68 26.9,126.98 26.73,126.98 26.7,127.02 v1(26.73,127.05) 26.7,127.05 26.67,127.08 26.69,127.09 26.69,127.7 UH4.W48 ; v1(32.98,146.38) 33.17,146.38 33.46,146.67 33.46,146.91 33.24,147.14 U12.25 ; JLVDS1.30 67.77,144.64 68.03,144.91 68.82,144.91 v1(69.02,144.7) 69.24,144.49 JLVDS1.27 ; JCPU1.AT29 71.9,76.91 72.24,77.24 v1(72.24,77.23) ; JCPU1.E13 87.79,45.45 87.28,44.94 v1(87.27,44.94) ; U12.12 26.39,148.14 25.7,147.46 v1(25.7,147.43) ; v5(70.38,70.89) 70.82,70.45 JCPU1.AK30 ; JLVDS1.17 74.27,144.51 74.09,144.69 v1(73.01,144.69) 72.77,144.45 JLVDS1.20 ; U12.27 33.73,148.14 v1(33.81,148.07) ; JCPU1.AH34 JCPU1.AH35 64.85,68.45 64.7,68.59 v1(64.15,68.59) ; JEDP1.25 55.24,157.08 55.54,157.38 55.6,157.38 v1(55.66,157.44) 55.73,157.38 55.87,157.38 56.24,157 JEDP1.23 ; v1(62.32,144.68) 62.44,144.68 62.77,144.35 JLVDS1.40 ; v1(50.06,158.09) 49.24,157.26 JEDP1.37 ; U12.20 30.32,145.36 v1(30.5,145.17) ; JXDP2.59 62.06,108.59 62.06,107.23 62.57,106.72 64.34,106.72 64.57,106.95 JXDP2.49 ; v1(289.85,99.45) 289.69,99.3 D16.3 D16.8 ; v1(87.27,47.92) 87.29,47.92 87.82,48.45 JCPU1.H13 ; JEDP1.34 v1(50.74,157.44) ; PC732.2 19.4,77.5 19.4,78.33 18.9,78.84 PC740.1 ; v1(196.46,147.27) JMXM1.101 ; v1(142.57,164.25) U18.28 ; v1(142.57,155.45) U18.9 ; v1(54.7,136.34) 55.05,136.69 U13.11 ; U12.14 26.92,147.14 v1(26.55,146.77) ; v1(100.44,69.92) 100.44,69.84 100.05,69.45 JCPU1.AJ1 99.87,69.42 98.93,69.42 JCPU1.AJ2 ; U18.31 141.07,163.94 v1(140.84,164.17) 140.57,163.91 U18.32
  TOP w0.279: v1(204.32,130.62) 204.92,130.02 JMXM1.162 ; v1(207.11,140.02) JMXM1.130 ; v1(202.67,114.17) 202.67,113.73 203.57,112.83 204.89,112.83 205.19,112.52 JMXM1.232 ; v1(198.82,112.64) 198.68,112.77 JMXM1.233 ; v1(207.36,133.67) 207.11,133.67 206.76,134.02 JMXM1.154 ; v1(64.55,101.35) 64.55,101.41 64.57,101.43 JXDP2.50 ; 69.03,104.63 70.17,104.63 70.57,104.24 JXDP2.26 ; 69.03,104.63 v1(68.95,104.71) 68.23,104.71 67.57,104.05 JXDP2.38 ; 69.03,104.63 69.03,102.9 JXDP2.32 ; v1(204.28,128.93) 204.69,128.52 JMXM1.168 ; JMXM1.256 206.84,106.52 v1(207.39,105.97) ; JMXM1.113 196.41,144.27 v1(196.33,144.35) ; JMXM1.220 204.91,115.52 204.87,115.48 v1(204.76,115.48) ; v1(196.39,136.77) JMXM1.143 ; JMXM1.148 207.18,135.52 v1(207.36,135.7) ; JMXM1.142 205,137.02 204.7,136.72 v1(204.44,136.72) ; JXDP2.2 76.56,103.96 75.84,104.69 v1(75.07,104.69) 75.06,104.68 JXDP2.8 ; JMXM1.131 198.58,139.77 v1(198.93,140.12) ; JMXM1.194 205.9,122.01 206.94,122.01 v1(207.11,122.17) ; v1(196.45,148.77) JMXM1.95 ; v1(76.52,106.96) 76.56,107.01 JXDP2.1 ; v1(196.39,135.27) JMXM1.149 ; v1(15.57,161.25) 15.74,161.08 U48.1 ; JXDP2.14 73.57,104.89 v1(73.63,104.95) 73.54,105.04 72.26,105.04 72.06,104.85 JXDP2.20 ; JMXM1.106 206.89,146.02 206.98,146.11 v1(207.11,146.11) ; JMXM1.136 204.75,138.52 204.68,138.58 204.61,138.58 v1(204.44,138.75) ; v1(196.35,145.77) JMXM1.107 ; v1(196.43,151.6) 196.59,151.77 JMXM1.83 ; JMXM1.227 198.86,114.27 v1(198.86,114.28) ; v1(196.57,117.4) 196.7,117.27 JMXM1.215 ; v1(198.98,128.84) 198.91,128.77 JMXM1.169 ; JXDP2.31 69.06,107.5 v1(68.65,107.09) ; v1(196.44,141.27) JMXM1.125 ; v1(207.36,132.52) JMXM1.160 ; v1(196.44,124.27) JMXM1.187 ; v1(203.68,125.54) 203.7,125.52 JMXM1.180 ; JMXM1.155 198.69,133.77 v1(198.92,134) ; JMXM1.208 204.57,118.52 v1(204.56,118.52) ; JMXM1.174 204.74,127.02 204.19,127.57 v1(203.68,127.57) ; v1(207.11,141.54) 207.09,141.52 JMXM1.124 ; v1(67.68,110.5) 67.57,110.39 JXDP2.37 ; JMXM1.163 198.87,130.27 v1(198.97,130.18) ; JMXM1.161 v1(196.44,132.27) ; v1(198.98,126.94) 198.87,127.05 198.77,127.05 198.55,127.27 JMXM1.175 ; JMXM1.226 204.79,114.02 v1(204.73,114.08) ; v1(198.86,111.36) 198.78,111.27 JMXM1.239 ; JMXM1.137 198.94,138.27 v1(198.97,138.24) ; JXDP2.19 72.06,107.46 71.63,107.02 v1(70.57,107.02) JXDP2.25 ; JMXM1.214 204.78,117.02 v1(204.76,117) ; JMXM1.245 198.8,109.77 v1(198.86,109.83) ; JXDP2.60 v1(62.06,101.33) ; JXDP2.13 v1(73.57,106.98) ; U54.B11 v1(162.86,146.13) ; v1(196.48,142.77) JMXM1.119 ; JXDP2.7 v1(75.06,106.97) ; JMXM1.100 204.56,147.52 v1(204.44,147.64) ; v1(196.44,125.77) JMXM1.181 ; v1(207.24,143.32) 206.94,143.02 JMXM1.118
  TOP w0.305: v1(78.4,75.97) 78.88,76.45 JCPU1.AT22 ; v1(78.4,71.95) 78.9,72.45 JCPU1.AM22 ; v1(87.4,69.94) 87.9,70.44 JCPU1.AK13 ; JCPU1.AR10 90.9,75.42 v1(91.4,74.92) 90.93,74.45 JCPU1.AP10 ; JCPU1.AT19 81.9,76.44 v5(81.43,75.97) ; JCPU1.AL13 87.9,71.42 v1(87.4,70.92) ; JCPU1.AH32 68.75,68.45 68.39,68.81 68.39,69.89 v5(68.35,69.93) ; v1(90.4,73.92) 90.87,73.45 JCPU1.AN10 ; JMXM1.281 198.7,100.77 v1(198.86,100.93) ; v1(204.74,103.05) 204.74,102.96 205.17,102.52 JMXM1.272 ; JCPU1.AM19 81.9,72.4 v5(81.43,71.93) ; v1(204.71,99.48) 204.75,99.52 JMXM1.284 ; v1(204.71,96.5) 204.73,96.52 JMXM1.296 ; U88.5 126.83,100.59 127.15,100.27 127.95,100.27 v1(128.19,100.03) ; JCPU1.AR19 81.9,75.39 v5(81.43,74.92) ; JMXM1.82 206.78,152.02 207.58,152.82 v1(208.25,152.82) ; JXDP2.59 62.06,109.55 61.85,109.77 61,109.77 60.34,109.11 v1(60.34,109.07) ; U54.B66 163.72,151.45 164.11,151.07 v1(164.11,150.94) ; JCPU1.AJ13 v1(87.4,68.95) ; U88.12 125.33,104.73 v1(125.11,104.94) 124.83,104.66 U88.13 ; v1(37.87,27.56) 37.86,27.55 JIO1.62 ; JCPU1.AP13 87.89,74.45 v1(87.41,74.93) ; JCPU1.AM10 90.9,72.42 v1(90.4,71.92) 90.87,71.45 JCPU1.AL10 ; JMXM1.238 204.69,111.02 v1(204.67,111) ; JCPU1.AK22 78.88,70.45 v1(78.4,69.97) ; JMXM1.94 205.13,149.02 v1(204.67,149.48) 204.67,150.14 205.05,150.52 JMXM1.88 ; JCPU1.AN13 87.9,73.43 v1(87.41,72.94) ; v1(78.4,70.96) 78.89,71.45 JCPU1.AL22 ; v1(169.86,149.02) 169.86,149.53 169.4,149.99 169.4,151.11 169.72,151.43 U54.B54 ; JCPU1.AN19 81.9,73.43 v5(81.43,72.96) ; v1(204.67,101.02) 204.68,101.02 JMXM1.278 ; JCPU1.AR13 87.88,75.45 87.4,75.93 v1(87.4,75.98) ; JMXM1.299 196.76,96.27 v1(196.44,96.58) 196.41,96.62 196.41,97.31 196.87,97.77 JMXM1.293 ; JMXM1.72 206.74,154.52 v1(207.1,154.17) ; v5(81.43,70.99) 81.89,71.45 JCPU1.AL19 ; v1(73.4,77.34) 73.4,77.32 73.9,76.82 JCPU1.AT27 ; JMXM1.203 196.85,120.27 196.57,119.99 v1(196.57,119.51) 196.57,119.13 196.93,118.77 JMXM1.209 ; U88.10 v1(126.33,104.96) ; JCPU1.AR22 78.89,75.45 v1(78.4,74.96) ; v5(84.4,73.95) JCPU1.AN16 84.4,72.95 JCPU1.AM16 84.4,71.95 JCPU1.AL16 84.4,70.95 JCPU1.AK16 v5(84.4,69.95) JCPU1.AJ16 84.9,69.42 v5(84.43,68.95) 84.9,68.48 JCPU1.AH16 ; v5(81.43,73.9) 81.9,74.37 JCPU1.AP19 ; JCPU1.AP22 78.9,74.45 v1(78.4,73.95) ; JMXM1.290 204.71,98.02 v1(204.67,97.98) ; JCPU1.AT10 90.9,76.42 v1(90.4,75.92) ; v1(90.4,70.92) 90.87,70.45 JCPU1.AK10 ; v1(196.42,150.52) 196.42,150.44 196.59,150.27 JMXM1.89 ; v1(87.4,76.95) 87.89,76.45 JCPU1.AT13 ; JMXM1.202 v1(207.02,120.02) ; JMXM1.221 196.6,115.77 196.34,115.51 v1(196.18,115.51) ; v1(78.4,72.96) 78.89,73.45 JCPU1.AN22 ; JMXM1.251 198.92,108.27 v1(198.92,108.27) ; JCPU1.AM13 87.9,72.43 v1(87.41,71.94) ; JCPU1.AH22 78.88,68.45 v1(78.4,68.93) 78.9,69.43 JCPU1.AJ22 ; v1(207.85,145.16) 207.21,144.52 JMXM1.112 ; v1(166.72,151.02) U54.B60 ; JMXM1.73 v1(196.44,154.27) ; JCPU1.AH19 81.9,68.48 v5(81.43,68.95) 81.9,69.42 JCPU1.AJ19 ; JCPU1.AK19 81.9,70.4 v5(81.43,69.93) ; v1(90.4,69.92) 90.87,69.45 JCPU1.AJ10
  TOP w0.33: JCPU1.G20 JCPU1.F19 ; JCPU1.AP28 v5(73.4,73.95) ; v1(74.32,46.94) 74.41,46.85 74.41,45.97 73.9,45.46 JCPU1.E27 ; v1(199.4,94.55) 199.18,94.77 JMXM1.305
  TOP w0.356: v5(76.38,42.96) 75.9,43.44 JCPU1.C25 JCPU1.D26 ; JDIMM3.156 147.24,69.4 146.55,68.71 v1(146.55,66.61) 146.55,65.5 148.05,64 JDIMM3.138 ; v1(98.4,41.97) 98.4,41.92 ; 98.4,41.92 97.93,41.45 JCPU1.A3 ; 98.4,41.92 97.9,42.42 JCPU1.B3 ; JCPU1.D35 65.8,44.45 v1(65.21,43.86) ; JIO1.121 31.97,9.55 v1(32.23,9.28) 31.9,8.95 JIO1.123 ; JDIMM1.162 133.77,71.2 133.31,71.66 133.31,72.7 ; JDIMM1.26 133.31,28 133.26,27.95 v1(133.26,27.92) 133.26,26.55 133.6,26.2 JDIMM1.20 ; JDIMM1.9 144.55,22.9 144.68,22.77 144.68,21.1 ; JIO1.134 36.2,5.94 35.16,5.94 35.03,6.08 33.39,6.08 v1(33.27,6.2) ; JDIMM1.25 144.52,27.7 144.59,27.77 ; JIO1.132 35.18,6.55 35.11,6.62 34.26,6.62 33.93,6.95 33.93,7.18 v1(33.91,7.2) ; v5(99.4,62.92) 98.9,63.42 JCPU1.AC2 ; v1(144.83,80.87) 144.6,81.1 JDIMM1.195 ; JCPU1.F31 69.92,46.45 70.39,45.97 v1(70.5,45.97) ; 144.59,27.77 144.59,25.86 v1(144.54,25.81) 144.45,25.9 JDIMM1.19 ; 144.59,27.77 144.59,29.27 144.36,29.5 JDIMM1.31 ; JCPU1.E24 76.9,45.62 77.28,46.01 77.3,46.01 77.34,46.05 v1(77.33,46.05) ; 98.4,45.92 98.87,45.45 JCPU1.E2 ; 98.4,45.92 v1(98.4,45.93) ; 98.4,45.92 97.93,45.45 JCPU1.E3 ; v1(70.47,52.05) 70.47,52.03 70.9,51.6 JCPU1.L30 70.9,51.44 71.89,50.45 JCPU1.K29 ; JCPU1.K35 65.91,50.45 v5(66.38,49.98) 66.9,49.46 JCPU1.J34 ; JCPU1.P9 91.9,54.4 v1(91.4,53.91) ; JCPU1.H30 70.9,48.56 70.51,48.95 v1(70.5,48.95) ; v1(37.77,25.69) 37.73,25.69 37.67,25.75 JIO1.68 ; v1(97.4,48.92) 97.87,48.45 JCPU1.H3 ; JCPU1.AR4 97.34,75.01 97.34,74.99 v1(97.4,74.92) ; v1(158.8,37.51) 158.8,36.94 158.56,36.7 JDIMM3.55 ; 145.71,71.18 145.13,70.6 145.13,69.97 144.26,69.1 JDIMM1.155 ; 145.71,71.18 v1(145.71,71.22) ; 145.71,71.18 145.71,69.59 144.62,68.5 JDIMM1.153 ; v1(145.29,33.11) 145.3,33.1 JDIMM1.43 ; JIO1.56 35,29.35 34.75,29.1 v1(34.75,28.74) ; v1(77.32,48.95) 77.32,48.9 76.9,48.49 JCPU1.H24 ; JCPU1.AK27 v5(73.4,70.95) ; JDIMM3.189 159.37,79.3 159.87,78.81 v1(159.87,78.5) ; v1(132.43,34.85) 132.43,35.15 133.68,36.4 JDIMM1.54 ; v1(93.4,44.94) 93.4,44.92 93.9,45.42 JCPU1.E7 ; v1(146.19,27.73) 146.19,27.33 147.32,26.2 JDIMM3.20 ; 80.38,44.9 79.9,45.38 JCPU1.E21 ; 80.38,44.9 80.83,44.45 JCPU1.D20 ; 80.38,44.9 v1(80.38,44.86) ; v1(67.4,48.97) 67.4,48.88 67.83,48.45 JCPU1.H33 ; JCPU1.E15 85.92,45.45 86.41,45.94 86.42,45.93 v1(86.42,45.93) ; v5(68.35,69.93) 68.3,69.93 67.9,70.33 JCPU1.AK33 ; JDIMM3.139 v1(159.26,64.3) 159.26,65.94 159.1,66.1 JDIMM3.145 ; 98.4,56.92 98.9,57.42 JCPU1.U2 ; 98.4,56.92 v1(98.39,56.92) ; 98.4,56.92 97.9,57.42 JCPU1.U3 ; JCPU1.AP7 93.87,74.45 v1(93.4,74.92) ; 133.31,72.7 v1(133.31,72.7) ; 133.31,72.7 133.61,73 JDIMM1.168 ; JIO1.113 32.04,11.95 v1(32.31,11.68) 31.97,11.35 JIO1.115 ; JIO1.139 31.55,4.15 32.4,3.3 v1(32.43,3.3) ; v1(32.36,29.43) 32.28,29.35 JIO1.55 ; v1(97.4,69.92) 97.4,69.95 JCPU1.AK4 ; v1(94.4,41.97) 94.4,41.96 94.4,41.92 93.9,42.42 JCPU1.B7 93.88,42.45 v1(93.4,41.97) 93.4,41.96 93.4,41.92 92.9,42.42 JCPU1.B8 ; v1(74.32,46.94) 74.39,46.94 74.9,47.45 JCPU1.G26 ; JCPU1.E4 96.9,45.42 96.4,44.92 v1(96.4,44.94) ; 83.32,44.9 82.9,45.32 JCPU1.E18 ; 83.32,44.9 83.77,44.45 JCPU1.D17 ; 83.32,44.9 v1(83.32,44.94) ; 145.48,39.6 145.48,39.27 146.55,38.2 JDIMM3.60 ; v1(68.36,50.96) 68.87,50.45 JCPU1.K32 ; v1(37.69,42.77) 37.47,42.55 JIO1.12 ; JCPU1.AG4 96.9,67.42 v1(97.4,66.92) 97.87,66.45 JCPU1.AF3 ; v1(32.55,4.81) 32.55,4.84 32.04,5.35 JIO1.135 ; JCPU1.AT35 65.83,76.45 v1(65.31,76.97) ; JCPU1.L8 92.9,51.42 v1(92.4,50.92) ; JDIMM1.190 133.73,79.6 133.31,80.02 v1(133.31,81.17) 133.54,81.4 JDIMM1.196 ; v1(144.86,76.1) 144.66,76.3 JDIMM1.179 ; v1(92.4,44.94) 92.4,44.92 92.9,45.42 JCPU1.E8 ; JCPU1.AN7 93.93,73.45 v1(94.4,73.92) ; v1(97.4,75.92) 97.9,76.42 JCPU1.AT3 JCPU1.AR2 ; JCPU1.A35 65.67,41.45 v1(65.28,41.84) ; JDIMM3.44 147.21,33.4 v1(146.92,33.11) 146.73,33.3 146.73,33.69 147.04,34 JDIMM3.46 ; JCPU1.B2 98.93,42.45 99.4,42.92 v1(99.4,42.96) 99.9,43.45 JCPU1.C1 ; v1(145.1,73.18) 145.1,74.01 144.61,74.5 JDIMM1.173 ; v1(131.53,40.06) 131.53,39.36 132.7,38.2 JDIMM1.60 ; v1(97.4,50.92) 97.9,51.42 JCPU1.L3 ; JCPU1.AE9 91.94,65.45 92.42,64.96 v1(92.4,64.96) ; v1(97.4,47.92) 96.9,48.42 JCPU1.H4 ; v1(98.4,71.92) 98.9,72.42 JCPU1.AM2 ; JDIMM1.136 133.75,63.4 v1(133.26,63.89) 133.37,64 JDIMM1.138 ; v1(100.4,50.92) 99.9,51.42 JCPU1.L1 ; v1(144.46,73.18) 144.46,72.96 144.21,72.7 JDIMM1.167 ; v1(158.93,79.96) 158.89,80 158.89,80.68 158.47,81.1 JDIMM3.195 ; v1(133.31,31.21) 133.7,31.6 JDIMM1.38 ; v1(159.1,70.04) 159.1,69.91 158.29,69.1 JDIMM3.155 ; JDIMM1.66 132.82,40 v1(132.88,40.07) ; v1(98.39,62.92) 98.4,62.92 97.9,63.42 JCPU1.AC3 ; v1(72.39,68.91) 71.93,68.45 JCPU1.AH29 ; JDIMM1.144 133.01,65.8 132.69,66.12 132.69,66.19 v1(132.66,66.22) 132.62,66.26 132.62,67.24 132.98,67.6 JDIMM1.150 ; v1(159.1,61.54) 158.26,60.7 JDIMM3.127 ; JDIMM1.128 133.84,61 133.38,61.46 132.73,61.46 v1(132.69,61.5) 132.69,61.5 132.68,61.51 132.68,62.09 133.38,62.8 JDIMM1.134 ; v1(94.39,62.92) 94.4,62.92 94.9,63.42 JCPU1.AC6 ; JDIMM3.43 158.44,33.1 158.82,33.47 ; v1(158.74,25.81) 158.65,25.9 JDIMM3.19 ; JCPU1.A20 80.93,41.45 81.9,42.42 JCPU1.B19 ; JCPU1.Y2 98.79,60.34 98.01,60.34 JCPU1.Y3 97.9,60.42 v1(97.4,59.92) ; JCPU1.C23 77.9,43.38 78.31,42.96 ; v1(133.37,24.43) 133.35,24.4 JDIMM1.14 ; JDIMM1.32 133.91,29.8 132.66,31.04 v1(132.66,31.21) ; JCPU1.AP4 97.4,73.95 v1(97.4,73.92) ; JDIMM3.61 158.8,38.5 159.03,38.73 v1(159.03,39.13) 157.32,39.13 JDIMM3.63 ; JCPU1.H1 99.87,48.45 v1(99.4,48.92) ; JCPU1.AP16 v5(84.4,74.95) JCPU1.AR16 v5(84.4,75.95) JCPU1.AT16 v5(84.4,76.95) ; 158.82,33.47 158.82,31.71 158.41,31.3 JDIMM3.37 ; 158.82,33.47 v1(158.82,33.71) ; JDIMM3.151 159.18,67.9 v1(159.24,67.84) 159.41,68 159.41,68.37 159.28,68.5 JDIMM3.153 ; JCPU1.L2 98.9,51.42 v1(98.4,50.92) ; JCPU1.G32 68.87,47.45 68.4,47.92 68.39,47.9 v1(68.41,47.9) ; v1(97.4,77.15) 97.46,77.09 97.46,76.84 97.08,76.45 JCPU1.AT4 ; JCPU1.AC5 95.88,63.45 v1(95.35,62.92) ; v1(68.41,41.95) 68.43,41.93 68.43,41.87 68.85,41.45 JCPU1.A32 ; JDIMM3.144 147.97,65.8 v1(147.51,66.26) 147.51,67.1 148,67.6 JDIMM3.150 ; JCPU1.AM3 97.9,72.42 97.41,71.93 v1(97.41,71.92) 96.9,72.43 JCPU1.AM4 ; JCPU1.L9 91.9,51.42 v1(91.4,50.92) ; JCPU1.AP34 66.8,74.45 v1(66.31,74.94) ; JCPU1.AM1 99.9,72.39 99.42,71.92 v5(99.4,71.92) ; JCPU1.B22 78.83,42.45 78.31,42.96 ; JDIMM1.133 144.58,62.5 144.82,62.74 144.82,63.81 v1(145.21,64.2) ; JDIMM1.55 144.37,36.7 144.72,36.35 v1(144.69,36.35) 144.69,35.49 144.1,34.9 JDIMM1.49 ; v1(32.51,4.09) 32.47,4.09 31.81,4.75 JIO1.137 ; v1(69.48,49.97) 69.9,49.55 JCPU1.J31 ; JDIMM1.145 144.16,66.1 144.52,66.46 v1(144.52,66.71) 144.52,67.4 144.02,67.9 JDIMM1.151 ; JDIMM3.31 158.77,29.5 v1(158.92,29.66) ; v1(146.92,31.31) 147.21,31.6 JDIMM3.38 ; v1(72.39,71.95) 72.88,71.45 JCPU1.AL28 ; v1(159.44,71.07) 159.27,70.9 JDIMM3.161 ; 146.4,64.09 v1(146.38,64.12) ; 146.4,64.09 146.45,64.05 146.9,64.05 147.55,63.4 JDIMM3.136 ; 146.4,64.09 146.4,63.13 146.73,62.8 JDIMM3.134 ; JCPU1.E6 94.9,45.42 94.4,44.92 v1(94.4,44.94) ; v1(93.4,68.92) 93.9,69.42 JCPU1.AJ7 ; v1(94.41,65.96) 94.41,65.97 94.89,66.45 JCPU1.AF6 JCPU1.AF5 ; JDIMM3.28 147.22,28.6 146.92,28.9 v1(146.92,29.51) 147.21,29.8 JDIMM3.32 ; JIO1.46 35.12,32.35 34.87,32.6 34.87,33.95 35.08,34.15 JIO1.40 38.3,34.15 38.75,34.6 v1(38.75,34.81) ; JCPU1.AL34 66.81,71.45 v1(66.32,71.95) ; 90.4,42.92 90.9,43.42 JCPU1.C10 ; 90.4,42.92 89.93,42.45 JCPU1.B11 ; 90.4,42.92 v1(90.4,42.96) ; v1(151.74,81.6) 151.74,81.98 151.36,82.36 150.72,82.36 150.47,82.11 150.47,81.85 150.02,81.4 JDIMM3.196 ; JCPU1.G17 83.88,47.45 83.42,47.91 v1(83.42,47.92) ; JIO1.41 32.21,33.55 v1(32.4,33.73) ; v1(34.58,7.19) 34.62,7.23 34.97,7.23 35.05,7.15 JIO1.130 ; v1(67.3,51.98) 67.3,51.96 67.81,51.45 JCPU1.L33 ; JCPU1.H9 91.9,48.42 v1(92.4,47.92) 92.9,48.42 JCPU1.H8 ; 144.68,21.1 JDIMM1.3 ; 144.68,21.1 v1(144.89,20.89) ; JCPU1.H6 94.9,48.42 v1(95.4,47.92) 95.9,48.42 JCPU1.H5 ; 95.4,50.96 95.4,50.97 94.92,51.45 JCPU1.L6 94.86,51.45 94.4,51 v1(94.4,50.92) ; 95.4,50.96 95.89,51.45 JCPU1.L5 96.4,50.95 v1(96.4,50.92) 96.9,51.42 JCPU1.L4 ; 95.4,50.96 v1(95.4,50.92) ; JDIMM3.179 158.79,76.3 v1(159.33,76.84) ; JCPU1.E10 90.9,45.42 90.4,44.92 v1(90.4,44.94) ; v1(146.25,41.38) 146.67,41.8 JDIMM3.72 ; 158.77,21.1 JDIMM3.3 ; 158.77,21.1 158.61,21.26 158.61,22.56 158.26,22.9 JDIMM3.9 ; 158.77,21.1 v1(158.83,21.05) ; JDIMM1.170 133.17,73.6 132.5,74.27 v1(132.5,74.61) 132.5,74.97 133.53,76 JDIMM1.178 ; JCPU1.F22 78.91,46.45 79.34,46.03 79.35,46.03 79.39,45.99 v1(79.38,45.99) ; v1(66.34,42.94) 66.34,42.98 66.82,43.45 JCPU1.C34 ; v1(132.23,40.06) 132.23,40.42 133.61,41.8 JDIMM1.72 ; v1(132.56,27.92) 132.56,28.23 132.92,28.6 JDIMM1.28 ; JCPU1.E9 91.9,45.42 91.4,44.92 v1(91.4,44.94) ; JCPU1.G35 65.71,47.45 65.28,47.88 v1(65.28,47.87) ; v1(34.73,21.87) 34.73,21.92 34.96,22.15 JIO1.80 ; JIO1.5 32.27,44.35 v1(32.36,44.26) ; JCPU1.M34 66.9,52.53 v1(66.45,52.99) ; JCPU1.AH7 93.9,68.42 v1(93.4,67.92) 92.93,67.45 JCPU1.AG8 ; v1(144.62,41.37) 144.62,41.09 144.21,41.5 JDIMM1.71 ; v1(91.4,47.92) 90.9,48.42 JCPU1.H10 ; JCPU1.G23 77.9,47.5 78.35,47.95 78.35,47.97 v1(78.33,47.97) ; v1(32.32,27.51) 32.29,27.55 JIO1.61 30.08,27.55 29.75,27.23 29.75,26.19 30.19,25.75 JIO1.67 ; JCPU1.AC8 92.9,63.42 v1(92.4,62.92) 91.9,63.42 JCPU1.AC9 ; v1(74.51,48.92) 74.04,48.45 JCPU1.H27 ; JCPU1.AJ4 96.9,69.42 v1(97.4,68.92) 97.9,69.42 JCPU1.AJ3 ; JCPU1.C31 69.9,43.51 v1(69.43,43.97) 68.96,44.45 JCPU1.D32 ; JCPU1.A29 72,41.45 v1(72.63,40.82) ; JDIMM1.127 144.3,60.7 v1(144.5,60.9) ; v1(79.42,48.92) 79.42,48.94 79.44,48.96 79.9,48.5 JCPU1.H21 JCPU1.G20 ; v1(146.2,79.29) 146.2,78.8 145.51,78.1 JDIMM1.185 ; v1(45.13,168.86) 44.98,169.01 U627.3 ; v1(93.36,63.95) 93.36,63.92 93.9,64.45 JCPU1.AD7 ; v1(94.4,72.92) 93.93,72.45 JCPU1.AM7 ; JDIMM3.187 158.96,78.7 v1(159.14,78.51) 158.73,78.1 JDIMM3.185 ; v1(37.62,20.05) 37.51,20.05 37.22,20.35 JIO1.86 ; JIO1.111 31.97,12.55 v1(32.27,12.85) 31.97,13.15 JIO1.109 29.56,13.15 29.18,13.53 C721.2 ; v1(69.42,77.02) 68.9,76.5 JCPU1.AT32 ; JCPU1.AG9 91.87,67.45 v1(91.4,67.92) ; v1(34.94,3.51) 34.94,3.59 35.49,4.15 JIO1.140 ; JCPU1.F34 66.9,46.45 v1(66.37,46.98) ; v5(94.39,56.98) 94.86,57.45 JCPU1.U6 ; JCPU1.C27 73.9,43.41 73.35,42.86 v1(73.35,42.9) 73.35,42.92 72.9,43.37 JCPU1.C28 ; JDIMM3.173 158.82,74.5 159.57,75.25 v1(159.57,75.58) ; JDIMM3.66 146.36,40 v1(146.26,39.91) ; JDIMM3.49 158.5,34.9 v1(158.8,34.6) ; JCPU1.AH4 96.87,68.45 v1(96.4,68.92) ; v1(100.52,75.04) 100.49,75.04 JCPU1.AP1 ; v1(158.77,27.37) 158.44,27.7 JDIMM3.25 ; JDIMM3.172 150.24,74.2 150.36,74.07 150.36,74.07 150.49,73.94 151.52,73.94 151.66,74.09 v1(151.66,74.56) ; v1(133.31,21.1) 133.61,20.8 JDIMM1.2 ; v1(132.61,72.72) 132.57,72.68 132.57,70.18 133.35,69.4 JDIMM1.156 ; JDIMM3.190 147.5,79.6 146.94,79.03 ; JCPU1.B5 95.9,42.42 96.4,41.92 v1(96.4,41.97) ; JCPU1.D29 71.9,44.48 70.93,45.45 JCPU1.E30 ; 78.31,42.96 v1(78.31,42.96) ; 98.48,53.93 98.9,54.35 JCPU1.P2 ; 98.48,53.93 v1(98.39,53.93) ; 98.48,53.93 97.96,54.45 JCPU1.P3 ; JCPU1.AT7 93.9,76.42 v1(94.4,75.92) 93.93,75.45 JCPU1.AR7 ; JCPU1.AM29 71.89,72.45 v5(71.38,72.96) 70.9,73.44 JCPU1.AN30 ; v1(146.92,36.71) 147.23,36.4 JDIMM3.54 ; JCPU1.U8 92.83,57.38 91.97,57.38 JCPU1.U9 91.9,57.43 91.42,56.94 v1(91.41,56.94) ; JDIMM3.48 146.65,34.6 146.18,34.13 v1(146.18,33.05) ; JDIMM3.13 158.7,24.1 v1(158.84,23.96) 158.38,23.5 JDIMM3.11 ; v1(95.4,44.94) 95.4,44.92 95.9,45.42 JCPU1.E5 ; JMXM1.287 199.84,99.27 200.81,100.24 200.81,100.72 v1(200.81,100.72) ; JCPU1.H7 93.9,48.42 v1(94.4,47.92) ; JCPU1.B9 91.9,42.42 92.4,41.92 92.4,41.96 v1(92.4,41.97) ; JCPU1.G11 89.93,47.45 v1(90.4,47.92) ; v1(146.45,60.8) 146.61,60.8 146.81,61 JDIMM3.128 ; v1(38.07,40.83) 37.99,40.75 JIO1.18 ; v1(99.4,70.92) 98.9,71.42 JCPU1.AL2 ; v1(146.92,24.44) 146.96,24.4 JDIMM3.14 ; v1(29.54,42.67) 29.66,42.55 JIO1.11 ; v1(204.11,109.33) 204.22,109.22 204.72,109.22 205.02,109.52 JMXM1.244 ; JCPU1.H15 85.81,48.45 85.31,47.94 v1(85.31,47.92) ; JCPU1.AL4 96.9,71.42 97.4,70.92 v1(97.4,70.91) ; JCPU1.AN4 96.9,73.42 97.39,72.93 v1(97.4,72.93) ; v1(37.9,38.7) 37.9,38.72 37.67,38.95 JIO1.24 ; v5(95.4,53.91) 95.43,53.91 ; 95.43,53.91 95.9,54.38 JCPU1.P5 ; 95.43,53.91 94.9,54.45 JCPU1.P6 ; JDIMM3.162 146.49,71.2 v1(146.48,71.21) 146.48,71.91 147.58,73 JDIMM3.168 ; JCPU1.A23 77.9,41.54 78.32,41.96 v1(78.32,41.99) ; v1(32.36,44.92) 32.36,45.28 32.08,45.55 JIO1.1 29.9,45.55 ; JCPU1.Y6 94.9,60.42 v1(95.4,59.92) 95.9,60.42 JCPU1.Y5 ; JDIMM1.139 144.18,64.3 144.79,64.92 144.79,65.71 145.16,66.08 v1(145.16,66.64) ; JIO1.138 35.2,4.75 v1(34.92,4.47) ; JDIMM1.161 144.64,70.9 v1(144.97,71.23) ; JIO1.79 v1(32.31,22.15) ; JDIMM1.172 133.43,74.2 v1(133.15,74.48) ; JDIMM1.184 133.21,77.8 133.18,77.83 v1(133.21,77.83) ; JCPU1.H2 98.87,48.45 v1(98.4,48.92) ; JCPU1.K26 74.9,50.46 v1(74.4,50.97) 73.91,51.45 JCPU1.L27 ; JCPU1.AP31 69.89,74.45 69.4,74.93 69.4,74.94 v1(69.38,74.97) ; JDIMM1.46 133.61,34 133.11,34.51 v1(133.11,34.82) 133.33,34.6 JDIMM1.48 ; JDIMM3.133 158.61,62.5 v1(159.37,63.26) ; JCPU1.U5 95.9,57.41 v5(96.39,56.93) ; v1(137.86,20.63) 137.86,20.78 136.04,22.6 JDIMM1.8 ; JDIMM3.8 147.23,22.6 v1(146.92,22.91) ; JDIMM3.170 146.27,73.6 v1(145.77,73.1) ; JDIMM3.2 146.82,20.8 v1(146.67,20.94) ; 146.94,79.03 v1(146.89,78.98) ; 146.94,79.03 146.94,78.34 147.48,77.8 JDIMM3.184 ; v1(75.25,40.83) 74.9,41.18 JCPU1.A26 ; v1(100.4,44.94) 100.4,44.92 99.9,45.42 JCPU1.E1 ; JDIMM1.44 132.94,33.4 131.8,34.54 v1(131.8,34.82) ; JCPU1.B17 84.4,42.95 85.11,42.95 85.12,42.96 v1(85.23,42.96) 85.23,42.93 85.71,42.45 JCPU1.B15 ; v1(29.65,31.59) 29.65,31.46 29.96,31.15 JIO1.49 ; v1(145.31,31.39) 145.31,31.34 145.27,31.3 JDIMM1.37 ; v1(146.92,27.71) 147.21,28 JDIMM3.26 ; JDIMM1.189 145.56,79.3 v1(145.57,79.29) 144.98,78.7 JDIMM1.187 ; v1(146.14,76.11) 146.25,76 JDIMM3.178 ; v1(69.38,71.87) 69.43,71.87 69.85,71.45 JCPU1.AL31 ; v1(168.18,96.55) 168.26,96.62 U37.4 ; JCPU1.AF2 98.89,66.45 98.42,66.92 v1(98.4,66.92) ; v5(73.4,68.91) 72.94,68.45 JCPU1.AH28 ; JIO1.74 37.03,23.95 37.35,23.64 v1(37.62,23.64) ; JCPU1.Y8 92.9,60.42 v1(92.4,59.92) 91.9,60.42 JCPU1.Y9 ; JDIMM1.13 144.5,24.1 v1(144.64,23.96) 144.18,23.5 JDIMM1.11 ; v1(34.75,5.49) 34.99,5.49 35.12,5.35 JIO1.136 ; JIO1.19 29.58,40.15 v1(29.27,40.46) ; v1(160.27,71.02) 160.27,71.66 159.23,72.7 JDIMM3.167 ; v1(92.4,53.91) 92.9,54.4 JCPU1.P8 ; v1(204.06,106.67) 204.06,107.25 204.83,108.02 JMXM1.250 ; JCPU1.AN27 v5(73.4,73.95) ; JDIMM3.65 158.49,39.7 158.82,40.03 v1(158.82,41.09) 158.41,41.5 JDIMM3.71
  TOP w0.381: 29.53,10.33 29.95,10.75 JIO1.117 ; 29.53,10.33 29.7,10.15 JIO1.119 ; 29.53,10.33 v1(29.53,10.3) ; v1(21.79,95.01) 21.54,94.76 20.78,94.76 20.56,94.97 UC3.3 ; 113.57,50.78 114.11,50.24 QC5.4 115.74,50.24 116.03,49.96 116.03,49.34 116.42,48.94 QC5.1 ; v1(208.72,133.85) 208.81,133.93 209.14,133.93 209.38,134.17 U16.3 ; Q313.1 17.95,153.54 17.77,153.72 v1(17.77,153.82) ; JIO1.30 34.97,37.15 34.7,37.42 34.7,38.53 35.13,38.95 JIO1.24 ; v1(210.45,159.6) 210.79,159.26 U8.3 ; v1(145.48,39.92) 145.48,39.6 144.98,39.1 JDIMM1.63 ; U39.8 U37.8 v1(170.86,96.45) ; v1(144.69,36.35) 144.69,38.01 144.2,38.5 JDIMM1.61 ; v1(132.04,154.38) 132.04,154.05 132.55,153.55 Q306.4 ; v1(157.15,174.82) U60.3 159.09,174.82 PC17.1 ; JUSH1.18 121.48,28.3 122.01,27.78 122.01,26.33 v1(122.03,26.3) ; v1(83.42,47.92) 82.9,48.44 JCPU1.H18 ; v1(173.04,106.64) 172.81,106.42 U37.18 U39.18 ; U39.1 U37.1 166.31,96.85 166.55,96.61 166.93,96.61 v1(166.96,96.63) U37.2 U39.2 ; U50.3 26.37,14.42 25.83,14.96 v1(25.83,15.74) ; PQ1005.1 163.25,175.16 v1(162.88,175.54) ; v1(78.73,40.44) 78.85,40.31 79.83,40.31 80.9,41.38 JCPU1.A20 ; U59.1 167.82,175.2 v1(167.97,175.35) 167.97,174.82 167.7,174.55 U59.2 ; v1(44.28,125.08) 44.64,125.08 44.91,125.35 Q304.4 ; v1(117.73,143.9) 116.84,144.79 116.84,145.75 U20.7 ; UC2.3 v1(66,87.89) ; v1(33.02,9.22) 33.02,9.27 34.5,10.75 JIO1.118 ; JCPU1.AJ7 94.05,69.6 94.05,70.3 JCPU1.AK7 JCPU1.AL7 ; U39.4 U37.4 ; v1(45.4,141.21) 45.41,141.2 45.46,141.2 45.91,140.75 45.91,140.54 46.42,140.03 C402.2 47.59,140.03 R66.1 ; v1(156.91,156.78) 156.8,156.67 Q312.4 ; v1(70.5,45.97) 70.5,45.91 70.9,45.51 JCPU1.E30 ; U39.25 U37.25 ; v1(191.48,86) 191.52,86.05 U27.3 ; U39.11 U37.11 172.81,97.03 173.06,96.78 v1(173.06,96.72) ; v1(63.07,136.27) 63.07,138.14 64.2,139.27 C1186.2 ; JDIMM1.65 144.47,39.7 v1(144.69,39.92) ; JIO1.112 37.22,12.55 37.48,12.29
  TOP w0.406: U37.25 168.26,106.89 v1(168.07,107.07) ; v1(108.23,147.63) 107.34,148.51 U21.3 ; v1(128.66,154.86) U15.3 ; v1(9.07,104.6) 8.29,104.6 UH3.3 ; v1(142.71,169.08) U10.3 ; v1(105.78,132.03) Q311.4 ; v1(81.74,131.31) 81.52,131.31 81.01,131.81 U3.3
  TOP w0.432: Q29.1 v1(188.29,55.29) ; v1(187.88,56.59) Q29.4 ; v1(105.31,139.9) 105.31,138.82 v4(105.32,138.81) 106.51,137.62 Q110.4 ; R733.2 158.98,154.53 158.14,155.37 Q312.1 ; v1(185.11,62.18) 184.9,61.97 Q300.4 ; Q110.1 108.35,136.18 v4(108.35,134.43) 108.35,133.57 v1(108.42,133.5) ; v1(183.86,60.24) 183.86,60.12 183.6,59.87 Q300.1
  TOP w0.457: v1(36.68,153.2) 36.68,151.54 36.31,151.17 Q322.1 ; Q322.4 34.88,148.97 34.63,149.23 v1(34.63,149.57) ; v1(93.71,88.65) 93.94,88.42 UC1.3 ; Q303.1 130.49,26.67 130.59,26.57 ; v1(136.86,138.9) Q297.4 ; Q297.1 v1(138.16,139.22)
  TOP w0.508: QH2.3 28.69,94.38 28.18,93.87 v1(28.18,93.59) ; v1(114.21,31.46) 114.44,31.23 C52.2 ; v1(8.89,113.22) 9.02,113.35 CH3.2 ; v1(175.19,173.39) 175.08,173.51 R935.2 ; v1(32.26,99.49) 32.05,99.49 31.6,99.95 RH46.2 CH76.2 ; R660.2 v1(171.04,93.89) ; C772.2 45.82,131.29 45.45,130.92 v1(45.22,130.92) ; R561.2 130.86,159.34 C464.2 130.86,157.95 131.04,157.77 v1(131.04,157.57) ; v1(62.32,144.68) 61.36,144.68 60.71,145.33 JLVDS1.41 ; JLVDS1.45 83.63,145.33 v1(83.55,145.42) ; CD10.2 126.64,60.06 v1(127.56,60.97) ; RC45.2 77.77,91.5 CC67.2 77.64,92.21 v1(77.63,92.22) 77.66,92.25 CC66.2 ; v1(194.55,154.81) 194.38,154.81 193.94,155.26 R1971.1 ; v1(126.99,57.62) 126.64,57.28 CD11.2 ; v1(106.59,150.69) 106.93,150.69 107.19,150.94 C365.2 ; v1(31.67,97.65) 31.67,97.07 CH64.2 35.2,95.42 CH65.2 ; C19.2 64.65,170.37 65.15,170.87 v1(65.56,170.87) ; CD59.2 v1(165.37,81.12) ; Q313.4 19.85,151.47 19.63,151.26 v1(19.63,151.18) ; v1(144.48,168.94) C287.2 ; C554.2 176.12,94.29 176.19,94.22 v1(176.19,93.89) ; v1(2.26,155.21) 1.75,155.72 1.75,156.66 2.23,157.13 PR406.2 ; PC1162.1 v1(78.4,63.06) ; JLVDS1.44 80.01,147.28 v1(79.35,146.62) ; v1(21.37,70.64) 20.15,70.64 PR19.2 19.91,69.94 v1(21.41,69.94) ; v1(58.98,52.65) 58.5,52.18 PC1124.1 ; v1(57.01,56.75) PC1145.1 ; C474.2 117.93,139.99 v1(117.42,139.48) ; R1628.2 161.14,158.37 161.2,158.43 v1(161.21,158.43) ; JDEG2.14 208.91,107.33 v1(208.09,106.5) ; R1629.2 C652.2 15.63,151.96 15.34,151.96 v1(15.15,151.77) ; PC1155.2 v1(87.48,56.45) ; C53.2 122.78,33.47 122.26,33.99 v1(122.11,33.99) 122.11,34.97 121.77,35.3 JUSH1.4 ; C735.2 v1(169.01,158.97) ; v1(169.01,158.97) 169.73,158.97 170.03,158.67 R836.2 ; v1(169.01,158.97) 170.16,160.12 C638.1 ; C609.2 v1(9,150.29) ; PC1153.2 v1(87.48,54.29) ; v1(69.12,86.75) 69.12,86.54 68.72,86.14 CC69.2 ; C359.2 113.52,154.46 113.78,154.2 v1(113.78,154.17) ; CD8.2 125.11,51.88 v1(124.89,51.66) ; v1(128.95,60.66) 129.31,61.02 CD16.2 ; v1(133.01,160.9) 133.01,160.22 132.98,160.19 C333.2 ; JSATA1.11 199.34,53.69 198.4,54.64 v1(198.4,55.32) ; v1(119.12,40.12) 119.11,40.11 118.55,40.11 117.45,41.21 CC68.2 ; v1(59.22,160.58) 58.94,160.3 JEDP1.43 ; C249.1 78.8,138.8 77.94,137.94 77.94,136.6 v1(77.99,136.55) 77.54,136.1 C1145.2 C1146.2 ; v5(80.82,82.87) 80.11,83.58 PC1117.2 ; RH141.2 17.12,97.06 CH99.2 17.15,97.41 v1(16.66,97.9) ; C1178.2 116.99,162.24 v1(116.56,162.67) ; v1(7.99,152.36) 8.48,151.87 C622.2 ; v1(183.89,174.8) 184.68,174.02 PC31.2 ; v1(28.4,16.64) 28.66,16.91 C416.2 ; R60.2 197.45,88.09 v1(198.19,88.84) ; C395.2 197.58,61.24 v1(197.64,61.31) 200.41,61.31 JSATA1.17 ; v1(102.32,156.64) 103.13,156.64 C613.2 103.15,157.42 v1(102.36,157.42) ; R812.1 176.95,150.57 v1(177.29,150.57) ; R1128.2 41.25,166.75 41.02,166.98 v1(40.77,166.98) ; RH133.1 RH132.1 RH131.1 22.71,132.75 22.16,133.3 v1(21.61,133.3) ; v1(22.88,133.87) 23.09,133.67 CH18.1 ; v1(177.4,145.35) R869.1 ; v1(47.99,113.22) 47.99,113.18 47.65,112.84 RH112.1 ; v5(82.78,82.87) 82.14,83.5 PC1138.2 ; C624.2 158.09,159.87 v1(157.62,159.39) ; v1(1.29,79.6) 1.89,79.6 PC14.2 2.27,78.81 v1(1.34,78.81) ; v1(93.46,35.33) 93.5,35.37 94.16,35.37 94.38,35.15 RC48.2 ; v1(176.66,146.42) 176.59,146.48 Q47.3 ; C300.2 5.36,137.92 4.72,138.56 3.77,138.56 3.4,138.93 v1(3.4,140.02) ; CD54.2 v1(163.97,49.34) ; C350.2 v1(148.82,162.88) ; C739.2 176.38,139.11 v1(176.64,139.38) 176.92,139.38 177.39,138.9 C738.2 ; C462.2 113.94,161.72 113.43,161.21 v1(113.43,160.82) 113.66,160.59 C463.2 ; JTAG1.2 167.74,158.39 v4(166.01,160.13) 165.56,160.58 164.65,160.58 164.6,160.53 v1(164.5,160.53) ; C668.2 15.95,165.35 15.95,164.24 v1(15.61,163.89) C676.2 ; CD2.2 CD4.2 129.47,58.23 v1(128.97,58.74) ; PC1120.1 v1(78.4,58.74) ; CD52.2 162.86,57.23 v1(163.42,57.79) ; v1(32.05,167.32) 32,167.27 C1335.2 C1333.2 ; v1(172.62,93.98) 172.62,94.01 173.07,94.46 C553.2 ; C4.2 207.59,175.67 v1(207.39,175.87) ; 29.9,45.55 29.44,46.01 29.44,47.94 30.07,48.57 JIO1.141 ; v1(133.42,124.37) 133.81,124.37 134,124.18 PC16.2 133.93,123.75 PQ7.3 ; v1(19.63,73.09) 19.63,73.01 19.18,72.56 PC15.2 ; C477.2 138.1,143.07 v1(138.7,142.47) 138.28,142.05 R1638.2 ; CH20.1 19.06,139.1 v1(19.62,139.66) 19.77,139.81 CH23.1 ; Y3.4 113.3,158.98 112.96,159.31 v1(112.96,160.27) 112.98,160.29 113.69,159.58 C470.2 ; v1(156.46,147.37) 156.46,147.36 156.51,147.31 156.51,146.81 156.97,146.36 C742.2 ; C633.2 160.14,159.63 R732.2 161.09,160.12 161.5,160.53 v1(161.5,160.53) ; v1(43.76,128.62) 43.76,128.62 R1611.2 ; CH19.1 26.74,133.87 26.35,134.26 YH2.4 27.47,135.15 v1(27.53,135.22) ; PC8.2 134.92,117.89 v1(134.9,117.87) ; C612.2 98.73,161.02 v1(98.47,161.28) ; v1(133.93,143.68) C476.2 133.93,144.63 134.16,144.87 C475.2 ; C482.2 v1(288.69,137.48) ; v1(46.96,122.23) 46.94,122.25 46.02,122.25 RH91.2 CH51.2 ; C91.2 212.07,155.13 211.61,155.59 v1(211.38,155.59) ; v1(197.83,44.17) 198.47,43.53 200.41,43.53 JSATA1.7 ; v1(161.07,153.51) 161.07,153.72 160.62,154.18 159.45,154.18 R733.2 ; R889.1 176.66,142.3 177.32,142.96 177.32,143.45 v1(177.51,143.64) ; v1(167.51,54.92) 166.93,54.33 CD53.2 ; PC917.2 180.53,38.38 v1(180.62,38.48) ; JDIMM3.206 163,84.95 162.52,85.43 v1(162.32,85.43) ; RH129.1 12.8,111.32 v1(12.63,111.15) ; R1627.2 27.02,17.24 R514.2 25.79,17.24 v1(25.75,17.21) ; R557.2 v1(117.05,165.16) ; C428.2 C429.2 27.61,27.5 28.15,28.04 29.03,28.04 v1(29.09,28.11) ; PR916.2 v1(180.06,24.45) ; C593.2 C614.2 107.58,140.76 v1(106.88,140.07) ; v1(154.24,88.76) 153.5,89.5 JDIMM1.206 ; PC1139.2 v5(84.17,82.87) ; PC1144.1 58.48,54.47 v1(58.98,54.97) ; Q311.1 107.52,130.73 107.98,131.19 108.04,131.19 108.1,131.25 R727.2 108.6,131.25 109.07,131.71 109.07,132.86 v1(108.42,133.5) ; C18.2 v1(69.92,170.22) ; 22.96,154.21 23.25,154.21 23.98,153.48 C620.2 ; 22.96,154.21 v1(22.96,154.24) ; 22.96,154.21 C621.2 ; C336.2 v1(148.83,160.85) 149.85,159.83 R402.1 ; CH2.2 12.37,114.49 v1(11.89,114.97) ; v1(198.42,56.26) 198.45,56.23 JSATA1.13 ; Q60.3 149.25,153.44 148.06,153.44 v1(147.81,153.68) ; PC1148.1 v1(57.06,65.9) ; v1(35.16,143.89) 35.2,143.85 36.18,143.85 C405.2 36.24,143.79 R491.1 ; v1(185.3,88.32) 184.96,88.66 CE3.2 ; v1(26.03,34.81) 26.03,34.63 25.41,34.01 JODD1.7 ; v1(26.82,70.41) 26.82,70.41 26.45,70.78 PC749.2 26.45,71.56 26.19,71.82 PC743.2 ; Q48.3 v1(146.52,175.22) ; JIO1.142 35.2,1.12 v1(35.91,1.84) ; C728.2 173.33,139.08 172.99,139.42 v1(172.31,139.42) C729.2 ; v1(190.05,163.59) 190.74,164.28 Q50.3 ; v1(64.21,148.64) 64.21,148.31 63.59,147.69 JLVDS1.42 ; v1(207.28,175.08) 207.76,174.6 C1.2 ; C1338.2 28.8,166.84 28.38,167.26 ; JDEG2.10 207.95,113.44 v1(207.58,113.81) 208.21,114.44 JDEG2.11 ; v1(166.35,48.06) 166.69,47.72 CD46.2 ; RD12.1 129.16,88.46 128.87,88.75 128.87,89.4 v1(128.94,89.47) RD13.1 ; RH47.2 18.13,100.06 18.62,99.58 v1(18.62,99.53) ; C701.2 112.62,127.81 112.85,128.04 112.86,128.04 v1(112.94,128.12) ; CE4.2 v1(175.11,96.24) ; PC19.2 162.33,172.61 v1(162.52,172.43) ; v1(89.81,35.4) 89.58,35.4 89.14,34.95 89.14,34.11 89.4,33.86 JSATA2.17 ; C610.2 v1(106.64,164.15) ; JPB1.7 v1(275.19,90.58) ; v1(65.54,135.24) 65.54,135.4 65.21,135.73 64.86,135.73 C1159.2 C1149.2 64.84,138.26 65.78,139.21 C1183.2 66.59,140.18 C1184.2 ; C436.2 34.4,146.66 33.97,146.23 v1(33.78,146.23) ; C15.2 67.66,166.75 67.52,166.61 v1(67.52,166.17) ; v1(118.01,128.16) 118.64,127.52 C703.2 ; CD45.2 CD49.2 161.4,23.91 v1(161.62,24.13) ; v1(99.18,84.78) 99.18,83.62 98.82,83.26 QC1.3 ; PR22.2 18.78,74.13 PR733.1 v1(18.93,73.22) ; RH282.2 9.56,127.86 v1(9.56,127.32) 9.56,126.98 10.22,126.32 QH6.3 ; JKB1.1 80.75,109.93 82.1,108.57 v1(83.35,108.57) ; v1(38.97,11.99) 37.78,11.99 37.48,12.29 ; JBT1.13 v1(303.86,110.4) ; v1(130.31,31.17) 130.05,30.92 130.05,30.6 129.49,30.04 C767.2 ; JEDP1.45 69.64,156.42 v1(69.85,156.21) ; C48.2 v1(167.99,93.92) ; C12.2 v1(53.66,163.4) ; v1(12.66,119.57) 12.65,119.57 12.65,119.57 12.67,119.55 12.7,119.55 12.71,119.56 13.39,119.56 RH151.2 ; v1(2.84,114.88) 2.86,114.88 3.36,114.38 C301.2 ; CD6.2 131.91,13.8 CD1.2 131.1,13.4 130.78,13.08 v1(130.64,13.08) ; CD50.2 v1(163.4,58.99) ; JSATA2.19 91.94,34.37 v1(91.93,34.37) 92.05,34.49 RC72.2 ; R1618.2 129.64,28 130.59,27.05 130.59,26.57 v1(130.61,26.56) ; v1(17.32,133.36) 17.33,133.36 17.33,133.3 17.6,133.03 17.6,132.64 RH342.2 ; v1(25.96,167.16) 26.34,167.16 26.54,166.95 C1340.2 ; JKB1.2 80.75,116.47 81.22,116.94 v1(81.71,116.94) ; CD63.2 v1(163.54,61.79) ; C623.2 32.36,153.61 v1(31.9,154.06) 31.34,153.51 C435.2 ; CD66.2 v1(163.91,77.86) ; C406.2 195.68,61.46 194.89,62.24 C394.2 194.16,63.16 v1(194.42,63.42) ; C1177.2 v1(113.43,167.02) ; v1(106.63,162.7) 106.96,162.37 C594.2 ; v1(14.54,161.67) 14.54,161.65 14.04,162.15 C675.2 ; JKB1.5 82.75,110.51 83.18,110.07 83.41,110.07 83.94,109.54 83.94,109.32 83.95,109.31 v1(83.95,109.14) ; v1(21.23,156.02) 21.23,156.92 v4(21.18,156.97) R783.2 ; v1(123.14,139.95) 123.14,139.77 123.09,139.72 123.09,139.53 C473.2 ; RH31.1 15.59,132.68 15.08,133.19 15.08,133.33 v1(15.05,133.35) ; C472.2 129.07,140.56 v1(129.04,140.59) ; C1182.2 58.89,150.66 59.41,150.14 v1(59.41,150.01) ; PC1122.1 v1(57.02,63.61) ; JDEG2.12 v1(211.91,115.45) ; v1(194.49,168.97) 195.17,169.66 C355.2 ; v1(96.09,159.09) 95.92,159.09 94.94,160.07 C481.2 ; v1(176.2,19.86) 176.72,20.38 PC1004.2 ; C478.2 133.93,156.07 134.47,155.52 v1(134.47,155.08) 134.36,155.18 133.86,155.18 Q306.1 ; v1(42.3,163.51) 42.23,163.58 C93.2 ; 46.11,49.68 PC714.2 ; C726.2 175.36,139.08 175.02,139.42 v1(174.26,139.42) 174.34,139.33 C731.2 ; C298.2 76.97,138.85 76.55,138.43 v1(75.72,138.43) 75.72,138.79 75.96,139.03 C243.2 ; v1(160.63,81.71) 161.22,81.12 CD62.2 ; v1(122.9,26.81) 122.78,26.92 C56.2 ; v1(45.24,103.96) 45.33,104.06 C787.2 ; v1(211.94,107.15) 211.91,107.17 JDEG2.13 ; PR1018.2 v1(178.38,80.57) ; v1(41.4,152.83) 40.34,152.83 C410.2 39.72,152.94 39.66,153 R73.1 ; CD61.2 CD60.2 163.68,80.68 v1(163.37,80.38) 163.07,80.07 RD28.1 ; v1(167.8,45.02) 167.75,45.07 166.98,45.07 CD57.2 ; RC19.2 83.92,34.43 84.32,34.04 JSATA2.13 84.32,30.09 v1(84.31,30.09) ; PC1150.2 v1(87.48,52.13) ; CD19.2 CD18.2 128.66,85.41 128.04,86.03 128.04,87.44 128.29,87.69 v1(128.29,87.71) ; C415.2 88.21,36.12 88.21,37.08 v1(88.26,37.14) 88.19,37.21 87.76,37.21 87.22,36.68 C409.2 ; R1625.2 C644.2 v1(104.47,133.67) ; v1(9.12,110.34) 9.13,110.34 9.17,110.3 RH39.2 ; v1(194.18,157.4) 193.94,157.16 R1970.1 ; JBT1.14 290.62,108.94 291,108.94 291.58,109.51 v1(291.58,109.89) ; C332.2 209.6,90.83 209.79,91.02 v1(209.79,91.44) 209.73,91.5 C8.2 ; v1(3.63,149.2) 3.39,148.96 PC408.2 ; CD15.2 CD16.2 ; CD16.2 CD5.2 ; PC3.2 191.44,7.63 v1(192,8.19) ; CD64.2 v1(163.49,60.52) ; R883.1 26.16,9.5 v1(25.69,9.03) 26.27,8.45 C763.2 ; v1(44.12,136.03) 44.12,135.9 44.35,135.67 R931.2 ; C467.2 v1(124.81,167.86) ; RH183.2 v1(22.71,137.53) ; C765.2 125.54,33.33 v1(126.03,32.83) ; v1(64.84,160.74) 65.29,160.3 JEDP1.44 ; PR403.1 v1(8.36,157.13) ; JDIMM3.205 165.19,20.83 v1(165.86,21.5) ; JKB1.6 82.75,116.03 83.65,116.94 v1(83.93,116.94) ; PC722.2 34.26,78.96 v1(34.43,79.12) ; CD65.2 v1(160.85,78.08) ; v1(28.29,9.11) 27.91,9.5 C720.2 ; R61.1 40.21,140.17 v1(40.32,140.06) ; v1(289.96,94.02) 289.74,93.79 D17.1 ; C90.2 211.81,134.34 v1(211.63,134.52) ; v1(25.79,38.58) 25.79,38.6 25.02,37.82 JODD1.4 ; v1(34.96,167.31) 34.96,167.06 34.53,166.63 C1334.2 ; v1(293.56,107.85) JBT1.10 ; D73.1 v1(8.63,164.68) ; C550.2 172.06,109.54 172.31,109.79 173.04,109.79 v1(173.07,109.83) C552.2 ; v1(50.68,151.27) 51.09,151.68 51.09,152.25 50.77,152.57 R336.1 ; v1(167.45,139.47) 167.74,139.18 C747.2 ; v1(7.62,101.51) 7.43,101.7 CH102.2 ; PR714.1 18.9,80.04 PC740.1 ; C617.2 29.54,156.1 v1(30.14,155.5) 29.69,155.05 C618.2 ; C611.2 106.89,152.97 106.56,153.3 v1(106.56,153.99) ; RC71.2 57.54,69.63 57.9,69.27 v1(58.96,69.27) ; v1(98,35.18) 97.97,35.15 RC87.1 RC47.2 ; JSATA2.7 71.62,30.72 71.97,30.36 72.94,30.36 v1(73.14,30.56) ; CH58.2 47,118.12 47.52,118.64 48.04,118.64 v1(48.12,118.72) ; v1(172.02,159.08) 172.02,158.8 172.06,158.76 R914.2 ; v1(128.9,87.44) CD17.2 CD20.2 ; C328.2 192.17,163.11 192.67,162.62 C7.2 v1(192.67,161.71) ; YH2.2 24.15,137.18 23.82,137.5 v1(23.82,137.74) ; R278.2 192.89,169.69 v1(192.39,170.18) ; PC1009.2 v1(184.02,71.95) ; PC911.2 v1(184,32.07) ; JDOCK1.153 79.86,126.62 80.62,127.39 C248.2 ; RC23.2 116.15,44.3 116.02,44.43 114.6,44.43 v1(114.52,44.35) ; v1(2.61,139.23) 2.26,138.88 C299.2 ; v1(132.27,159.18) 132.27,158.9 132.61,158.56 R406.2 ; D11.1 v1(49.88,165) ; R492.1 C1174.2 112.37,142.14 v1(112.01,141.78) ; R1630.2 186.63,57.18 186.41,56.96 v1(186.41,56.58) ; v1(33.73,98.58) 33.88,98.73 CH80.2 ; v1(32.46,85.66) 32.73,85.93 PC763.2 ; PR408.1 PC407.2 5.43,157.33 6.35,158.24 6.97,158.24 v4(7.31,158.59) 7.92,159.2 v1(7.92,159.23) ; v1(18.22,76.81) 18.25,76.84 18.74,76.84 PC732.2 ; C1339.2 27.73,166.63 28.36,167.26 28.38,167.26 ; v1(47.13,154.38) 46.66,153.91 C766.2 ; JUSH1.24 122.03,26.3 v1(122.03,26.3) ; PC1164.1 78.66,52.52 v1(78.4,52.26) ; PC1156.2 v1(87.48,58.48) ; v1(47.19,127.15) 47.09,127.25 Q304.1 ; RD29.1 v1(163.51,77.03) ; Q45.3 155.18,146.88 v1(154.18,145.87) ; U52.4 56.91,109.67 v1(57.49,109.08) ; CD47.2 v1(163.4,47.05) ; CC65.2 98.13,85.63 v1(98.25,85.51) ; CH94.2 v1(37.69,136.47) ; v1(45.95,160.72) 45.34,160.11 JEDP1.41 ; v1(62.7,142.14) 62.36,141.8 62.36,140.34 62.89,139.8 C1185.2 ; C756.2 87.21,107.75 87.04,107.92 v1(87.04,107.93) 87.01,107.89 85.6,107.89 C758.2 ; CD55.2 v1(167.79,56.96) ; PC1147.1 v1(57.02,61.33) ; JSATA1.4 202.24,39.72 v1(202.93,40.41) ; v1(59.04,50.38) 58.9,50.38 58.29,49.77 PC1170.1 ; PC11.2 14.3,59.26 13.32,58.28 12.13,58.28 v1(11.94,58.47) ; PD3.1 v1(200,9.72) ; v1(128.06,105.01) 128.41,104.66 C392.2 ; v1(74.37,138.39) 73.86,138.39 73.51,138.75 C1188.2 ; v1(80.38,37.15) 80.38,37.08 79.86,36.56 C408.2 C407.2 ; R2187.1 v1(151.92,174.13) ; R739.2 v1(20.17,154.24) ; v1(156.56,151.82) 157.12,151.82 C734.2 ; C466.2 v1(121.77,167.89) ; JSATA2.4 67.81,33.57 68.13,33.9 v1(68.13,34.89) ; v1(126.13,82.36) CD21.2 126.86,82.34 CD22.2 ; C741.2 164.95,155.66 164.68,155.93 v1(164.68,156.67) ; Q52.3 v1(180.07,150.8) ; v5(78.46,82.87) 78.08,83.25 PC1119.2 ; JBT1.1 v1(302.56,104.75) ; 28.38,167.26 v1(28.4,167.26) ; R1617.2 139.29,153.26 C348.2 140.42,152.89 v1(140.42,152.53) 140.6,152.53 141.07,153 C341.2 ; C651.2 v1(158.24,157.76) ; v1(47.46,109.4) 47.46,109.84 47.06,110.24 C761.2 ; R1137.2 83.4,132.04 v1(83.92,131.52) ; PC1146.1 v1(57.02,59.04) ; v1(47.53,100.23) 47.45,100.14 C764.2 ; C1337.2 C1336.2 30.87,167.09 v1(30.61,167.36) ; v1(139.93,151.19) 139.67,150.94 C770.2 ; CD3.2 129.67,51.43 130.03,51.07 v1(130.69,51.07) 130.21,50.59 130.21,49.48 130.17,49.44 130.16,49.44 129.44,48.73 CD7.2 ; C733.2 154.57,152.02 v1(154.8,151.79) ; CH101.2 12,127.28 v1(12.59,127.88) ; v1(130.05,43.92) 129.44,44.54 CD9.2 ; PC1163.1 v1(78.4,65.22) ; v1(116.98,72.75) 116.53,72.75 116.06,73.22 RC81.2 ; Q88.3 v1(45.68,168.37) ; C45.2 v1(166.98,93.89) ; CH21.1 v1(24.1,139.79) ; v1(152.69,171.3) 152.71,171.32 R2186.1 ; PC1104.2 58.56,47.74 v1(59.02,48.2) ; v1(46.71,160.81) 47.22,160.3 JEDP1.42 ; R801.1 v1(288.95,142.81) ; JSATA1.1 v1(202.84,35.91) ; CC71.2 119.24,52.2 119.24,51.58 RC79.2 120.39,51.37 120.5,51.47 v1(120.51,51.47) ; v1(63.71,30.04) 64,30.32 JSATA2.1 ; U53.4 56.92,103.32 57.4,102.83 v1(57.4,102.34) ; C14.2 67.89,169.66 68.37,170.14 v1(68.38,170.14) ; C483.2 95.93,160.07 v1(96.19,159.82) ; JPB1.8 283.82,88.45 v1(284.25,88.02) ; PR18.2 1.87,77.53 v1(1.34,78.05) ; v1(24.37,99.25) 24.36,99.26 24.36,100.05 RH274.2 ; v1(131.52,151.21) 131.52,151.17 131.75,150.94 R919.2 131.98,150.7 C768.2 ; R1138.2 83.4,134.57 v1(83.6,134.77) ; v1(25.55,41) 24.92,41.63 JODD1.1 ; R734.2 v1(16.83,154.34) ; v1(202.04,83.85) 200.04,85.85 C94.2 ; R843.1 179.65,148.31 180.39,147.56 v1(180.39,147.1) ; C327.2 v1(148.83,161.86) ; v1(186.54,62.08) C393.2 ; CD51.2 v1(163.99,45.02) ; R659.2 164.95,93.36 v1(165.15,93.16) ; v1(150.89,17.93) 150.29,17.34 JDIMM1.205 ; v1(12.79,138.79) 13.33,138.24 D87.1 ; RC86.2 59.68,74.52 60.3,73.9 v1(60.79,73.9) ; CD48.2 v1(162.63,52.38) ; PC1149.2 v1(87.48,60.52) ; v1(168.04,109) C551.2 ; v1(41.45,136.44) 40.99,135.98 CH95.2 ; C773.2 v1(48.54,128.62) ; JPB1.5 280.49,89.96 280.85,89.6 v1(281.49,89.6) JPB1.6 ; C21.2 49.9,163.18 v1(49.85,163.12) ; R882.1 v1(166.72,136.87) 166.56,137.03 165.92,137.03 165.71,137.25 R880.1 ; v1(12.66,134.48) 13.02,134.48 13.33,134.16 D13.1 ; v1(145.13,167.09) C343.2 ; JSATA1.19 199.5,63.85 199.22,64.12 v1(198.88,64.12) ; v1(98.28,34.52) 98.3,34.52 98.93,35.15 RC88.1 ; PC4.2 v1(191.84,9.81) ; D10.1 v1(54.88,166.15) ; JLVDS1.43 73.99,147.28 v1(74.29,146.98) ; v1(35.05,166.08) 35.24,165.89 C337.2 ; v1(47.51,113.7) 47.27,113.94 46.39,113.94 CH40.2 ; PR1028.2 v1(183.68,74.99) ; C737.2 177.07,153.99 v1(177.35,153.71) ; CD56.2 v1(167.8,49.34) ; R504.2 191.65,55.88 v1(191.97,55.55) ; PC1169.1 v1(78.4,56.58) ; PC907.2 v1(184.25,33.85) ; Q36.3 193.54,164.99 193.85,164.67 194.52,164.67 v1(194.61,164.58) ; C313.2 v1(289.44,140.91) ; C730.2 178.66,139.22 178.9,139.46 v1(179.55,139.46) ; CD13.2 v1(124.81,48.32) ; R505.2 v1(184.76,55.55) ; v1(21.79,95.01) 21.79,95.31 21.69,95.42 RH271.2 ; Q65.3 v1(128.62,32.18) ; CH1.2 v1(64.49,113.69) ; v1(26.06,98.68) 26.07,98.69 26.32,98.69 26.81,99.18 26.81,99.38 26.87,99.44 26.87,99.63 27.28,100.04 CH54.2 ; C13.2 v1(54.74,163.4) ; Q303.4 128.48,25.6 v1(128.52,25.64) ; PC1161.1 v1(78.4,60.9) ; PC1008.2 v1(184.12,70.68) ; PC1165.1 v1(78.4,54.42) ; v1(104.68,136.1) Q73.3 ; C1167.2 78.29,162.44 77.77,162.95 v1(77.77,162.97) ; C469.2 v1(122.25,154.78) ; C743.1 162.4,155.98 v1(161.92,155.98) ; PC5.2 v1(210.41,9.46) ; PC30.2 183.98,172 v1(183.54,172.44) ; PD2.1 v1(194.92,9.84) ; JSATA2.11 v1(81.78,29.74) ; v1(140.96,166.15) R392.2 ; PC703.2 24.23,87.73 24.23,87.83 24.15,87.91 v1(24.15,88.27) ; C338.2 v1(36.61,164.1) ; PC1116.2 v1(86.21,82.87)
  TOP w0.762: 37.5,85.13 35.94,85.13 35.8,84.99 PC767.2 ; PC744.2 35.83,67.16 35.94,67.27 37.01,67.27 37.53,66.75 ; 37.65,78.5 37.22,78.93 35.56,78.93 35.05,78.42 PC728.2 ; PC745.2 37.65,61.25 ; 37.45,73.1 35.86,73.1 35.76,73 PC727.2
  BOTTOM w0.102: v1(123.65,100.36) v4(123.65,101) ; v1(133.01,160.9) 133.01,160.91 v4(133.45,161.35) ; v1(196.39,135.27) v4(195.6,135.27) ; v1(134.9,117.87) 134.92,117.87 v4(135.48,118.43) ; v1(138.16,139.22) v4(138.16,138.51) ; v1(147.81,153.68) v4(147.81,152.98) ; v1(122.25,154.78) v4(122.25,154.14)
  BOTTOM w0.127: v4(173.07,94.44) v1(172.62,93.98)
  BOTTOM w0.203: v1(64.67,151.5) 64.77,151.6 64.77,151.98 64.56,152.19 U19.10 ; v1(59.41,150.01) 59.77,150.37 U19.20 ; v1(58.46,157.42) 58.37,157.33 58.37,155.94 58.52,155.79 U19.30
  BOTTOM w0.254: JDOCK1.107 110.24,119.72 109.84,120.12 v1(109.84,120.4) ; v1(289.15,111.32) D14.3 D14.8 ; JDOCK1.119 113.24,120.06 v1(112.93,120.37) ; v1(286.53,78.89) U22.24 ; JDOCK1.47 93.24,117.46 92.94,117.16 v1(92.09,117.16) 92.09,117.45 92.24,117.6 JDOCK1.43 ; JDOCK1.125 114.74,119.75 114.24,120.25 ; v1(108.82,125.35) 108.74,125.43 JDOCK1.102 ; v1(279.37,72.54) U22.3 ; U625.10 v1(271.79,74.24) ; JDOCK1.70 99.74,125.21 99.97,124.98 v1(99.97,124.77) ; JDOCK1.20 86.24,125.59 85.88,125.22 84.85,125.22 v1(84.74,125.33) ; v1(102.86,120.46) 103.77,120.46 104.24,119.99 JDOCK1.87 ; JDOCK1.75 101.24,119.86 102.14,120.76 v1(102.14,121.97) ; JDOCK1.44 92.24,127.54 92.72,128.02 v1(93.2,128.02) ; U22.18 283.53,76.95 v1(283.11,76.53) ; 114.24,120.25 JDOCK1.123 ; 114.24,120.25 v1(114.13,120.36) ; JDOCK1.61 v1(97.74,121.74) 98.24,121.24 JDOCK1.63 ; JDOCK1.126 v1(114.74,125.4) ; v1(259.52,74.04) 259.33,74.24 U626.10 ; v1(111.82,120.42) 111.74,120.34 JDOCK1.113 ; v1(116.75,120.96) 116.67,120.96 116.32,120.6 116.32,120.02 116.24,119.94 JDOCK1.131 ; v1(116.01,125.17) 116.01,125.6 116.24,125.83 JDOCK1.132 ; v1(288.26,74.04) U22.31 ; JDOCK1.76 101.24,124.88 ; 101.24,124.88 101.26,124.89 102.42,124.89 102.74,125.21 JDOCK1.82 ; 101.24,124.88 v1(101.13,124.77) ; JDOCK1.37 90.74,120.04 90.91,120.21 v1(90.91,120.68) 89.82,120.68 89.49,120.35 89.49,120.32 89.24,120.07 JDOCK1.31 ; v1(96.51,124.79) 96.74,125.02 JDOCK1.58 ; JDOCK1.1 v1(81.74,120) ; v1(111.35,125.35) 111.74,125.74 JDOCK1.114 ; JDOCK1.57 96.74,121.38 v1(96.43,121.69) 96.24,121.5 JDOCK1.55 ; v1(108.62,120.33) 108.74,120.21 JDOCK1.101 ; v1(90.27,125.36) 90.74,125.83 JDOCK1.38 ; JDOCK1.25 87.74,119.8 87.48,120.07 86.45,120.07 86.23,119.85 86.23,118.71 JDOCK1.19 86.24,117.7 86.38,117.55 v1(86.38,117.43) ; JDOCK1.91 105.24,119.73 v1(105.5,119.99) 105.74,119.75 JDOCK1.93 ; JDOCK1.108 v1(110.24,125.4) ; JDOCK1.69 v1(99.74,121.75) ; v1(83.67,120.63) 84.74,119.55 JDOCK1.13 ; JDOCK1.32 89.24,125.59 88.99,125.34 88.09,125.34 87.74,125.68 JDOCK1.26 87.74,127.96 87.73,127.97 v1(87.73,128.11) ; JDOCK1.120 113.24,127.69 113.14,127.79 113.14,127.91 v1(112.94,128.12) ; JDOCK1.138 117.74,127.89 v1(118.01,128.16) ; U625.21 v1(265.95,74.24) ; U26.3 211.68,87.95 v1(211.87,88.14) ; JDOCK1.137 v1(117.74,120.33) ; v1(98.03,124.66) 98.24,124.87 JDOCK1.64 ; v1(93.22,121.78) 93.22,121.37 93.74,120.85 JDOCK1.49 ; v1(95.48,121.56) 95.48,120.74 95.24,120.5 JDOCK1.51 ; JDOCK1.7 v1(83.24,120.08) ; U26.13 v1(211.68,81.93)
  BOTTOM w0.279: JDOCK1.14 v1(84.74,125.33) ; U626.21 v1(253.43,74.24) ; U45.1 290.95,57.89 v1(290.17,57.12) ; JDOCK1.81 102.74,117.59 v1(102.92,117.41) ; v1(83.44,124.99) 83.41,124.99 83.24,125.16 JDOCK1.8
  BOTTOM w0.305: v1(77.63,92.22) 77.65,92.2 JXDP1.19 ; JXDP1.6 71.15,92.08 v1(71.02,92.22) 70.86,92.37 69.96,92.37 69.65,92.06 JXDP1.3 ; v1(72.79,92.24) 72.79,92.2 72.65,92.06 JXDP1.9 ; U17.3 205.6,152.45 207.1,153.95 v1(207.1,154.17) ; v1(79.93,92.27) 79.96,92.24 80.44,92.24 80.65,92.03 JXDP1.25
  BOTTOM w0.33: v1(232.96,72.7) U46.B27
  BOTTOM w0.356: JDIMM2.65 133.95,39.7 133.49,40.16 132.97,40.16 v1(132.88,40.07) 132.88,39.65 133.43,39.1 JDIMM2.63 ; JDIMM2.20 144.15,26.2 v1(144.54,25.81) 144.54,24.81 144.13,24.4 JDIMM2.14 ; JDIMM4.54 158.26,36.4 158.8,36.94 v1(158.8,37.51) ; JDIMM2.195 133.38,81.1 v1(133.31,81.17) ; JDIMM4.153 150.29,68.5 150.89,69.1 ; PU903.3 244.03,19.46 v1(244.02,19.44) ; v1(146.92,36.71) 146.93,36.7 JDIMM4.55 ; v1(132.58,63.89) 132.58,63.91 132.56,63.91 132.56,63.32 133.37,62.5 JDIMM2.133 ; v1(146.38,64.12) 148,62.5 JDIMM4.133 ; JSPI1.16 48.59,111.76 47.89,112.46 47.89,113.12 v1(47.99,113.22) ; PQ205.4 238.7,42.25 238.47,42.48 v1(238.11,42.48) ; PQ106.1 270.75,63.3 270.99,63.06 272.01,63.06 v1(272.64,62.42) ; 144.89,63.4 145.08,63.59 145.08,64.07 ; 144.89,63.4 144.29,62.8 JDIMM2.134 ; 144.89,63.4 JDIMM2.136 ; v1(133.31,72.7) 133.31,72.7 ; 133.31,72.7 JDIMM2.167 ; 133.31,72.7 133.32,72.69 133.32,71.44 133.86,70.9 JDIMM2.161 ; v1(240,38.68) PQ205.1 ; v1(145.16,66.64) 145.11,66.59 145.11,66.1 144.8,65.8 JDIMM2.144 ; JDIMM4.25 146.93,27.7 v1(146.92,27.71) ; JDIMM2.150 145.15,67.6 145.82,66.93 v1(145.82,66.69) ; JDIMM2.8 144.38,22.6 144.68,22.9 144.68,23.92 v1(144.64,23.96) ; JDIMM2.37 133.4,31.3 v1(133.31,31.21) ; v1(151.47,77.86) 151.47,78.18 150.95,78.7 JDIMM4.187 ; v1(158.82,33.71) 158.82,32.09 158.33,31.6 JDIMM4.38 ; v1(158.82,33.71) 158.5,33.4 JDIMM4.44 ; v1(158.82,33.71) 158.82,33.77 158.59,34 JDIMM4.46 ; JDIMM2.153 136.23,68.5 136.63,68.9 136.63,69.15 136.88,69.41 137.64,69.41 137.9,69.15 137.9,68.8 v1(137.91,68.79) ; JDIMM4.13 147.26,24.1 v1(146.92,24.44) ; v1(151.79,67.62) 151.79,67.85 151.38,68.26 150.91,68.26 150.55,67.9 JDIMM4.151 ; JDIMM2.46 144.46,34 145.29,33.17 v1(145.29,33.11) 145,33.4 JDIMM2.44 ; JDIMM4.150 159,67.6 v1(159.24,67.84) 159.24,69.17 159.01,69.4 JDIMM4.156 ; PQ908.1 240.31,17.5 v1(239.94,17.13) ; PQ106.4 269.45,66.12 269.19,66.38 v1(268.37,66.38) ; JDIMM4.65 146.47,39.7 ; 146.47,39.7 v1(146.26,39.91) ; 146.47,39.7 147.07,39.1 JDIMM4.63 ; JDIMM4.173 147.17,74.5 v1(145.77,73.1) 146.17,72.7 JDIMM4.167 ; JDIMM2.72 144.2,41.8 144.62,41.38 v1(144.62,41.37) ; v1(132.69,61.5) 133.49,60.7 JDIMM2.127 ; v1(146.45,60.8) 146.55,60.7 JDIMM4.127 ; JDIMM2.155 135.81,69.1 136.96,70.25 v1(137.21,70.25) ; JDIMM2.26 144.17,28 144.61,27.56 144.61,26.67 v1(145.32,25.96) 145.32,28.32 145.03,28.6 JDIMM2.28 ; JDIMM2.156 144.35,69.4 144.97,70.02 v1(144.97,71.23) 144.94,71.2 JDIMM2.162 ; JDIMM4.128 158.56,61 v1(159.1,61.54) ; JDIMM2.2 144.79,20.8 v1(144.89,20.89) ; v1(146.67,20.94) 146.83,21.1 JDIMM4.3 ; 150.89,69.1 JDIMM4.155 ; 150.89,69.1 151.26,69.1 v1(151.48,69.32) ; JDIMM2.145 132.78,66.1 132.67,66.22 v1(132.66,66.22) ; JDIMM2.9 137.6,22.9 v1(137.86,22.64) ; v1(146.92,33.11) 146.93,33.1 JDIMM4.43 ; JDIMM4.134 158.91,62.8 v1(159.37,63.26) 159.23,63.4 JDIMM4.136 ; PQ204.1 239.91,46.59 PC214.2 ; JDIMM4.20 158.35,26.2 v1(158.74,25.81) 158.74,24.81 158.33,24.4 JDIMM4.14 ; JDIMM2.19 132.82,25.9 132.56,26.17 v1(132.56,27.92) ; 159.38,27.62 159.52,27.76 159.52,28.3 159.22,28.6 JDIMM4.28 ; 159.38,27.62 159,28 JDIMM4.26 ; 159.38,27.62 v1(159.38,27.62) ; 133.39,24.42 133.7,24.1 JDIMM2.13 ; 133.39,24.42 v1(133.37,24.43) ; 133.39,24.42 133.39,23.69 133.57,23.5 JDIMM2.11 ; JDIMM2.25 133.51,27.7 133.26,27.95 v1(133.26,27.92) ; JDIMM4.71 146.37,41.5 v1(146.25,41.38) ; JDIMM2.31 133.88,29.5 132.66,30.71 v1(132.66,31.21) ; v1(146.19,27.73) 146.15,27.69 146.15,26.89 147.14,25.9 JDIMM4.19 ; JDIMM4.139 147.91,64.3 146.55,65.65 v1(146.55,66.61) ; JDIMM2.38 145.11,31.6 v1(145.31,31.39) ; JDIMM4.178 158.87,76 159.33,76.47 v1(159.33,76.84) ; JDIMM2.179 133.47,76.3 132.46,75.29 132.46,74.65 v1(132.5,74.61) ; JDIMM4.189 147.2,79.3 v1(146.89,78.98) ; JDIMM2.54 144.65,36.4 v1(144.69,36.35) 144.69,34.87 144.42,34.6 JDIMM2.48 ; JDIMM2.138 145.01,64 145.08,64.07 ; JDIMM2.49 133.18,34.9 v1(133.11,34.82) ; v1(131.53,40.06) 131.53,39.82 132.85,38.5 JDIMM2.61 ; JDIMM4.144 158.53,65.8 159.26,65.07 v1(159.26,64.3) 158.96,64 JDIMM4.138 ; JDIMM2.184 145.14,77.8 145.57,78.23 v1(145.57,79.29) 145.26,79.6 JDIMM2.190 ; JDIMM2.172 144.57,74.2 145.1,73.67 v1(145.1,73.18) ; JDIMM2.60 144.57,38.2 144.69,38.33 v1(144.69,39.92) 144.61,40 143.09,40 JDIMM2.66 ; v1(132.43,34.85) 132.43,35.17 133.97,36.7 JDIMM2.55 ; v1(144.86,76.1) 144.76,76 JDIMM2.178 ; v1(160.27,71.02) 160.27,71.73 159.01,73 JDIMM4.168 ; JDIMM4.179 146.33,76.3 v1(146.14,76.11) 146.14,77.19 147.05,78.1 JDIMM4.185 ; JDIMM4.162 159.3,71.2 v1(159.44,71.07) ; v1(104.81,129.37) 104.78,129.37 104.24,128.83 JDOCK1.88 ; v1(146.92,29.51) 146.93,29.5 JDIMM4.31 ; JDIMM4.196 158.49,81.4 158.93,80.95 v1(158.93,79.96) 158.57,79.6 JDIMM4.190 ; v1(158.83,21.05) 158.83,20.96 158.66,20.8 JDIMM4.2 ; JDIMM2.139 133.67,64.3 v1(133.26,63.89) ; JDIMM4.145 147.67,66.1 v1(147.51,66.26) ; JDIMM2.196 144.3,81.4 v1(144.83,80.87) ; JDIMM4.11 147.51,23.5 v1(146.92,22.91) 146.93,22.9 JDIMM4.9 ; JDIMM2.168 144.28,73 v1(144.46,73.18) 144.05,73.6 JDIMM2.170 ; v1(145.95,31.36) 145.95,31.15 144.6,29.8 JDIMM2.32 ; v1(158.92,29.66) 158.78,29.8 JDIMM4.32 ; v1(131.8,34.82) 131.8,34.54 133.24,33.1 JDIMM2.43 ; Q294.4 195.82,77.43 195.59,77.2 v1(195.57,77.2) ; JDIMM4.61 146.35,38.5 145.49,39.36 145.49,39.91 v1(145.48,39.92) ; v1(159.14,78.51) 159.14,78.04 158.9,77.8 JDIMM4.184 ; JDIMM4.195 148.01,81.1 v1(146.2,79.29) ; v1(159.57,75.58) 159.56,75.57 159.57,75.57 159.57,74.37 159.41,74.2 ; v1(137.66,79.01) 137.64,79.02 137.64,79.44 137.39,79.69 136.63,79.69 136.37,79.44 136.37,79.19 135.89,78.7 JDIMM2.187 ; JDIMM4.37 146.93,31.3 v1(146.92,31.31) ; JDIMM4.161 146.79,70.9 v1(146.48,71.21) ; JDIMM2.3 v1(133.31,21.1) ; v1(133.15,74.48) 133.17,74.5 JDIMM2.173 ; JDIMM4.49 146.95,34.9 146.18,34.13 v1(146.18,33.05) ; JDIMM4.170 159.26,73.6 159.41,73.74 159.41,74.2 ; v1(237.96,50.74) 238.47,50.74 238.61,50.59 PQ204.4 ; JDIMM4.60 158.8,38.2 159.03,38.43 159.03,39.12 v1(159.03,39.13) ; JDIMM2.128 144.4,61 v1(144.5,60.9) ; 145.08,64.07 v1(145.21,64.2) ; JDIMM2.151 133.02,67.9 132.72,68.2 132.72,72.61 v1(132.61,72.72) ; JDIMM4.8 158.65,22.6 158.9,22.85 158.9,23.9 v1(158.84,23.96) ; JDIMM2.185 133.48,78.1 v1(133.21,77.83) 133.2,77.85 133.2,78.68 133.82,79.3 JDIMM2.189 ; JDIMM4.48 v1(158.8,34.6) ; JDIMM4.72 158.2,41.8 158.6,41.4 158.6,41.31 v1(158.82,41.09) 158.82,41.08 158.82,40.4 158.43,40 JDIMM4.66 ; 159.41,74.2 JDIMM4.172 ; JDIMM2.71 133.38,41.5 132.23,40.35 v1(132.23,40.06)
  BOTTOM w0.381: v1(17.32,133.36) 17.34,133.36 17.48,133.22 18.14,133.22 18.32,133.03 18.32,132.94 RH333.2 ; v1(1.34,78.05) 1.32,78.05 1.32,77.98 1.8,77.5 2.73,77.5 3.4,76.82 PU1.2 ; U25.3 212.1,108.08 212.55,107.63 R758.2 ; v1(42.4,95.01) 42.39,95.01 41.97,95.43 UC4.3 ; Q22.3 73.04,139.18 70.36,139.18 70.09,139.45 v1(70.01,139.45) ; Q310.1 177.04,108.63 177.3,108.37 v1(177.3,108.26) ; v1(176.82,111.82) 177.27,111.82 v4(177.77,111.32) 178.6,110.49 Q310.4 ; C310.2 1.85,125.32 1.24,125.92 1.24,127.7 1.49,127.95 1.53,127.95 C311.2 ; Q339.1 292.09,63.69 292.17,63.78 v1(292.31,63.78) ; v1(209.46,106.82) 209.9,106.38 U14.3 ; v1(244.02,19.44) 243.37,18.8 PQ908.4 ; U7.3 181.06,146.68 180.86,146.48 180.47,146.48 v1(180.14,146.15)
  BOTTOM w0.406: v1(194.21,80.44) 194.29,80.44 194.52,80.21 Q294.1 ; v1(245.51,62.73) 246.08,62.16 U58.3 ; v1(245.59,69.29) U47.3
  BOTTOM w0.457: Q13.1 71.87,154.06 72.55,153.38 v1(73.54,153.38) ; v1(70.18,150.46) 69.92,150.46 69.76,150.29 Q19.1 ; Q336.1 48.87,151.09 C1332.2 ; v1(25.75,17.21) 25.75,17.62 26.37,18.24 Q301.1 ; v1(178.42,142.07) 178.42,141.79 178.11,141.48 U4.2
  BOTTOM w0.483: R63.1 49.09,143.19 49.57,143.66 50.84,143.66 51.12,143.94 v1(51.13,143.94)
  BOTTOM w0.508: R908.2 7.52,127.05 C760.2 6.65,128.08 v1(5.99,128.74) ; v1(182.12,87.3) 182.46,87.3 182.79,86.97 C607.1 ; v1(10.22,116.46) 10.22,117.21 CH63.2 ; v1(72.1,151.98) 72.08,151.98 71.69,151.59 Q19.4 ; v1(71.42,161.38) 71.94,161.9 C255.2 ; CH35.2 CH34.2 23.88,127.98 24.66,127.2 v1(24.66,126.97) ; v1(45.24,103.96) 45.67,103.53 JSPI1.17 ; C1332.2 49.03,150.61 v1(48.69,150.28) ; C601.2 196.72,102.93 C595.2 196.44,103.84 196.59,103.99 v1(196.59,104.03) ; v1(84.43,26.61) 83.84,26.61 PC1129.2 ; JDIMM2.205 129.28,19.35 130.86,17.77 v1(130.86,17.21) ; PC311.2 v1(210.92,78.42) ; C769.2 205.09,53.11 205.09,52.69 204.86,52.46 204.86,52.01 v1(204.94,51.93) ; v1(182.99,155.42) 183.04,155.47 JMINI3.26 ; R55.2 C22.2 55.1,158.09 v1(54.58,157.57) ; v1(180.1,155.4) 180.1,155.74 179.84,156 JMINI3.18 ; R813.1 v1(260.2,80.46) 259.31,81.34 R2203.1 ; PC718.2 19.02,83.37 19.4,83.76 v1(20.17,83.76) ; v1(214.6,89.97) 214.9,89.68 C419.2 ; C450.2 R105.1 v1(265.28,80.46) ; v1(98.4,41.97) 98.37,41.93 CC89.2 98.37,40.18 CC88.2 ; C604.2 179.18,102.65 v1(179.48,102.95) 179.63,102.95 179.93,102.65 C602.2 ; v1(292.45,112.13) C793.2 ; R767.1 233.53,81.36 v1(233.53,82.09) ; Q55.3 286.69,62.74 286.32,63.11 v1(286.05,63.11) ; v1(90.02,28.64) 90.6,28.64 PC1128.2 ; C92.2 200.54,154.05 v1(200.71,154.22) ; R51.1 206.11,86.44 v1(206.11,86.92) 206.11,87.21 205.41,87.91 203.1,87.91 203.09,87.91 C600.2 ; PQ3.3 v1(1.56,58.17) ; C260.2 32.41,13.44 32.27,13.3 v1(32.27,12.85) ; C669.2 284.72,56.31 v1(284.2,56.83) ; C637.1 v1(183.07,153.01) C635.2 ; v1(164.68,156.67) 164.43,156.67 163.68,155.92 C745.2 ; JMINI1.50 106.97,163.05 v1(106.63,162.7) ; PC797.1 40.55,86.11 ; R57.1 45.21,147.16 R67.1 44.12,147.18 v1(43.85,147.45) ; v1(202.77,78.45) 202.77,77.94 PC309.2 201.89,77.9 v1(201.89,78.44) ; PR220.2 PC215.2 v1(238.38,52.61) ; RH49.2 12.04,95.3 13.19,94.15 14.39,94.15 14.71,94.46 v1(14.71,94.76) ; PC1135.2 89.99,35.4 v1(89.81,35.4) ; Q305.1 14.72,133.05 15.03,133.35 v1(15.05,133.35) ; v1(126.05,40.23) 126.07,40.26 126.07,44.58 CD33.2 ; PC1141.2 85.83,82.49 v1(86.21,82.87) ; JRTC1.4 57.37,102.31 v1(57.4,102.34) ; RH174.2 25.25,99.9 25.41,99.73 25.41,99.57 25.42,99.56 25.42,99.06 25.8,98.69 26.06,98.69 v1(26.06,98.68) ; v1(269.16,31.38) 268.87,31.67 C630.2 ; C24.1 216.81,85.08 v1(217.84,85.08) ; PR313.2 215.21,75.92 214.98,76.14 v1(213.97,76.14) ; PC101.2 276.31,65.7 276.54,65.48 v1(276.54,64.92) ; v1(92.85,111.16) 92.3,111.71 C695.2 R757.2 ; v1(7.3,119.89) 6.99,120.2 CH98.2 RH278.2 6.99,123.01 7.33,123.34 7.72,123.34 7.73,123.36 v1(7.94,123.36) 8.14,123.36 8.22,123.28 9.22,123.28 CH71.2 ; v1(249.31,78.73) 249.13,78.55 C708.2 ; JMINI1.54 v1(100.44,169.16) ; JMINI1.15 101.23,145.85 v1(101.38,146) ; v1(200.3,80.3) 202.96,80.3 203.54,80.89 C449.2 ; JMINI4.26 22.84,150.57 v1(23.21,150.94) ; PQ909.3 v1(244.62,20.24) ; v1(275.36,74.5) 276.49,75.63 R62.1 C496.2 ; v1(44.04,12.64) 44.15,12.53 44.79,12.53 PR609.1 ; CD3.2 129.67,51.43 130.03,51.07 v1(130.69,51.07) 130.21,50.59 130.21,49.45 129.44,48.67 CD7.2 ; v1(191.48,86) 191.86,85.62 192.39,85.62 C357.2 192.1,86.91 190.84,86.91 190.18,87.57 v1(190.18,87.94) ; PC1136.2 83.67,81.98 v5(82.78,82.87) ; CD48.2 v1(162.63,52.38) ; C716.2 246.31,78.55 v1(246.4,78.46) ; CC92.2 65.05,85.98 66,86.93 v1(66,87.89) ; PC938.2 v1(228.01,21.35) ; JMINI3.4 171.04,158.08 171.78,158.81 171.78,158.84 v1(172.02,159.08) ; Q69.3 v1(289.52,53.02) ; v1(188.85,102.4) 188.85,102.46 189.03,102.65 C605.2 ; v1(101.43,116.02) 101.43,115.95 101.22,115.74 101.22,114.48 100.94,114.2 CE9.2 ; v1(48.12,118.72) 47.88,118.48 47.15,118.48 46.53,117.86 CH85.2 ; v1(17.25,99.33) 17.22,99.35 17.22,99.63 17.12,99.73 RH59.2 ; v1(290.77,80.47) R59.1 ; v1(199.24,77.41) C352.2 ; v1(224.98,82.42) 224.14,81.59 JFAN2.3 ; C749.1 247.1,72.49 v1(246.52,73.08) 245.9,72.45 R803.2 ; R91.2 215.96,87.63 215.63,87.96 v1(215.63,87.92) ; v1(73.35,53.87) 73.56,53.66 CC85.2 ; PC936.2 v1(238.05,16) ; v1(25.63,73.72) 25.25,73.34 PC755.2 ; v1(48,157.39) 48.36,157.75 C20.2 ; v1(265.48,30.23) 265.08,30.23 264.83,29.97 JSIM1.5 ; v1(128.97,58.74) 129.47,58.23 CD4.2 CD2.2 ; RC61.1 59.03,71.91 RC56.1 57.99,73 v1(57.83,72.84) ; v1(90.02,26.61) 90.6,26.61 PC1127.2 ; v1(228.88,74.46) 228.88,74.33 228.55,74 C712.2 ; v1(7.68,75.74) 7.68,73.21 PD7.2 ; Q87.3 181.92,174.45 182.15,174.69 v1(182.15,175.17) ; R1613.1 279.06,83.85 Q338.3 279.14,84.45 278.84,84.75 v1(278.48,84.75) ; C722.2 37.23,11.99 v1(38.97,11.99) ; CMOS1.1 ME1.1 v1(141.36,92.04) ; CD26.2 126.12,59.77 CD30.2 125.88,60.69 126.38,61.19 127.34,61.19 v1(127.56,60.97) 127.56,61.1 128.75,62.29 CD41.2 ; v1(89.76,37.78) 90.35,37.78 PC1131.2 ; D15.1 v1(296.77,123.57) ; C86.2 45.03,143.9 v1(44.02,144.92) ; JMINI1.53 100.44,138.21 101.74,139.51 v1(101.74,139.85) ; v1(166.77,145.03) 166.65,144.91 C740.2 ; RD37.1 147.8,93.07 v1(148.42,93.69) 148.82,93.29 RD38.1 ; v1(266.74,66.36) 266.3,66.36 266,66.05 PQ105.3 ; PC1132.2 PC1133.2 84.3,38.16 v1(84.68,37.78) ; v1(180.07,150.8) 180.73,150.14 C289.2 ; CD68.2 161.39,23.9 v1(161.62,24.13) 161.87,24.13 162.41,23.6 CD45.2 ; v1(167.51,54.92) 166.93,54.33 CD53.2 ; JXDP1.28 83.6,91.49 v1(83.2,91.08) ; C725.2 35.69,20.88 36.52,20.05 v1(37.62,20.05) ; v1(162.83,140.07) 163.2,140.44 R881.1 ; v1(194.61,164.58) JMINI3.53 ; JMINI1.9 101.79,143.44 v1(102.65,144.31) ; v1(206.72,78.35) 207.36,78.99 C420.2 ; v1(105.97,150.97) 105.92,150.91 105.92,150.31 106.17,150.05 106.89,150.05 107.08,150.25 JMINI1.18 ; RC46.2 67.11,83.57 v1(67.18,83.5) 67.41,83.27 RC58.2 ; v1(275.87,71.27) 275.87,71.68 276.77,72.58 R77.2 R75.1 ; R113.1 R114.1 v1(255.12,68.52) ; CD31.2 125.11,51.88 v1(124.89,51.66) ; C293.2 74.52,151.89 74.33,152.08 v1(73.61,152.08) 73.51,151.98 R1632.2 ; PC619.1 47.85,12.45 v1(48.35,11.95) ; PC602.1 v1(52.21,21.19) ; v1(229.5,81.97) 229.76,81.71 JFAN2.5 ; v1(84.45,65.18) 83.92,64.64 PC1113.2 ; CH70.2 12.3,114.55 v1(11.89,114.97) ; PC941.2 240.65,21.07 v1(241.15,21.57) ; C628.2 v1(265.12,37.62) ; v1(191.38,92.19) 191.32,92.19 191.09,91.96 JMINI2.21 ; v1(8.99,135.8) 8.48,135.29 7.8,135.29 6.19,133.69 5.54,133.69 v4(4.53,132.67) 3.53,131.67 3.53,129.55 2.69,128.72 v1(2.68,128.72) ; v1(201.71,160.06) 201.71,159.67 C634.2 ; v1(174.14,92.19) 174.14,92.19 174.14,92.01 175.19,90.96 JMINI2.53 ; Q339.4 290.21,64.89 v1(290.14,64.96) ; JMINI3.43 189.84,163.8 v1(190.05,163.59) ; JMINI3.21 v1(181.04,163.16) ; v5(78.46,82.87) 79.22,82.11 PC1118.2 ; v1(240.88,36.89) PR224.2 PC216.2 ; C754.2 R904.2 v1(296.52,110.81) ; PR942.2 v1(233.48,15.75) ; v1(126.99,57.62) 126.68,57.62 125.88,56.82 CD29.2 ; JMINI2.26 189.09,96.98 v1(189.23,96.84) ; R88.2 216.53,82.32 v1(216.73,82.53) R87.2 ; JMINI1.26 107.11,153.45 v1(106.56,153.99) ; CD54.2 v1(163.97,49.34) ; v1(126.13,82.36) 126.16,82.33 126.16,81.79 126.83,81.12 CD37.2 CD38.2 CD40.2 CD39.2 ; PR215.2 242.28,44.64 v1(241.9,45.02) ; v1(239.07,82.32) 239.11,82.28 C710.2 ; v1(81.52,135.59) 81.13,135.98 C296.2 ; C750.1 249.01,76.63 v1(249.29,76.91) ; CD77.2 163.12,57.48 v1(163.42,57.79) ; v1(43.9,146.15) 43.99,146.05 R69.1 ; CH106.2 33.77,133.63 v1(34.48,134.34) ; PC616.2 38.77,12.91 v1(39.02,12.66) ; RH134.1 21.61,132.7 v1(21.61,133.3) ; v1(259.18,68.52) R111.1 ; C774.2 v1(185.77,174.98) ; R74.1 40.49,150.93 v1(40.65,151.09) ; v1(173.57,163.73) 173.04,164.26 JMINI3.9 ; v1(45.06,138.6) 44.74,138.28 Q326.1 ; v1(51.46,158.09) C23.2 R54.2 ; PR515.2 v1(55.98,27.75) ; v1(272.83,68.48) 272.83,68.91 273.11,69.19 C453.2 ; R775.1 v1(241.15,82.06) ; v1(15.98,99.48) 15.98,99.58 16.01,99.62 16.01,100.08 RH48.2 ; v1(50.01,24.7) 50.01,24.52 PC601.2 ; PR1001.2 v4(132.97,114.36) 132.13,114.36 131.9,114.14 v1(131.89,114.14) ; v1(238.86,62.17) R17.1 ; v1(219.43,89.52) 219.43,89.73 219.06,90.09 Q67.3 ; v1(47.53,100.23) 47.34,100.42 44.69,100.42 44.02,99.75 PC2.2 ; U40.2 264.25,34.02 v1(263.9,34.37) ; v1(287.12,66.74) 287.15,66.74 287.37,66.97 R79.2 ; JMINI4.43 v1(29.64,159.3) ; Q61.3 207.22,51.7 206.83,51.31 v1(205.17,51.31) ; C759.2 283.94,89 PWRSW1.2 283.95,88.37 284.25,88.06 v1(284.25,88.02) ; C702.2 80.64,133.9 80.64,134.43 v1(80.31,134.76) ; v1(146.27,108.07) v4(146.27,106.49) 146.27,106.16 145.88,105.78 PC1003.2 143.85,105.78 PC1002.2 ; v1(222.9,88.95) 223.5,88.35 JFAN2.6 ; C455.2 R110.1 v1(253.08,80.46) ; C616.2 264.02,31.77 264.55,32.3 v1(264.74,32.3) 265.19,31.84 C629.2 ; C484.2 83.88,141.59 v1(83.23,142.24) 82.87,142.24 82.4,141.77 C486.2 ; v1(265.2,66.35) 265.2,66.03 264.97,65.8 PC119.2 ; R921.2 v1(285.85,49.12) ; PC1137.2 81.63,82.06 v5(80.82,82.87) ; JMINI4.50 32.44,150.96 v1(32.22,151.18) ; CC86.2 70.76,45.71 v1(70.5,45.97) ; R102.1 232.64,81.7 v1(232.26,82.08) ; JMINI3.27 183.44,164.16 v1(183.93,163.67) 184.24,163.99 JMINI3.29 ; CD70.2 162.63,54.61 162.18,54.16 v1(161.84,54.16) ; D33.1 75.79,136.45 76.3,136.96 v1(76.64,136.96) ; v1(26.15,155.98) 26.44,156.27 JMINI4.35 ; v1(290.23,89.75) 290.47,89.99 C794.2 ; RH132.1 23.72,132.86 22.88,133.69 v1(22.88,133.87) ; v1(280.26,64.33) 280.26,64.96 279.91,65.31 PR106.1 279.25,65.98 278.87,66.36 PR103.1 ; PC1120.1 v1(78.4,58.74) ; R791.2 226.36,73.06 v1(226.35,73.08) ; v1(29.09,28.11) 28.83,27.84 28.1,27.84 R517.2 ; JXDP1.27 v1(66.2,91.35) ; PC1156.2 v1(87.48,58.48) ; JMINI2.27 188.69,91.85 v1(188.39,92.15) 187.89,91.65 JMINI2.29 ; v1(202.54,80.96) C354.2 ; PR944.2 v1(241.15,20.05) ; C1181.2 64.52,149.38 64.21,149.06 v1(64.21,148.64) ; v1(203.95,93.27) 205.14,92.08 JMINI2.54 ; v1(271.12,68.5) R108.1 ; JMINI4.27 23.24,156.54 23.09,156.39 v1(23.09,156.02) 23.84,156.02 24.04,156.22 JMINI4.29 ; PC1106.2 v1(78.4,66.99) ; JMINI1.35 101.5,157.05 v1(101.55,157) ; v1(235.58,81.98) 235.56,81.96 R1582.1 ; PC1130.2 83.84,28.64 v1(84.43,28.64) ; v1(200.9,103.58) 200.57,103.25 C606.1 C603.2 ; v1(101.7,150.42) 101.7,150.67 100.93,151.44 JMINI1.21 ; JMINI4.53 35.06,157.15 v1(34.47,156.55) ; v1(287.76,47.18) 287.76,47.74 C775.2 288.52,47.74 v1(288.52,47.18) ; JMINI3.15 175.44,164.36 176.25,163.55 v1(176.25,163.25) ; CD84.2 160.76,79.9 160.27,80.39 160.27,81.36 v1(160.63,81.71) ; v1(249.24,79.93) 249.24,79.83 248.97,79.57 C719.2 ; v1(42.77,144.98) v4(43.67,144.09) 44.35,143.4 C437.2 ; JDIMM3.205 165.19,20.83 v1(165.86,21.5) ; v1(186.97,166.83) 186.64,166.5 JMINI3.35 ; PC1162.1 v1(78.4,63.06) ; C713.2 228.67,71.17 v1(228.84,71.34) ; R747.2 v1(293.63,61.2) ; JMINI1.43 98.54,160.25 v1(98.31,160.47) ; PR941.2 v1(228.01,19.06) ; R2201.1 271.5,81.34 v1(272.39,80.46) R773.1 ; C96.2 214.35,105.39 v1(215.11,105.39) ; v1(162.32,85.43) 162.51,85.43 162.99,84.95 JDIMM3.206 ; PC507.2 55.35,22.42 v1(54.84,22.92) ; v1(288.78,62.54) 289.2,62.54 C1341.2 ; C498.2 84.99,30.76 v1(84.31,30.09) ; JMINI4.15 15.24,156.77 15.48,156.54 15.81,156.54 16.29,157.02 v1(16.29,157.59) ; R2202.1 251.34,77.12 v1(251.94,77.72) ; PC937.2 238.4,14.99 238.73,15.32 v1(238.73,16.02) ; v1(170.25,167.58) 170.65,167.97 PU2.4 ; C711.2 249.75,68 249.19,68.57 249.1,68.57 249.03,68.64 v1(248.77,68.64) ; PC217.2 PR225.2 v1(238.05,44.23) ; v1(84.43,24.58) 83.84,24.58 PC1134.2 ; C639.2 C625.2 v1(191.21,153.01) ; v1(166.39,150.08) 166.39,149.63 165.9,149.14 C727.2 ; v1(37.62,23.64) 37.16,23.18 C724.2 ; v1(161.92,155.98) 161.92,155.93 161.63,155.64 161.63,155.24 R879.1 ; v1(276.27,68.94) 276.69,68.52 C87.2 R81.2 ; C714.2 v1(237.84,82.69) ; CH8.2 7.62,125.66 7.62,124.91 RH32.2 7.75,124.78 7.75,124.17 v1(7.94,123.99) ; C95.2 208.1,112.47 v1(207.73,112.1) 208.49,111.34 R519.1 ; C778.2 v1(248.51,61.99) ; C608.2 185.49,86.47 185.72,86.25 v1(185.84,86.25) ; v1(41.64,101.98) 41.76,102.1 CH97.2 ; PC208.1 230.29,39.6 v1(230.34,39.56) ; v1(196.52,78.14) 196.52,78.16 196.95,78.59 R305.2 ; v1(19.63,151.18) 19.82,150.99 19.82,150.61 19.64,150.43 JMINI4.18 ; R107.1 R103.1 v1(268.32,80.46) ; v1(187.76,151.08) Q68.3 ; CD56.2 v1(167.8,49.34) ; C479.2 91.79,141.3 91.11,140.61 v1(91.11,140.58) ; v1(160.76,166.27) v4(162.44,164.58) JMINI3.54 ; C88.2 290.77,69.75 v1(290.42,69.41) ; v1(51.19,24.77) PC510.2 ; v5(76.81,82.87) 77.06,82.61 PC1140.2 76.87,81.8 75.53,80.46 RC44.2 ; v1(176.82,102.86) 177.03,102.65 R716.2 C632.2 ; C715.2 277.85,79.63 278.24,80.02 v1(278.24,80.2) ; v1(90.02,24.58) 90.6,24.58 PC1126.2 ; v1(191.81,158.81) 191.83,158.81 192.64,158.01 JMINI3.50 ; JMINI2.18 192.29,97.85 192.79,97.36 194.97,97.36 v1(195.11,97.22) ; v1(191.74,80.33) R301.2 ; C404.2 195.9,50.05 195.9,49.4 195.81,49.31 v1(195.81,49.17) ; CD64.2 v1(163.49,60.52) ; PR940.2 v1(228.01,24.4) ; JDIMM2.206 124.73,84.95 124.18,85.5 v1(124.13,85.5) ; v1(176.79,167.07) PC21.2 176.79,168.59 176.34,169.04 C776.2 ; C351.2 194.95,173.02 194.21,173.76 C356.2 v1(194.21,175.53) ; R892.1 176.8,149.11 v1(177.34,149.11) ; PR104.2 272.77,66.36 v1(272.39,65.98) PR107.2 ; PR305.2 106.89,23.01 PC305.2 107.98,24.14 v1(108.05,24.21) ; CD63.2 v1(163.54,61.79) ; PC1112.2 82.22,64.12 v1(82.9,63.44) ; PC796.1 40.49,61.29 40.49,61.29 ; PC703.2 24.52,87.9 v1(24.15,88.27) ; JMINI2.34 185.89,100.33 v1(186.16,100.6) ; C753.2 C748.2 v1(294.49,110.81) ; v1(78.4,52.26) 79.11,52.26 PC1164.1 ; Q59.3 v1(291.12,55.1) ; PQ910.3 247.74,14.6 247.76,14.58 247.78,14.58 247.79,14.59 v1(247.79,14.61) ; v1(279.45,66.87) 279.25,67.07 C497.2 ; Q66.3 10.69,133.27 v1(9.74,132.32) ; JMINI2.35 185.49,88.5 v1(185.3,88.32) ; CD57.2 v1(167.8,45.02) ; CD32.2 v1(124.81,48.32) ; CD88.2 v1(163.91,77.86) ; C732.2 172.28,143.52 172.64,143.16 172.64,142.35 v1(171.87,141.58) ; JSIM1.10 v1(256.27,13.17) ; v1(284.17,62.64) 284.15,62.64 283.51,62 PC105.2 283.51,61.28 284.07,60.72 v1(284.14,60.72) ; v1(128.95,60.66) 128.95,60.65 129.21,60.91 129.56,60.91 CD16.2 ; PC1005.2 v1(202.92,15.05) ; 40.83,69.18 40.84,69.17 PC794.1 ; CD87.2 160.89,78.04 v1(160.85,78.08) ; v1(173.07,109.83) 172.98,109.74 R717.2 ; v1(273.9,77.69) 274.13,77.45 R1207.1 ; v1(285.79,60.26) 285.72,60.19 C670.2 ; v1(292.31,51.79) 292.73,51.37 C777.2 ; R104.1 R106.1 v1(267.05,68.52) ; v1(183.01,146.3) C290.2 ; CD83.2 CD82.2 162.9,79.9 v1(163.37,80.38) ; C370.2 217.68,87.98 217.36,88.3 C330.2 218.11,88.8 v1(218.74,89.43) ; JRTC1.2 55.34,98.51 v1(55.59,98.26) 54.82,97.49 JRTC1.3 ; C292.2 71.45,146.82 71.45,148.59 v1(71.33,148.7) ; v1(50.06,158.09) R53.2 ; Q301.4 v1(28.4,16.64) ; R1631.2 295.62,52.61 v1(295.83,52.83) ; PC18.2 v1(176.75,175.05) ; v1(293.56,107.85) 293.56,107.29 293.15,106.89 Q318.4 ; C311.2 1.88,129.03 v1(2.7,129.86) ; v1(261.21,68.52) C451.2 ; PC103.2 PC106.2 280.74,54.96 v1(280.39,55.31) ; CH105.2 46.79,126.76 47.18,127.15 v1(47.19,127.15) ; Q20.3 v1(67.42,147.73) ; PU902.4 v1(233.73,21.21) ; PC214.2 PR217.2 v1(240.75,45.53) ; v1(105.31,139.9) 106.85,141.44 JMINI1.4 ; R786.2 234.29,62.4 234.49,62.19 v1(234.49,61.99) ; v1(47.51,113.7) 47.3,113.91 JSPI1.18 ; R89.2 v1(204.56,86.1) ; v1(69.85,156.21) 70.11,155.95 Q13.4 ; C480.2 90.02,140.79 v1(90.36,140.45) ; v1(109.37,17.78) 109.82,17.78 110.3,18.26 110.3,18.86 PR306.2 ; v1(59.79,26.7) 59.62,26.53 PR506.2 ; 40.68,72.06 40.68,72.06 PC793.1 ; RD20.1 127.51,77.54 127.96,77.09 v1(127.96,76.77) 127.99,76.77 128.24,77.03 RD19.1 ; JFAN1.6 9.21,78.6 v1(10.21,77.6) ; RH270.1 RH172.2 18.9,99.93 18.9,99.84 18.64,99.58 18.64,99.56 v1(18.62,99.53) ; C704.2 112.03,113.06 v1(111.85,112.88) ; R13.1 v1(240.13,82.33) ; CD69.2 v1(166.69,52.55) ; PC211.2 234.51,39.58 v1(234.53,39.56) ; v1(130.05,43.92) 129.44,44.54 CD9.2 ; v1(237.39,21.93) 236.94,22.38 PC940.2 ; v1(78.42,160.74) 77.6,160.74 77.14,160.29 C485.1 ; JMINI2.9 199.09,89.34 198.59,88.84 v1(198.19,88.84) 197.19,88.84 196.69,89.33 JMINI2.15 ; v1(249.97,79.96) 249.97,80.16 249.55,80.58 C717.2 C718.2 ; R2160.2 90.61,133.64 v1(91.04,134.07) 91.54,133.58 C696.2 ; v1(166.52,140.93) 166.48,140.97 166.48,140.99 166.18,141.29 C736.2 ; R888.2 245.9,71.44 246.02,71.31 v1(246.37,71.31) ; v1(110.13,156.01) 110.13,156.21 109.7,156.65 JMINI1.34 ; RC52.2 74.52,83.17 73.99,83.71 v1(73.7,83.71) 73.56,83.57 RC53.2 ; PC210.2 v1(233.37,50.58) ; PC939.2 228.38,20.08 v1(228,19.7) ; v1(186.21,158.92) 186.24,158.88 JMINI3.34 ; v1(78.24,135.66) 78.24,134.98 CE6.2 ; v1(191.11,78.68) 191.54,78.68 C362.2 191.67,79.31 v1(191.11,79.31) ; R109.1 R112.1 v1(256.13,80.46) ; v1(40.3,39.99) 40.61,40.31 PC710.2 ; R90.2 R82.2 205.67,81.19 v1(205.31,80.82) ; v1(264.64,76.9) 264.42,76.68 R2200.1 ; v1(79.42,48.92) 79.6,49.1 79.6,50.36 79.02,50.94 CC83.2 CC84.2 74.42,50.94 v1(74.4,50.97) ; RH353.2 16.13,95.83 v1(16.13,94.69) ; v1(262.86,76.27) 262.61,76.52 262.1,77.03 R1191.1 ; v1(230.53,63.06) 230.53,63.07 230.69,62.91 231.16,62.91 R789.2 ; v1(246.39,70.42) R790.2 ; JFAN1.5 8.25,86.72 v1(9.05,85.92) ; R1620.2 177.43,107.43 177.43,108.13 v1(177.3,108.26) ; v1(47.13,154.38) 47.57,153.94 Q336.4 ; RC57.2 71.47,83.35 71.17,83.66 70.51,83.66 v1(70.46,83.71) RC62.2 ; PR1003.2 v1(197.8,17) ; v1(179.5,100.44) 179.49,100.43 JMINI2.50 ; v1(24.56,137.74) 24.56,137.44 23.82,136.7 CH37.2 24.6,136.37 24.89,136.67 CH36.2 ; PR312.2 212.1,77.79 212.1,78.28 v1(211.95,78.44) ; v1(279.63,55.18) PR112.2 ; v1(264.01,68.52) R809.1 ; v1(133.31,21.1) 132.83,21.58 132.83,22.96 132.4,23.39 CD24.2 131.67,23.4 CD23.2 ; v1(236.69,45.53) PC213.2 ; CH22.1 22.3,137.94 v1(22.71,137.53) ; PC795.1 40.52,58.44 40.51,58.43 ; v1(78.4,65.22) 79.24,65.22 PC1111.2 ; R86.2 v1(206.09,83.13) ; v1(158.42,157.12) 158.42,155.81 C757.2 C746.2 ; JMINI4.21 20.84,156.59 21.23,156.2 v1(21.23,156.02) ; v1(165.37,81.12) 165.37,81.12 164.15,79.9 CD81.2 ; v1(194.59,52.71) 194.59,51.5 194.97,51.12 C403.2 ; PR604.1 v1(46.71,24.32) ; v1(12.59,127.88) 12.9,127.57 RH273.2 ; PR503.1 55.51,20.16 v1(54.96,19.62) ; JMINI4.54 8.34,157.15 v1(8.36,157.13) ; v1(12.66,134.48) 13.28,134.48 Q305.4 ; v1(129.59,78.09) 129.59,78.23 129.93,78.57 CD44.2 CD43.2 ; CD55.2 v1(167.79,56.96) ; Q72.3 237.3,55.88 v1(237.5,56.08) ; v1(211.94,107.15) 211.96,107.18 212.16,107.18 R758.2 ; C723.2 v1(32.33,42.77) ; CD51.2 v1(163.99,45.02) ; v1(178.72,171.94) PC20.2 178.72,170.1 PR26.2 ; CE8.2 106.04,113.09 v1(106.04,115.74) ; JMINI4.34 v1(26.04,151.06) ; PC1165.1 v1(78.4,54.42) ; PR601.1 v1(47.73,24.32) ; v1(272.9,56.07) 272.31,56.07 PC117.2 272.18,55.44 v1(272.9,55.44) ; v1(236.83,62.17) R793.2 ; JSIM1.9 v1(276.82,12.23) ; PC942.1 v1(249.73,18.05) ; v1(64.84,160.74) 64.75,160.65 Q23.3 ; v1(8.96,148.04) 10.23,148.04 10.84,148.65 JMINI4.4 ; v1(195.27,52.73) 195.92,53.37 R912.2 196.97,53.37 C771.2 ; RH79.2 RH78.2 33.95,96.08 v1(34.16,96.29) ; PC1153.2 v1(87.48,54.29) ; PC310.2 v1(200.85,72) ; CD47.2 v1(163.4,47.05) ; PC1169.1 v1(78.4,56.58) ; v1(226.4,67.12) 227.04,66.49 R770.2 R804.2 ; CH100.2 v1(36.68,95.19) ; v1(200.81,100.72) 200.81,100.72 200.81,100.33 201.09,100.05 JMINI2.4 ; PC1155.2 v1(87.48,56.45) ; PC1150.2 v1(87.48,52.13) ; v1(181.98,88.72) 181.98,88.72 182.29,89.03 JMINI2.43 ; JMINI1.29 101.32,154.65 v1(101.53,154.43) 100.95,153.85 JMINI1.27 ; C353.2 192.37,174.14 v1(192.07,174.44) ; v1(8.52,58.48) 7.89,59.12 PR12.1 ; PC792.1 45.07,52.97 ; v1(237.84,62.15) C709.2 ; C631.2 v1(268.04,37.7) ; v1(252.07,68.52) R826.1 ; v1(156.63,141.29) R876.1 ; v1(156.56,144.34) C744.2 ; PC1161.1 v1(78.4,60.9) ; JMINI4.9 v1(12.84,155.81)
  vias: v1(2.77,131.48) v1(2.94,134.6) v1(3.22,169.23) v1(3.45,58.75) v1(3.58,177.06) v1(3.55,174.31) v1(4.01,153.61) v1(4.71,153.61) v1(5.48,177.17) v1(5.51,174.27) v1(5.46,153.62) v1(5.47,126.72) v1(7.02,143.83) v1(7.66,143.83) v1(8.36,143.45) v1(8.43,142.77) v1(8.46,142.13) v1(8.47,132.15) v1(9.09,143.41) v1(9.09,142.77) v1(9.1,142.14) v1(9.19,58.51) v1(9.93,58.53) v1(9.97,82.64) v1(9.94,81.95) v1(10.82,165.24) v1(10.76,58.52) v1(11.33,156.21) v1(12.3,172.9) v1(12.83,165.24) v1(12.8,71.4) v1(12.79,70.73) v1(12.79,70.08) v1(12.8,69.44) v1(12.79,68.81) v1(12.8,68.16) v1(12.8,67.51) v1(12.88,66.85) v1(13.3,66.35) v1(13.4,71.08) v1(13.36,70.41) v1(13.4,69.72) v1(13.44,69.08) v1(13.52,146.37) v1(13.52,145.73) v1(13.51,68.19) v1(13.51,67.55) v1(13.6,66.92) v1(14.02,66.37) v1(14.16,146.37) v1(14.16,145.73) v1(14.16,68.24) v1(14.25,67.59) v1(14.4,66.92) v1(15.11,172.89) v1(15.11,165.16) v1(15.4,130.24) v1(16.39,63.2) v1(16.56,63.83) v1(17.05,63.3) v1(17.33,172.89) v1(17.31,92.2) v1(17.63,147.38) v1(17.63,146.75) v1(17.88,160.08) v1(18.26,147.38) v1(18.26,146.75) v1(18.49,130.92) v1(18.97,123.3) v1(19.03,119.34) v1(18.99,113.38) v1(18.98,111.41) v1(18.96,109.42) v1(18.96,107.43) v1(19.1,121.23) v1(19.09,115.44) v1(19.68,124.26) v1(19.72,115.35) v1(19.71,112.42) v1(19.76,105.17) v1(20.04,78.42) v1(20.22,172.17) v1(20.29,174.74) v1(20.32,125.26) v1(20.36,113.37) v1(20.36,112.42) v1(20.7,126.98) v1(20.81,107.07) v1(21.03,121.25) v1(21.03,112.43) v1(21.04,113.34) v1(21.71,115.38) v1(21.66,112.43) v1(21.78,109.42) v1(22.07,154.88) v1(22.32,117.3) v1(22.72,127.06) v1(22.72,126.34) v1(22.72,125.1) v1(22.72,123.82) v1(22.64,107.73) v1(22.74,105.72) v1(22.79,122.3) v1(22.93,177.04) v1(22.93,173.91) v1(22.87,170.65) v1(22.9,168.36) v1(22.99,118.34) v1(22.99,115.38) v1(23,114.38) v1(22.98,110.39) v1(23.06,113.38) v1(23.62,115.37) v1(23.75,166.7) v1(24.28,111.44) v1(24.38,166.7) v1(24.65,126.31) v1(24.7,109.69) v1(24.7,107.69) v1(24.7,105.69) v1(24.75,125.07) v1(24.76,122.35) v1(25.02,166.7) v1(25.06,172.73) v1(25.12,7.35) v1(25.63,155.26) v1(25.7,123.71) v1(25.68,119.6) v1(25.7,116.37) v1(25.69,79.57) v1(25.69,78.41) v1(25.91,23.03) v1(25.92,22.35) v1(26.43,113.11) v1(26.47,117.98) v1(26.52,80.07) v1(26.69,107.69) v1(26.69,105.66) v1(26.74,78.8) v1(26.9,142.14) v1(27,177.18) v1(26.97,174.59) v1(26.97,171.91) v1(27.26,113.11) v1(27.67,125) v1(27.72,123.03) v1(27.69,109.66) v1(27.66,107.7) v1(28.04,137.58) v1(28.1,120.39) v1(28.29,78.55) v1(28.42,80.14) v1(28.63,126.93) v1(28.63,126.29) v1(28.63,125.02) v1(28.62,123.72) v1(28.64,104.24) v1(28.68,107.75) v1(28.68,107.07) v1(28.68,106.43) v1(28.68,105.75) v1(28.93,147.88) v1(28.89,142.15) v1(28.91,120.41) v1(28.91,115.54) v1(28.91,113.91) v1(29.08,38.95) v1(29.11,36.84) v1(29.71,117.98) v1(29.72,116.34) v1(29.64,110.95) v1(29.67,106.32) v1(29.77,137.15) v1(29.96,87.88) v1(30.07,147.89) v1(30.22,63.17) v1(30.49,171.81) v1(30.53,113.1) v1(30.63,123.1) v1(30.54,117.19) v1(30.63,109.65) v1(30.62,108.32) v1(30.65,125.09) v1(30.67,105.74) v1(30.73,62.66) v1(30.86,63.32) v1(30.95,1.49) v1(31.06,147.89) v1(31.52,142.1) v1(31.66,126.29) v1(31.65,124.33) v1(31.66,109.54) v1(31.66,108.24) v1(32.16,120.35) v1(32.17,117.2) v1(32.15,115.52) v1(32.15,113.94) v1(32.18,113.12) v1(32.62,126.33) v1(32.56,123.09) v1(32.62,105.75) v1(32.64,127.07) v1(32.64,125.01) v1(32.66,110.9) v1(32.66,110.21) v1(32.93,117.97) v1(33.01,119.6) v1(33.58,142.14) v1(33.65,110.88) v1(33.67,110.25) v1(33.81,171.81) v1(34.34,120.29) v1(34.36,114.3) v1(34.47,137.71) v1(34.62,127.07) v1(34.62,125.08) v1(34.57,110.3) v1(34.62,105.63) v1(34.97,120.31) v1(35.02,118.35) v1(35.57,123.13) v1(35.61,109.66) v1(35.61,108.9) v1(35.61,108.26) v1(35.67,117.31) v1(35.78,118.35) v1(36.36,123.37) v1(36.36,115.34) v1(36.41,114.31) v1(36.61,124.95) v1(36.6,106.44) v1(36.64,126.98) v1(36.66,107.69) v1(37.01,148.83) v1(37.03,117.31) v1(37.02,112.43) v1(37.08,171.78) v1(37.11,146.85) v1(37.1,121.32) v1(37.12,110.39) v1(37.23,144.82) v1(37.57,145.83) v1(37.6,125.57) v1(37.62,106.5) v1(37.7,117.3) v1(37.67,109.42) v1(37.82,80.88) v1(37.82,63.44) v1(37.82,62.55) v1(37.82,58.48) v1(37.93,176.89) v1(37.9,173.65) v1(38.01,167.22) v1(38.19,121.32) v1(38.33,123.33) v1(38.31,122.23) v1(38.33,115.35) v1(38.33,59.04) v1(38.36,117.31) v1(38.38,114.31) v1(38.43,37.48) v1(38.45,77.58) v1(38.57,126.93) v1(38.58,62.93) v1(38.72,130.94) v1(38.71,75.04) v1(38.78,125.34) v1(38.84,83.93) v1(38.84,68.44) v1(38.84,59.8) v1(38.99,119.36) v1(38.95,111.39) v1(38.96,69.41) v1(38.96,56.83) v1(39.09,58.28) v1(39.28,86.41) v1(39.34,88.89) v1(39.34,88) v1(39.34,87.23) v1(39.34,76.06) v1(39.34,66.15) v1(39.34,62.55) v1(39.37,24.74) v1(39.53,126.26) v1(39.51,107.33) v1(39.47,81.77) v1(39.47,81.01) v1(39.47,77.84) v1(39.47,59.17) v1(39.62,117.3) v1(39.54,108.38) v1(39.6,80.25) v1(39.6,74.23) v1(39.6,71.87) v1(39.6,64.07) v1(39.6,57.6) v1(39.73,105.84) v1(39.72,83.93) v1(39.72,69.41) v1(39.72,68.44) v1(39.72,56.75) v1(39.71,32.04) v1(39.71,31.41) v1(39.67,28.52) v1(39.71,27.28) v1(39.71,26.65) v1(39.71,25.44) v1(39.77,29.19) v1(39.94,172.67) v1(39.85,76.95) v1(39.85,63.06) v1(39.98,75.17) v1(39.98,59.93) v1(40.11,58.28) v1(40.22,126.28) v1(40.27,125.26) v1(40.26,123.28) v1(40.32,121.31) v1(40.31,119.31) v1(40.32,117.29) v1(40.31,115.35) v1(40.27,109.35) v1(40.49,88.89) v1(40.49,88) v1(40.49,87.23) v1(40.49,86.47) v1(40.49,81.77) v1(40.49,81.01) v1(40.49,80.25) v1(40.49,77.84) v1(40.49,76.19) v1(40.49,74.28) v1(40.49,71.87) v1(40.49,66.15) v1(40.49,64.12) v1(40.49,62.6) v1(40.49,59.17) v1(40.61,83.93) v1(40.61,69.41) v1(40.61,68.44) v1(40.61,57.34) v1(41.38,52.82) v1(41.38,51.93) v1(41.68,147.46) v1(42.05,111.96) v1(42.26,52.82) v1(42.26,51.93) v1(42.54,128.6) v1(42.7,147.4) v1(42.77,146.11) v1(42.9,51.17) v1(43.15,52.82) v1(43.15,51.93) v1(43.53,27.98) v1(43.53,27.34) v1(43.53,26.07) v1(43.53,25.44) v1(43.7,172.57) v1(44.04,52.82) v1(44.04,52.06) v1(44.17,51.29) v1(44.66,50.61) v1(44.93,71.82) v1(44.93,52.06) v1(44.93,51.29) v1(45.06,79.19) v1(45.19,86.42) v1(45.31,44.39) v1(45.57,71.82) v1(45.69,79.19) v1(45.82,86.42) v1(45.82,64.58) v1(45.82,63.95) v1(45.82,25.59) v1(46.2,71.82) v1(46.33,79.19) v1(46.52,94.39) v1(46.46,86.42) v1(46.46,64.58) v1(46.7,171.67) v1(46.84,58.23) v1(46.84,57.6) v1(46.94,120.23) v1(47.09,52.82) v1(47.09,50.02) v1(47.09,42.23) v1(47.09,25.59) v1(47.47,57.6) v1(47.6,52.06) v1(47.73,42.23) v1(48.11,50.02) v1(48.23,52.82) v1(48.3,29.1) v1(48.36,42.23) v1(48.49,18.73) v1(48.49,16.96) v1(48.75,94.43) v1(48.74,52.06) v1(49,50.02) v1(49,42.23) v1(49.25,17.84) v1(49.5,52.82) v1(49.76,55.61) v1(50.01,51.93) v1(50.01,50.02) v1(50.27,18.73) v1(50.27,16.96) v1(50.39,52.69) v1(50.77,51.93) v1(50.77,50.02) v1(51.03,63.44) v1(51.03,57.6) v1(51.03,56.83) v1(51.23,148.04) v1(51.54,146.98) v1(51.54,68.18) v1(51.66,63.44) v1(52.17,68.18) v1(52.42,63.42) v1(52.69,52.82) v1(52.68,49.01) v1(52.68,47.1) v1(52.67,12.32) v1(52.81,68.14) v1(53.21,53.71) v1(53.44,68.14) v1(53.57,49.01) v1(53.85,53.76) v1(54.48,53.81) v1(54.46,49.07) v1(54.72,81.05) v1(54.89,39.33) v1(54.9,38.62) v1(55.59,38.57) v1(57.39,134.73) v1(57.42,134.1) v1(57.38,19.69) v1(57.38,19.05) v1(58.01,19.69) v1(58.01,19.05) v1(58.77,134.71) v1(58.76,134.07) v1(59.42,24.7) v1(59.41,23.94) v1(59.42,23.18) v1(59.83,134.06) v1(59.88,134.71) v1(60.5,154.5) v1(60.95,155.37) v1(61.19,19.11) v1(61.19,18.48) v1(61.38,154.5) v1(61.75,155.37) v1(62.11,154.5) v1(62.08,17.72) v1(62.44,155.37) v1(62.71,59.63) v1(62.71,56.83) v1(62.84,154.48) v1(62.84,65.98) v1(62.84,62.93) v1(63.32,27.19) v1(63.47,59.63) v1(63.47,56.83) v1(63.6,65.98) v1(63.6,62.93) v1(63.96,27.19) v1(64.01,19.98) v1(64.49,65.98) v1(64.49,62.93) v1(64.49,59.63) v1(64.49,56.83) v1(64.53,20.35) v1(65.24,62.91) v1(65.17,20.32) v1(65.3,59.89) v1(65.3,56.9) v1(65.4,53.93) v1(66.01,18.61) v1(66.01,17.97) v1(66.32,65.96) v1(66.32,62.97) v1(66.32,59.97) v1(66.45,53.89) v1(67.33,62.89) v1(67.33,56.89) v1(67.35,53.89) v1(67.92,25.72) v1(67.92,25.08) v1(68.4,62.87) v1(68.4,59.84) v1(68.4,56.92) v1(68.55,25.72) v1(68.55,25.08) v1(69.53,149.67) v1(69.86,132.61) v1(70.18,149.68) v1(71.12,135.18) v1(71.22,133.92) v1(71.23,132.63) v1(71.44,53.86) v1(72.44,133.91) v1(72.46,135.22) v1(72.48,132.63) v1(72.45,53.87) v1(74.4,65.88) v1(74.4,62.89) v1(74.4,59.86) v1(74.41,56.89) v1(74.42,53.85) v1(75.09,85.22) v1(75.08,84.56) v1(75.06,83.87) v1(76.33,87.31) v1(77.44,144.74) v1(78.44,145.38) v1(78.44,144.74) v1(79.12,173.44) v1(79.12,172.81) v1(79.12,172.17) v1(80.03,17.75) v1(80.03,17.12) v1(80.67,17.75) v1(80.66,17.12) v1(81.89,57.72) v1(82.65,53.15) v1(83.78,62.75) v1(83.86,59.47) v1(83.92,56.45) v1(84.68,55.69) v1(84.68,54.67) v1(84.68,53.79) v1(84.68,17.72) v1(84.68,17.08) v1(85.32,17.72) v1(85.32,17.08) v1(87.81,135.47) v1(88.34,109.46) v1(89.72,135.47) v1(89.76,109.21) v1(89.76,17.72) v1(89.76,17.08) v1(90.26,139.18) v1(90.26,138.54) v1(90.4,17.72) v1(90.4,17.08) v1(90.89,139.17) v1(90.89,138.53) v1(91.86,122.62) v1(92.07,135.37) v1(93.42,34.67) v1(94.05,135.38) v1(94.59,17.72) v1(94.59,17.08) v1(95.22,17.72) v1(95.22,17.08) v1(95.68,124.79) v1(96.37,173.44) v1(96.37,172.81) v1(96.37,172.17) v1(97.75,34.05) v1(97.89,12.51) v1(98.16,116.03) v1(98.37,123.03) v1(98.53,12.51) v1(99.54,123.74) v1(99.9,106.29) v1(99.95,116.89) v1(100.05,12.51) v1(100.68,12.51) v1(101.47,123.91) v1(101.92,106.27) v1(103.61,123.37) v1(104.07,17.74) v1(104.8,17.58) v1(105.09,124.18) v1(105.55,20.3) v1(105.56,19.27) v1(105.56,18.31) v1(106.06,125.3) v1(106.54,20.3) v1(106.53,19.24) v1(106.53,18.35) v1(108.02,50.88) v1(108.47,50.42) v1(108.91,128.73) v1(108.97,49.93) v1(109.42,49.48) v1(110.81,129.01) v1(113.68,128.91) v1(115.57,113.04) v1(115.93,69.39) v1(116.59,69.39) v1(116.86,25.57) v1(116.99,156.52) v1(116.99,155.88) v1(117.66,72.76) v1(119.51,36.96) v1(119.68,129.86) v1(121.18,143.38) v1(121.18,71.83) v1(121.69,129.82) v1(121.77,71.29) v1(122.34,143.38) v1(122.87,162.19) v1(122.9,161.19) v1(122.92,159.98) v1(123.38,69.66) v1(123.8,143.38) v1(123.86,69.16) v1(124.01,162.2) v1(124.03,161.16) v1(124.05,160.01) v1(124.29,100.36) v1(124.78,40.23) v1(125,143.38) v1(125.09,162.2) v1(125.12,161.15) v1(125.13,160.01) v1(125.28,25.63) v1(125.41,40.23) v1(126.32,66.7) v1(126.5,143.38) v1(126.64,176.53) v1(129.18,176.53) v1(131.72,176.53) v1(131.72,31.18) v1(134.26,176.53) v1(136.72,64.6) v1(136.8,176.53) v1(137.32,82.33) v1(137.31,75.67) v1(137.47,36.68) v1(137.62,39.73) v1(137.62,34.75) v1(137.6,31.35) v1(137.83,80.6) v1(137.78,62.93) v1(137.83,29.23) v1(137.79,26.18) v1(137.91,77.04) v1(137.9,73.92) v1(137.86,23.95) v1(138.07,71.73) v1(138.5,27.5) v1(138.74,36.68) v1(138.8,66.59) v1(138.85,82.34) v1(138.93,79.01) v1(138.89,34.75) v1(138.89,32.73) v1(138.87,31.35) v1(139.03,64.6) v1(139.1,29.23) v1(139.06,26.18) v1(139.18,77.04) v1(139.17,73.92) v1(139.18,68.79) v1(139.18,62.93) v1(139.15,39.73) v1(139.34,176.53) v1(139.38,75.67) v1(139.34,71.72) v1(139.38,23.95) v1(139.38,20.63) v1(139.49,70.25) v1(139.93,159.86) v1(139.98,160.99) v1(139.95,158.61) v1(140.01,36.68) v1(140.12,80.6) v1(140.16,34.75) v1(140.15,22.64) v1(140.32,66.59) v1(140.27,31.35) v1(140.33,26.18) v1(140.37,82.34) v1(140.4,79.01) v1(140.44,73.92) v1(140.37,29.23) v1(140.45,77.05) v1(140.45,68.79) v1(140.45,62.93) v1(140.61,71.72) v1(140.54,39.73) v1(140.66,27.5) v1(140.91,23.95) v1(140.91,20.63) v1(141.05,32.73) v1(141.22,160.96) v1(141.2,159.83) v1(141.21,158.62) v1(141.67,64.51) v1(141.88,176.53) v1(142.33,158.65) v1(142.34,160.97) v1(142.39,159.79) v1(144.42,176.53) v1(145.51,76.11) v1(146.96,176.53) v1(149.5,176.53) v1(151.16,22.74) v1(151.44,38.01) v1(151.54,62.77) v1(151.51,20.84) v1(151.67,40.87) v1(151.67,24.59) v1(151.86,70.66) v1(151.85,35.69) v1(151.85,34.09) v1(151.84,30.52) v1(151.84,27.35) v1(151.97,66.15) v1(151.98,32.35) v1(152.04,176.53) v1(152.04,75.88) v1(152.04,72.83) v1(152.12,39.29) v1(152.36,80.09) v1(152.35,29.14) v1(152.48,64.32) v1(152.63,161.15) v1(152.71,38.01) v1(153,77.86) v1(153.03,20.84) v1(153.06,67.62) v1(153.06,62.77) v1(153.24,66.15) v1(153.2,40.87) v1(153.19,24.59) v1(153.26,81.6) v1(153.32,22.74) v1(153.39,70.66) v1(153.34,38.01) v1(153.38,35.69) v1(153.37,30.52) v1(153.37,27.35) v1(153.5,32.35) v1(153.57,75.88) v1(153.57,72.83) v1(153.64,69.32) v1(153.95,74.56) v1(154.14,34.09) v1(154.33,67.62) v1(154.41,39.29) v1(154.52,77.86) v1(154.51,66.15) v1(154.58,176.53) v1(154.58,62.77) v1(154.61,38.01) v1(154.64,29.14) v1(154.56,20.84) v1(154.65,80.09) v1(154.72,40.87) v1(154.72,24.59) v1(154.79,81.6) v1(154.76,64.32) v1(154.91,70.66) v1(154.89,30.52) v1(154.89,27.35) v1(155.03,35.69) v1(155.03,32.35) v1(155.09,75.88) v1(155.09,72.83) v1(157.12,176.53) v1(158.55,89.04) v1(159.66,176.53) v1(162.2,176.53) v1(164.74,176.53) v1(165.07,148.34) v1(165.07,147.1) v1(165.07,146.09) v1(165.94,119.94) v1(166.72,148.34) v1(166.72,147.13) v1(166.71,146.03) v1(167.28,176.53) v1(168.26,148.34) v1(168.26,147.13) v1(168.26,146) v1(168.25,15.16) v1(169.82,176.53) v1(171.55,36.64) v1(172.36,176.53) v1(173.86,64.52) v1(174.5,131.52) v1(174.5,64.52) v1(174.9,176.53) v1(175.13,64.52) v1(175.23,73.72) v1(175.23,70.55) v1(175.77,64.52) v1(175.89,132.22) v1(176.76,72.07) v1(177.44,176.53) v1(178.41,73.72) v1(178.41,70.55) v1(179.98,176.53) v1(180.57,31.94) v1(180.72,161.57) v1(181.35,9.12) v1(181.35,6.83) v1(181.39,3.18) v1(182.52,176.53) v1(183.13,3.16) v1(184.99,133.54) v1(185.06,176.53) v1(186.28,163.69) v1(187.6,176.53) v1(190.14,176.53) v1(190.35,29.02) v1(190.35,28.39) v1(190.35,26.99) v1(190.35,26.35) v1(190.35,25.08) v1(190.35,24.45) v1(190.47,47.44) v1(191.11,47.44) v1(191.46,73.15) v1(191.46,72.52) v1(191.74,23.31) v1(191.74,22.67) v1(192.1,72.52) v1(192.38,47.18) v1(193.01,47.18) v1(193.27,176.75) v1(193.34,109.98) v1(193.39,37.53) v1(193.39,36.77) v1(193.39,36.01) v1(194.13,178.11) v1(194.08,115.49) v1(194.19,49.56) v1(194.19,48.92) v1(194.16,37.53) v1(194.16,36.77) v1(194.16,36.01) v1(194.41,47.18) v1(194.49,124.27) v1(194.47,121.9) v1(194.5,119.52) v1(194.55,100.72) v1(194.83,49.56) v1(194.83,48.92) v1(194.92,37.53) v1(194.92,36.77) v1(194.92,36.01) v1(194.92,35.24) v1(195.05,47.18) v1(195.35,127.41) v1(195.68,37.53) v1(195.68,36.77) v1(195.68,36.01) v1(195.68,35.24) v1(195.87,109.98) v1(196.09,178.55) v1(196.05,73.06) v1(196.05,72.43) v1(196.44,47.05) v1(196.58,160.5) v1(196.61,159.51) v1(196.59,121.97) v1(196.68,73.06) v1(196.68,72.43) v1(196.92,177.38) v1(197.08,47.05) v1(197.56,177.38) v1(198.09,46.67) v1(198.19,177.38) v1(198.63,178.55) v1(198.73,92.16) v1(198.83,177.38) v1(198.91,167.77) v1(198.88,166.98) v1(198.86,166.18) v1(198.84,163.98) v1(198.94,165.06) v1(199.11,46.67) v1(199.62,130.64) v1(199.73,136.58) v1(199.74,167.83) v1(199.74,167.07) v1(199.74,166.18) v1(199.74,165.04) v1(199.74,163.89) v1(200.63,141.92) v1(200.63,92.52) v1(200.83,111.34) v1(200.77,93.43) v1(200.93,112.56) v1(200.89,108.26) v1(201.17,127.59) v1(201.4,94.51) v1(202.16,40.58) v1(202.33,42.62) v1(202.28,3.87) v1(202.41,130.62) v1(202.41,128.72) v1(202.49,118.52) v1(202.54,4.76) v1(202.6,134.82) v1(202.6,132.4) v1(202.68,136.62) v1(202.7,117.11) v1(202.69,115.53) v1(202.64,98.03) v1(202.67,38.8) v1(202.67,36.77) v1(202.77,102.97) v1(202.77,96.5) v1(202.87,148.76) v1(202.96,138.16) v1(203.05,3.87) v1(203.27,141.92) v1(203.29,139.95) v1(203.3,4.76) v1(203.8,143) v1(203.81,3.87) v1(203.94,167.32) v1(203.92,145.99) v1(203.85,144.4) v1(204.06,166.31) v1(204.06,165.42) v1(204.05,164.22) v1(204.19,4.76) v1(204.63,159.58) v1(204.57,3.87) v1(204.66,112.31) v1(204.75,167.31) v1(204.79,166.29) v1(204.79,165.3) v1(204.79,164.28) v1(204.95,4.76) v1(205.09,178.56) v1(205.12,177.22) v1(205.33,3.87) v1(205.71,4.76) v1(205.84,174.75) v1(205.95,177.22) v1(205.97,38.02) v1(206.09,3.87) v1(206.17,175.51) v1(206.22,41.85) v1(206.6,4.76) v1(206.98,177.2) v1(206.98,3.87) v1(207.48,127.17) v1(207.49,4.76) v1(207.63,138.33) v1(208.02,141.54) v1(208.29,150.76) v1(208.24,134.68) v1(208.37,148.32) v1(208.44,176.62) v1(208.48,147.07) v1(208.94,144.02) v1(210.87,176.63) v1(210.92,75.5) v1(210.92,73.77) v1(210.95,74.59) v1(211.06,150.67) v1(211.3,3.11) v1(211.42,85.33) v1(211.42,84.56) v1(211.43,9.08) v1(211.43,6.16) v1(211.68,72.07) v1(211.68,71.44) v1(211.78,75.5) v1(211.81,74.6) v1(211.81,73.77) v1(211.81,70.04) v1(212.11,85.34) v1(212.16,84.54) v1(212.28,9.12) v1(212.28,6.2) v1(212.28,3.15) v1(212.42,175.5) v1(212.42,174.87) v1(212.47,91.16) v1(212.7,176.59) v1(212.84,36.2) v1(213.05,175.5) v1(213.05,174.87) v1(213.47,36.2) v1(213.78,175.35) v1(213.83,173.29) v1(219.81,56.2) v1(220.45,56.2) v1(220.45,55.56) v1(221.08,56.2) v1(221.08,55.56) v1(222.74,32.97) v1(222.77,32.26) v1(222.77,31.62) v1(223.38,32.97) v1(223.4,32.26) v1(223.4,31.62) v1(224.01,32.97) v1(224.04,32.26) v1(224.04,31.62) v1(224.65,33.35) v1(224.65,32.72) v1(224.65,32.08) v1(224.65,31.45) v1(224.67,30.73) v1(225.28,33.35) v1(225.28,32.72) v1(225.28,32.08) v1(225.28,31.45) v1(225.31,30.73) v1(225.92,33.35) v1(225.92,32.72) v1(225.92,32.08) v1(225.92,31.45) v1(225.94,30.73) v1(226.55,33.35) v1(226.55,32.72) v1(227.19,33.35) v1(227.19,32.72) v1(230.34,52.26) v1(230.34,51.63) v1(230.27,50.23) v1(230.27,49.59) v1(230.78,43.05) v1(230.78,42.42) v1(230.92,45.12) v1(230.97,45.92) v1(231.7,45.93) v1(231.72,45.17) v1(234.71,74.24) v1(234.73,70.05) v1(236.83,72.2) v1(238.73,74.22) v1(238.87,70.14) v1(248.27,58.37) v1(248.27,57.7) v1(248.96,58.36) v1(248.97,57.68) v1(255.62,73.91) v1(255.75,75.2) v1(256.39,74.49) v1(257,75.2) v1(257.16,73.9) v1(259.69,72.2) v1(261.72,72.2) v1(262.1,74.49) v1(262.86,73.42) v1(268.13,75.25) v1(268.06,73.84) v1(268.83,74.49) v1(269.39,75.29) v1(269.51,73.81) v1(270.48,49.21) v1(270.61,48.45) v1(270.61,47.44) v1(270.61,46.55) v1(270.61,45.78) v1(271.25,48.45) v1(271.25,47.44) v1(271.25,46.55) v1(271.25,45.78) v1(271.5,49.85) v1(271.75,42.48) v1(271.88,48.45) v1(271.88,47.44) v1(271.88,46.55) v1(272.39,49.85) v1(272.9,47.85) v1(272.9,47.22) v1(272.9,46.55) v1(272.9,45.78) v1(272.9,45.02) v1(272.9,44.26) v1(273.66,47.85) v1(273.66,47.22) v1(273.66,46.55) v1(273.66,45.78) v1(273.66,45.02) v1(273.66,44.26) v1(273.79,51.12) v1(274.55,51.12) v1(274.89,72.25) v1(275.6,77.42) v1(275.69,54.17) v1(275.69,53.53) v1(275.82,51.12) v1(275.82,36.01) v1(275.82,35.24) v1(276.07,79.82) v1(276.07,54.93) v1(276.41,57.35) v1(276.45,51.12) v1(276.62,56.72) v1(276.58,36.01) v1(276.58,35.24) v1(277.24,86.61) v1(277.73,94.37) v1(277.67,93.45) v1(279.2,5.37) v1(279.25,4.61) v1(279.32,3.96) v1(279.51,92.96) v1(279.82,5.93) v1(280,3.32) v1(280.6,5.94) v1(280.67,3.32) v1(280.86,97.8) v1(281.33,5.21) v1(281.32,4.43) v1(281.34,3.67) v1(281.81,66.83) v1(282.29,72.94) v1(282.42,75.67) v1(282.76,79.44) v1(283.3,102.51) v1(283.61,9.26) v1(283.6,8.59) v1(283.69,74.33) v1(283.78,66.82) v1(283.83,5.94) v1(283.83,5.13) v1(283.83,3.61) v1(283.86,4.36) v1(284.14,104.33) v1(284.38,7.99) v1(284.4,7.16) v1(284.47,3.28) v1(284.61,79.38) v1(284.82,6.25) v1(284.9,75.6) v1(284.96,73) v1(285.19,3.29) v1(285.6,102.05) v1(285.7,6.07) v1(285.94,3.76) v1(285.98,99.04) v1(285.95,5.46) v1(285.95,4.61) v1(286.19,91.05) v1(286.24,90.39) v1(286.27,89.75) v1(286.27,89.12) v1(289.8,91.53) v1(290.05,79.96) v1(290.19,98.91) v1(290.19,98.27) v1(291.63,74.93) v1(291.86,71.83) v1(292.76,59.64) v1(292.76,58.89) v1(292.76,58.14) v4(12.55,141.29) v4(38.53,73.11) v4(39.05,130.11) v4(39.34,61.41) v4(45.95,52.39) v4(112.13,66.75) v4(117.7,73.6) v4(124.53,39.07) v4(126.59,42.48) v4(126.76,39.21) v5(18.99,117.32) v5(21,119.36) v5(21.01,118.34) v5(21.63,119.36) v5(31.66,108.92) v5(32.67,123.73) v5(65.32,65.92) v5(66.32,56.94) v5(67.33,65.91) v5(67.33,59.91) v5(68.4,65.85) v5(68.42,53.9) v5(69.39,65.85) v5(69.4,62.89) v5(69.39,59.88) v5(69.4,56.85) v5(69.4,53.88) v5(70.38,65.88) v5(70.38,62.88) v5(70.38,59.86) v5(70.38,56.89) v5(70.39,53.87) v5(71.38,65.84) v5(71.38,62.9) v5(71.38,59.85) v5(71.38,56.88) v5(72.39,65.88) v5(72.39,62.9) v5(72.39,59.87) v5(72.39,56.88) v5(73.39,65.88) v5(73.39,62.9) v5(73.39,59.86) v5(73.41,56.88) v5(75.39,76.97) v5(75.39,75.95) v5(75.39,74.98) v5(75.39,73.98) v5(75.39,72.98) v5(75.39,71.95) v5(75.39,70.95) v5(75.39,69.97) v5(75.39,68.93) v5(89.37,86.67) v5(89.8,87.15) v5(90.08,88.3) v5(90.1,87.69) v5(90.33,88.86) v5(90.98,88.88)
