# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP2-: length 119.6
  TOP w0.102: v3(32.43,28.78) 32.26,28.61 32.04,28.61 31.9,28.75 JIO1.57 ; UH4.C26 18.65,116.94 18.21,116.94 17.93,117.22 16.43,117.22 16.36,117.3 16.19,117.46 16.19,117.53 16.29,117.63 16.29,118.06 16.1,118.25 15.58,118.25 v1(15.47,118.36)
  IN3 w0.14: v1(10.45,75.71) 10.45,75.3 10.37,75.22 10.36,75.22 10.04,74.89 9.31,74.89 8.29,75.91 8.29,76.73 7.77,77.25 7.77,88.55 8.62,89.4 8.62,98.63 10.58,100.58 10.58,104.41 11.2,105.04 11.2,105.89 11.85,106.54 11.85,107.57 12.38,108.1 12.7,108.1 14.3,109.71 14.3,116.66 15.38,117.74 15.38,118.28 v1(15.47,118.36)
  BOTTOM w0.102: v1(10.45,75.71) 10.45,62.76 14.2,59.02 23.34,59.02 25.94,56.41 25.94,48.15 28.64,45.45 28.64,41.1 26.72,39.18 26.72,34.46 26.95,34.23 28.15,34.23 29.09,33.29 29.81,33.29 31.77,31.32 31.77,28.83 31.82,28.78 32.43,28.78 v3(32.43,28.78)
USBP3+: length 100.1
  TOP w0.102: UH4.H28 21.03,117.53 21.03,117.31 v5(21.04,117.3)
  IN1 w0.102: v5(21.04,117.3) 21.04,117.33 21.65,117.93 24.69,117.93 25.49,117.13 25.94,117.13 26.41,116.66 26.9,116.18 27.57,116.18 28.34,115.41 28.34,113.53 28.54,113.33 28.99,113.33 30.37,111.95 31.08,111.95 31.1,111.93 32.9,111.93 32.99,112.01 39.83,112.01 41.63,110.21 41.63,109.67
  IN1 w0.135: v1(100.17,123.89) 100.37,123.69 100.37,123.5 97.95,121.07 93.06,121.07 92,120.02 90.5,120.02 87.72,117.24 87.72,116.97 84.66,113.91 84.52,113.91 82.12,111.51 80,111.51 78.5,110 72.17,110 71.12,108.95 70.56,108.95 69.12,107.5 69.12,106.92 68.84,106.64 66.8,106.64 65.89,105.73 65.46,105.73 65.01,105.28 64.24,105.28 63.94,104.99 63.04,104.99 62.51,104.46 60.83,104.46 60.41,104.04 59.9,104.04 59.72,104.22 57.58,104.22 56.98,103.61 51.97,103.61 51.34,104.24 48.3,104.24 47.49,105.06 46.87,105.06 44.01,107.92 43.38,107.92 41.63,109.67
  BOTTOM w0.102: JDOCK1.72 100.24,125.65 100.42,125.47 100.42,124.13 v1(100.17,123.89)
USBP3-: length 100
  TOP w0.102: v5(21.68,117.33) 21.68,117.64 21.87,117.84 UH4.K28
  IN1 w0.102: 41.35,109.55 41.35,110.1 39.65,111.8 33.1,111.8 33.02,111.72 31.01,111.72 30.98,111.75 30.19,111.75 28.88,113.06 28.42,113.06 28.07,113.41 28.07,115.29 27.46,115.9 26.78,115.9 26.22,116.46 25.8,116.88 25.39,116.88 24.53,117.73 21.83,117.73 21.58,117.48 21.58,117.44 v5(21.68,117.33)
  IN1 w0.135: v3(100.81,123.89) 100.68,123.77 100.68,123.37 98.08,120.76 93.18,120.76 92.13,119.71 90.63,119.71 88.03,117.11 88.03,116.84 84.79,113.6 84.65,113.6 82.25,111.2 80.13,111.2 78.63,109.69 72.3,109.69 71.25,108.64 70.69,108.64 69.43,107.37 69.43,106.79 68.97,106.33 66.93,106.33 66.02,105.42 65.59,105.42 65.14,104.97 64.36,104.97 64.07,104.68 63.17,104.68 62.64,104.15 60.96,104.15 60.54,103.73 59.77,103.73 59.59,103.91 57.71,103.91 57.1,103.3 51.85,103.3 51.22,103.93 48.17,103.93 47.36,104.75 46.74,104.75 43.88,107.61 43.29,107.61 41.35,109.55
  BOTTOM w0.102: JDOCK1.74 100.74,125.65 100.63,125.54 100.63,124.06 v3(100.81,123.89)
USBP4+: length 112
  TOP w0.102: UH4.D28 19.43,117.64 v1(19.76,117.31)
  IN1 w0.102: v1(19.76,117.31) 19.84,117.38 19.84,117.5 19.68,117.66 19.35,117.66 18.95,118.06 18.95,118.62 19.28,118.95 19.34,118.95 28.89,118.95 29.16,118.68 33.3,118.68 33.89,118.08 33.89,115.18 34.14,114.93 40.06,114.93 40.46,114.53 40.46,112.19 42.23,110.42 42.23,110.29 42.77,109.74
  IN1 w0.135: 42.77,109.74 43.74,108.77 44.36,108.77 47.19,105.94 47.8,105.94 48.66,105.07 51.7,105.07 52.3,104.46 56.59,104.46 57.42,105.28 62.16,105.28 62.75,105.87 63.63,105.87 64.36,106.59 65.53,106.59 66.53,107.6 68.01,107.6 70.23,109.82 70.77,109.82 71.84,110.88 76.45,110.88 77.96,112.4 81.72,112.4 84.07,114.75 84.33,114.75 86.87,117.29 86.87,117.74 90.57,121.44 90.57,124.94 90.85,125.22 90.85,126.82 92.86,128.83 96.41,128.83 97.57,127.67 97.57,124.45 98.08,123.94 98.68,123.94 99,124.27 99,124.35 98.7,124.65 v3(98.7,124.65)
  BOTTOM w0.102: v3(98.7,124.65) 98.88,124.84 98.88,125.51 98.74,125.65 JDOCK1.66
USBP4-: length 112.1
  TOP w0.102: v1(20.4,117.31) 20.07,117.64 UH4.E28
  IN1 w0.102: v1(20.4,117.31) 20.11,117.59 20.11,117.62 19.8,117.93 19.47,117.93 19.22,118.18 19.22,118.5 19.47,118.75 25.06,118.75 25.09,118.71 28.74,118.71 29.04,118.41 33.18,118.41 33.62,117.97 33.62,115.12 34.01,114.73 39.87,114.73 40.18,114.41 40.18,112.08 41.95,110.31 41.95,110.17 42.48,109.64 42.48,109.62 42.54,109.55 42.54,109.53 42.55,109.52
  IN1 w0.135: 42.55,109.52 43.62,108.46 44.23,108.46 47.06,105.63 47.67,105.63 48.54,104.76 51.57,104.76 52.18,104.15 56.72,104.15 57.54,104.97 62.29,104.97 62.88,105.56 63.76,105.56 64.48,106.28 65.65,106.28 66.66,107.29 68.14,107.29 70.36,109.51 70.9,109.51 71.96,110.57 76.58,110.57 78.09,112.09 81.84,112.09 84.19,114.44 84.46,114.44 87.18,117.16 87.18,117.62 90.88,121.32 90.88,124.81 91.16,125.09 91.16,126.7 92.99,128.52 96.28,128.52 97.26,127.55 97.26,124.32 97.95,123.64 98.8,123.64 99.31,124.14 99.31,124.63 v1(99.33,124.65)
  BOTTOM w0.102: v1(99.33,124.65) 99.1,124.88 99.1,125.51 99.24,125.65 JDOCK1.68
USBP5+: length 147.3
  TOP w0.102: UH4.A28 17.86,117.97 17.77,118.06 16.8,118.06 16.7,117.96 v1(16.7,117.72)
  IN1 w0.102: v1(16.7,117.72) 16.7,118.57 16.43,118.83 16.4,118.83
  IN1 w0.135: v1(104.2,160.17) 104.19,160.16 103.53,160.16 103.37,160 103.11,160 102.5,159.39 101.17,159.39 99.55,157.76 99.55,155.18 93.21,148.84 80.81,148.84 80.43,149.22 76.47,149.22 75.41,150.28 72.33,150.28 70.68,151.94 68.69,151.94 66.74,153.89 49.22,153.89 44.77,149.43 39.9,149.43 37.96,151.37 33.88,151.37 33.45,150.94 32.68,150.94 32.18,150.44 22.18,150.44 19.6,147.87 19.6,145.99 19.1,145.49 17.59,145.49 14.77,142.67 13.9,142.67 13.3,142.07 13.3,138.58 12.6,137.88 12.3,137.88 10.57,136.16 10.57,134.46 8.94,132.82 8.94,131.95 9.51,131.38 9.51,129.76 8.17,128.42 8.17,126.24 9.09,125.32 10.13,125.32 10.75,124.7 10.75,124.09 10.95,123.89 10.95,121.23 11.5,120.68 13.34,120.68 13.72,120.29 13.72,119.73 14.62,118.83 16.4,118.83
  BOTTOM w0.102: v1(104.2,160.17) 104.43,159.94 104.84,159.94 105.29,159.49 105.29,158.54 105.94,157.89 106.79,157.89 107.15,158.25 JMINI1.38
USBP5-: length 147.2
  TOP w0.102: UH4.C28 18.71,117.79 18.26,117.79 17.99,117.53 17.44,117.53 17.33,117.63 v1(17.32,117.63)
  IN1 w0.102: v1(17.32,117.63) 17.32,117.86 17.2,117.98 17.02,117.98 16.98,118.02 16.98,118.68 16.55,119.11 16.54,119.11 16.52,119.13 16.43,119.13 16.42,119.14 16.4,119.14
  IN1 w0.135: v1(104.19,159.52) 104.19,159.55 103.89,159.85 103.66,159.85 103.5,159.69 103.24,159.69 102.63,159.08 101.3,159.08 99.86,157.63 99.86,155.05 93.34,148.53 80.68,148.53 80.3,148.91 76.34,148.91 75.28,149.97 72.2,149.97 70.55,151.63 68.56,151.63 66.61,153.58 49.35,153.58 44.9,149.12 39.77,149.12 37.83,151.06 34.01,151.06 33.58,150.63 32.8,150.63 32.31,150.13 22.31,150.13 19.91,147.74 19.91,145.86 19.23,145.18 17.72,145.18 14.9,142.36 14.03,142.36 13.61,141.94 13.61,138.46 12.73,137.57 12.43,137.57 10.88,136.03 10.88,134.33 9.25,132.69 9.25,132.08 9.82,131.5 9.82,129.63 8.48,128.3 8.48,126.37 9.22,125.63 10.26,125.63 11.06,124.83 11.06,124.22 11.26,124.02 11.26,121.36 11.63,120.99 13.47,120.99 14.03,120.42 14.03,119.86 14.75,119.14 16.4,119.14
  BOTTOM w0.102: JMINI1.36 107.07,157.45 106.84,157.67 105.85,157.67 105.08,158.45 105.08,159.4 104.75,159.73 104.39,159.73 v1(104.19,159.52)
USBP6+: length 124.5
  TOP w0.102: JIO1.65 31.89,26.35 32.07,26.53 32.4,26.53 v1(32.65,26.28) ; v1(16.32,119.61) 16.34,119.58 16.34,119.3 16.29,119.25 15.97,119.25 15.91,119.2 15.91,119.01 15.98,118.95 16.41,118.95 16.84,118.52 17.98,118.52 18.25,118.78 18.35,118.78 18.6,118.53 18.6,118.47 18.47,118.33 UH4.B29
  IN3 w0.102: 17.14,118.43 17.16,118.42 17.32,118.42 17.45,118.29 17.6,118.29 17.98,117.9 17.98,114.44 17.3,113.75 17.3,110.19 16.36,109.25
  IN3 w0.14: 17.14,118.43 16.29,119.29 16.29,119.58 v1(16.32,119.61) ; 16.36,109.25 15.52,108.41 14.57,108.41 14.07,107.91 14.07,103.54 13.43,102.89 13.43,101.87 12.99,101.44 12.9,101.44 12.05,100.58 12.05,99.89 10.27,98.11 10.27,95.61 9.73,95.07 9.73,86.63 9.82,86.54 9.82,84.81 9.22,84.21 9.22,77.41 9.69,76.94 v1(10.22,76.94)
  BOTTOM w0.102: v1(10.22,76.94) 10.03,76.75 9.54,76.75 9.1,76.31 v1(9.1,72.54) 9.1,62.41 13.84,57.67 23.24,57.67 24.95,55.96 24.95,46.32 26.62,44.65 26.62,40.86 24.8,39.04 24.8,34.8 26.35,33.25 27.67,33.25 28.22,32.7 28.22,30.53 30.86,27.89 30.86,27.01 31.37,26.51 32.42,26.51 v1(32.65,26.28)
USBP6-: length 124.6
  TOP w0.102: JIO1.63 32.05,26.95 32.26,26.75 32.48,26.75 32.49,26.76 v3(32.65,26.92) ; UH4.C29 18.81,118.33 18.49,118 18.18,118 17.88,118.3 16.75,118.3 16.32,118.73 15.89,118.73 15.7,118.92 15.7,119.6 v1(15.68,119.61)
  IN3 w0.102: 16.36,118.81 17,118.16 17.22,118.16 17.34,118.03 17.49,118.03 17.73,117.8 17.73,114.55 17.04,113.86 17.04,110.34 16.36,109.66
  IN3 w0.14: v1(10.13,76.26) 10.13,76.37 9.85,76.65 9.57,76.65 8.93,77.29 8.93,84.34 9.52,84.93 9.52,86.42 9.43,86.51 9.43,95.19 9.98,95.73 9.98,98.23 11.76,100.01 11.76,100.71 12.78,101.73 12.87,101.73 13.13,101.99 13.13,103.01 13.78,103.66 13.78,108.03 14.45,108.7 15.4,108.7 16.36,109.66 ; 16.36,118.81 15.87,119.29 15.87,119.42 v1(15.68,119.61)
  BOTTOM w0.102: v1(10.13,76.26) 10.07,76.26 9.8,76.53 9.63,76.53 9.32,76.23 9.32,72.82 9.33,72.81 9.33,72.28 9.32,72.26 9.32,62.5 13.93,57.89 23.33,57.89 25.17,56.05 25.17,46.41 26.83,44.74 26.83,40.77 25.02,38.95 25.02,34.89 26.44,33.47 27.76,33.47 28.43,32.79 28.43,30.62 31.08,27.98 31.08,27.1 31.46,26.72 32.45,26.72 v3(32.65,26.92)
USBP7+: length 248.4
  TOP w0.102: UH4.M28 23.63,117.47 v1(23.63,117.29) ; JUSH1.3 116.62,35.8 116.31,35.48 v1(116.31,34.95) 116.31,34.42 v1(116.55,34.18)
  IN3 w0.102: v1(23.63,117.29) 23.63,117.59 23.77,117.73 24.49,117.73 24.78,117.45 24.78,111.55 25.11,111.22 25.11,104.93 24.38,104.2 24.38,103.21 24.36,103.19
  IN3 w0.14: v1(108.62,15.54) 108.79,15.37 108.99,15.37 109.49,14.86 109.49,14.44 106.79,11.74 106.55,11.74 103.51,8.69 46.08,8.69 44.68,10.1 44.68,13.17 43.41,14.44 37.51,14.44 35.66,16.29 35.66,28.5 36.73,29.57 37.62,29.57 38.85,30.8 39.74,30.8 40.16,31.22 40.16,35.31 38.84,36.63 36.43,36.63 35.41,37.66 35.41,44.1 35.84,44.53 35.84,46.72 32.33,50.23 32.33,59.24 24.83,66.74 15.85,66.74 15.47,67.12 15.47,68.77 14.83,69.41 14.83,72.45 14.64,72.64 14.64,84.03 13.74,84.93 13.74,92.84 15.29,94.39 15.29,95.02 17.12,96.85 18.22,96.85 19.21,97.84 19.21,99.38 19.4,99.57 19.4,100.24 20.69,101.52 23.53,101.52 24.36,102.35 24.36,103.19
  IN4 w0.135: v1(108.62,15.54) 108.73,15.42 108.86,15.42 109.07,15.64 109.07,15.86 108.31,16.62 108.31,20.5 108.86,21.05 108.86,25.31 110.77,27.23 118.23,27.23 119.14,28.14 119.14,29.85 119.88,30.59 119.88,31.64 119.49,32.03 118.02,32.03 117.53,32.52 117.53,33.53 116.89,34.18 v1(116.55,34.18)
USBP7-: length 248.4
  TOP w0.102: JUSH1.2 119.98,36.3 119.23,35.55 v1(119.23,34.37) ; v1(23.62,118.34) 23.95,118 UH4.N28
  IN3 w0.102: 24.65,103.19 24.65,103.21 24.63,103.23 24.63,104.1 25.32,104.79 25.32,111.32 25.03,111.61 25.03,117.55 24.65,117.93 24.03,117.93 v1(23.62,118.34)
  IN3 w0.14: v3(108.62,14.9) 108.79,15.08 108.87,15.08 109.2,14.74 109.2,14.56 106.67,12.03 106.43,12.03 103.38,8.98 46.21,8.98 44.97,10.22 44.97,13.29 43.53,14.73 37.63,14.73 35.95,16.41 35.95,28.38 36.85,29.27 37.74,29.27 38.97,30.51 39.86,30.51 40.45,31.1 40.45,35.43 38.96,36.92 36.56,36.92 35.7,37.78 35.7,43.98 36.13,44.41 36.13,46.84 32.62,50.35 32.62,59.36 24.95,67.03 15.97,67.03 15.76,67.24 15.76,68.89 15.12,69.53 15.12,72.58 14.93,72.77 14.93,84.15 14.03,85.05 14.03,92.72 15.58,94.27 15.58,94.9 17.24,96.56 18.34,96.56 19.51,97.72 19.51,99.26 19.69,99.45 19.69,100.11 20.81,101.23 23.65,101.23 24.65,102.23 24.65,103.19
  IN4 w0.135: v3(108.62,14.9) 108.62,14.91 108.82,15.11 108.99,15.11 109.38,15.51 109.38,15.99 108.62,16.75 108.62,20.37 109.17,20.92 109.17,25.18 110.9,26.92 118.36,26.92 119.45,28.01 119.45,29.72 120.19,30.46 120.19,31.77 119.62,32.34 118.15,32.34 117.84,32.65 117.84,33.82 118.39,34.37 v1(119.23,34.37)
USBP8+: length 206.4
  TOP w0.102: v1(21.69,118.34) 21.69,118.37 21.97,118.65 UH4.K30
  IN4 w0.102: v1(21.69,118.34) 22.31,117.72 24.69,117.72 25.06,118.09 25.06,118.49 25.44,118.87 33.29,118.87 33.79,119.38 33.79,121.3 34.72,122.23 34.72,123.55 34.08,124.19 34.08,125.55 37.55,129.02 41.71,129.02 42.04,129.35
  IN4 w0.135: 42.04,129.35 42.04,131.17 45.25,134.38 46.05,134.38 46.47,134.79 54.05,134.79 54.79,135.53 60.52,135.53 62.76,133.29 65.68,133.29 65.88,133.09 67.23,133.09 67.44,132.88 67.44,132.36 66.68,131.6 66.68,129.93 66.95,129.66 66.95,121.91 67.58,121.27 67.58,117.61 70.21,114.98 70.21,113.56 70.88,112.88 71.45,112.88 72.95,111.39 78.29,111.39 78.7,110.98 90.29,110.98 92.57,108.7 102.99,108.7 104.08,107.61 123.32,107.61 123.8,107.13 130.38,107.13 132.39,105.11 155.56,105.11 155.84,104.83 159.66,104.83 160.76,103.73 163.51,103.73 164.76,102.48 168.33,102.48 169.58,103.73 174.84,103.73 180.78,97.79 184.26,97.79 184.64,97.41 184.64,96.85 v1(184.52,96.74)
  BOTTOM w0.102: v1(184.52,96.74) 184.73,96.95 184.73,97.1 184.29,97.55 JMINI2.38
USBP8-: length 206.3
  TOP w0.102: v1(22.33,118.34) 22.33,118.45 22.61,118.74 UH4.L30
  IN4 w0.102: v1(22.33,118.34) 22.33,118.15 22.54,117.93 24.51,117.93 24.78,118.2 24.78,118.61 25.32,119.15 33.17,119.15 33.52,119.5 33.52,121.41 34.44,122.34 34.44,123.44 33.81,124.08 33.81,125.66 37.44,129.3 41.55,129.3 41.6,129.35
  IN4 w0.135: 41.6,129.35 41.73,129.48 41.73,131.3 45.12,134.69 45.93,134.69 46.34,135.1 53.92,135.1 54.66,135.84 60.65,135.84 62.89,133.6 65.81,133.6 66.01,133.4 67.36,133.4 67.75,133.01 67.75,132.23 66.99,131.47 66.99,130.06 67.26,129.79 67.26,122.03 67.89,121.4 67.89,117.74 70.52,115.11 70.52,113.68 71.01,113.19 71.58,113.19 73.07,111.7 78.42,111.7 78.83,111.29 90.42,111.29 92.7,109.01 103.11,109.01 104.2,107.92 123.45,107.92 123.93,107.44 130.5,107.44 132.52,105.42 155.69,105.42 155.97,105.14 159.78,105.14 160.89,104.04 163.64,104.04 164.89,102.79 168.2,102.79 169.45,104.04 174.97,104.04 180.91,98.1 184.39,98.1 184.95,97.54 184.95,96.95 v3(185.16,96.74)
  BOTTOM w0.102: JMINI2.36 185.09,97.56 184.95,97.42 184.95,96.95 v3(185.16,96.74)
USBP9+: length 53.4
  TOP w0.102: R736.1 10.26,158.94 L51.1 10.18,158.36 10.04,158.23 9.78,158.23 9.68,158.13 9.68,157.86 9.84,157.7 9.84,156.36 10.11,156.1 10.22,156.1 v3(10.49,156.36) ; v1(19.66,118.34) 20.07,118.75 UH4.E30
  IN1 w0.135: v1(12.22,145.89) 12.3,145.97 12.65,145.97 13.03,146.36 13.03,147.4 12.84,147.59 12.84,153.44 11.94,154.35 11.94,155.13 11.42,155.66 11.25,155.66 10.8,156.1 10.75,156.1 v3(10.49,156.36)
  IN3 w0.102: 17.44,129.35 17.44,127.79 16.36,126.72 ; v1(19.66,118.34) 19.66,118.47 19.48,118.64 18.66,118.64 18.16,119.15 18.16,120.15 17.4,120.91 16.36,120.91
  IN3 w0.14: 16.36,120.91 16.28,120.91 15.56,121.63 14.53,121.63 14.4,121.76 13.92,122.24 13.92,122.48 13.92,124.9 14.9,125.89 14.99,125.97 15.61,125.97 16.36,126.72 ; 17.44,129.35 17.44,130.65 16.96,131.13 16.39,131.13 15.35,132.16 15.03,132.16 14.23,132.96 14.23,136.23 13.3,137.16 13.3,144.58 12.41,145.47 12.41,145.71 v1(12.22,145.89)
USBP9-: length 53.3
  TOP w0.102: v1(10.49,155.73) 10.34,155.88 10.02,155.88 9.63,156.27 9.63,157.61 9.46,157.77 9.46,158.72 L51.4 9.24,158.94 R742.1 ; v3(20.3,118.34) 20.7,118.75 UH4.G30
  IN1 w0.135: v1(12.22,146.53) 12.22,146.52 12.46,146.28 12.52,146.28 12.72,146.48 12.72,147.27 12.53,147.46 12.53,153.31 11.63,154.22 11.63,155 11.29,155.35 11.12,155.35 10.67,155.79 10.55,155.79 v1(10.49,155.73)
  IN3 w0.102: 17.73,129.35 17.73,127.67 16.36,126.3 ; 17.37,121.2 17.47,121.2 18.41,120.26 18.41,119.25 18.77,118.9 19.68,118.9 20.24,118.34 v3(20.3,118.34)
  IN3 w0.14: v1(12.22,146.53) 12.23,146.53 12.7,146.06 12.7,145.59 13.59,144.7 13.59,137.28 14.52,136.35 14.52,133.08 15.15,132.46 15.47,132.46 16.51,131.42 17.08,131.42 17.73,130.77 17.73,129.35 ; 16.36,126.3 15.73,125.68 15.11,125.68 14.21,124.78 14.21,122.36 14.61,121.96 14.65,121.92 15.71,121.92 16.43,121.2 17.37,121.2
USBP9_D+: length 23.2
  TOP w0.102: R736.2 10.18,160.39 L51.2 10.18,160.8 9.86,161.12 9.86,162.5 9.96,162.6 D73.3 10.72,163.03 11.25,163.56 11.25,164.68 11.12,164.81 10.79,164.81 10.67,164.68 10.67,164.41 v1(10.65,164.41)
  IN3 w0.14: JESA1.3 10.69,170.97 11.06,171.34 11.06,171.91 10.62,172.35 7.44,172.35 6.27,171.18 6.27,169.16 9.5,165.94 9.5,164.55 9.92,164.14 10.44,164.14 10.65,164.35 v1(10.65,164.41)
USBP9_D-: length 23.3
  TOP w0.102: v3(10.68,163.75) 10.6,163.68 9.59,163.68 8.79,162.88 D73.2 9.54,162.6 9.64,162.5 9.64,161.12 9.33,160.8 L51.3 9.33,160.39 R742.2
  IN3 w0.14: v3(10.68,163.75) 10.59,163.84 9.8,163.84 9.21,164.43 9.21,165.82 5.98,169.04 5.98,171.3 7.32,172.64 10.74,172.64 11.35,172.03 11.35,171.61 JESA1.2
USBP10+: length 117.3
  TOP w0.102: v1(37.8,32.79) 37.58,33.01 37.24,33.01 37.18,32.95 JIO1.44 ; v3(16.95,119.38) 16.91,119.34 16.91,119 17.09,118.83 UH4.A30
  IN3 w0.102: v3(16.95,119.38) 16.99,119.34 16.99,118.91 17.27,118.63 17.39,118.63 17.51,118.52 17.94,118.52 18.25,118.21 18.25,113.62 17.89,113.26 17.89,109.96 16.81,108.88
  IN3 w0.14: v1(37.8,32.79) 37.76,32.83 31.72,32.83 31.13,33.43 31.13,47.02 30.05,48.1 30.05,57.88 23.62,64.31 11.8,64.31 10.6,65.51 10.6,74.69 10.77,74.86 10.85,74.95 10.94,75.04 12.17,76.26 12.17,82.68 11.31,83.53 11.31,92.37 10.27,93.41 10.27,94.81 10.91,95.45 10.91,96.38 12.36,97.83 12.36,99.29 12.67,99.61 12.67,100.46 13.14,100.93 13.52,100.93 14.11,101.52 14.11,102.78 16.73,105.41 16.73,108.8 16.81,108.88
USBP10-: length 117.3
  TOP w0.102: v3(37.81,33.43) 37.81,33.41 37.69,33.29 37.36,33.29 37.1,33.55 JIO1.42 ; UH4.C30 18.58,119 18.15,119 17.78,119.37 v1(17.59,119.37)
  IN3 w0.102: 17.03,108.71 17.08,108.77 17.08,108.79 18.15,109.86 18.15,113.16 18.5,113.51 18.5,118.31 18.05,118.77 17.61,118.77 17.5,118.89 17.38,118.89 17.25,119.02 17.25,119.09 17.52,119.37 v1(17.59,119.37)
  IN3 w0.14: 17.03,108.71 17.03,105.29 14.4,102.66 14.4,101.4 13.64,100.64 13.26,100.64 12.97,100.34 12.97,99.49 12.65,99.17 12.65,97.71 11.2,96.26 11.2,95.33 10.56,94.69 10.56,93.54 11.61,92.49 11.61,83.66 12.46,82.8 12.46,76.14 11.14,74.83 11.14,74.83 11.06,74.74 10.97,74.66 10.89,74.57 10.89,65.63 11.92,64.6 23.74,64.6 30.34,58 30.34,48.22 31.42,47.14 31.42,33.55 31.84,33.12 37.36,33.12 37.44,33.2 37.44,33.41 37.53,33.5 37.75,33.5 37.81,33.44 v3(37.81,33.43)
USBP11+: length 334.8
  TOP w0.102: JBT1.12 291.56,105.49 291.64,105.41 291.91,105.41 292,105.32 292,103.11 291.2,102.31 286.95,102.31 286.11,101.47 283.61,101.47 v3(283.27,101.81) ; UH4.K32 21.97,119.67 22.29,119.36 v1(22.3,119.36)
  IN4 w0.102: v1(22.3,119.36) 22.35,119.41 22.35,119.8 22.63,120.08 24.47,120.08 25.11,120.71 27.16,120.71 27.9,119.98 29.1,119.98 30.36,121.24 31.79,121.24 32.97,122.43 32.97,123.37 33.06,123.46 33.06,124.87 33.12,124.93 33.12,126.87 34.12,127.87 34.77,127.87 34.79,127.89
  IN4 w0.135: 34.79,127.89 37.11,130.21 38.68,130.21 39.49,131.02 39.49,131.75 42.89,135.14 44.04,135.14 46.29,137.4 55.64,137.4 56.37,136.67 61.13,136.67 62.23,135.57 63.35,135.57 63.76,135.16 63.76,134.7 64.02,134.44 64.71,134.44 64.89,134.62 67.35,134.62 68.58,133.39 68.58,131.85 67.82,131.08 67.82,130.45 68.09,130.18 68.09,122.4 68.87,121.62 68.87,117.99 72.01,114.85 72.01,113.93 73.42,112.52 78.88,112.52 79.29,112.12 90.85,112.12 93.13,109.84 103.46,109.84 104.55,108.75 130.52,108.75 133,106.26 156.32,106.26 156.57,106.01 160.76,106.01 161.9,104.86 175.35,104.86 176.57,103.65 177.13,103.65 177.87,102.9 177.87,102.54 179.21,101.21 179.79,101.21 180.57,101.98 182.36,101.98 182.59,101.75 195.43,101.75 196.02,102.34 199.14,102.34 199.66,102.87 201.41,102.87 202.36,103.82 205.39,103.82 206.75,102.46 214.86,102.46 218.53,98.79 218.53,98.52 228.16,88.89 228.89,88.89 231.19,86.59 232.62,86.59 233.06,86.14 233.39,86.14 234.26,85.27 234.89,85.27 235.79,84.37 237.57,84.37 238.77,83.17 240.81,83.17 241.1,82.89 242.96,82.89 243.39,82.45 247.27,82.45 247.41,82.31 271.42,82.31 281.5,92.39 281.5,93.23 282.19,93.92 282.19,101.15 282.77,101.73 283.19,101.73 v3(283.27,101.81)
USBP11-: length 334.8
  TOP w0.102: v1(22.99,119.37) 22.92,119.37 22.61,119.68 UH4.L32 ; JBT1.11 292.56,105.58 292.21,105.23 292.21,103.02 291.29,102.1 287.06,102.1 v1(286.66,101.7) 286.22,101.26 283.35,101.26 v1(283.27,101.18)
  IN4 w0.102: v1(22.99,119.37) 22.79,119.37 22.71,119.45 22.71,119.54 22.59,119.66 22.59,119.72 22.67,119.8 24.59,119.8 25.22,120.44 27.05,120.44 27.79,119.7 29.21,119.7 30.48,120.97 31.9,120.97 33.25,122.31 33.25,123.25 33.34,123.34 33.34,124.75 33.4,124.82 33.4,126.76 34.24,127.6 34.94,127.6
  IN4 w0.135: v1(283.27,101.18) 283.27,101.19 283.05,101.42 282.9,101.42 282.5,101.02 282.5,93.79 281.81,93.1 281.81,92.27 271.55,82 247.28,82 247.14,82.14 243.26,82.14 242.83,82.58 240.97,82.58 240.68,82.86 238.64,82.86 237.44,84.06 235.66,84.06 234.76,84.96 234.13,84.96 233.26,85.83 232.93,85.83 232.49,86.28 231.06,86.28 228.76,88.58 228.03,88.58 218.22,98.39 218.22,98.67 214.73,102.15 206.62,102.15 205.26,103.51 202.49,103.51 201.54,102.56 199.79,102.56 199.27,102.03 196.15,102.03 195.56,101.44 182.46,101.44 182.23,101.67 180.7,101.67 179.92,100.9 179.08,100.9 177.56,102.42 177.56,102.77 177,103.34 176.44,103.34 175.22,104.55 161.77,104.55 160.63,105.7 156.44,105.7 156.19,105.95 132.87,105.95 130.39,108.44 104.42,108.44 103.33,109.53 93,109.53 90.72,111.81 79.16,111.81 78.76,112.21 73.29,112.21 71.7,113.8 71.7,114.72 68.56,117.86 68.56,121.49 67.78,122.27 67.78,130.05 67.51,130.33 67.51,131.21 68.27,131.97 68.27,133.26 67.22,134.31 65.02,134.31 64.84,134.13 63.89,134.13 63.45,134.57 63.45,135.03 63.23,135.26 62.11,135.26 61.01,136.36 56.24,136.36 55.51,137.09 46.42,137.09 44.17,134.83 43.02,134.83 39.8,131.62 39.8,130.89 38.81,129.9 37.24,129.9 34.94,127.6
USBP12+: length 27.4
  TOP w0.102: v5(19.73,119.36) 19.73,119.42 20.07,119.76 UH4.E32 ; v3(18.03,138.11) 17.78,137.86 17.4,137.86 L10.4 17.02,138.24 R428.1
  IN3 w0.102: 19.49,129.35 19.49,128.88 17.35,126.73 17.35,125.17 18.26,124.26 18.26,120.96 18.88,120.35 19.58,120.35 19.72,120.2 19.72,119.37 v5(19.73,119.36)
  IN3 w0.14: v3(18.03,138.11) 18.03,138.11 18.01,138.13 17.37,138.13 16.55,137.31 16.44,137.31 16.01,136.87 16.01,136.26 16.34,135.92 16.34,135.3 15.44,134.4 15.44,133.73 17.23,131.94 17.3,131.94 17.79,131.45 19.13,131.45 19.49,131.08 19.49,129.35
USBP12-: length 27.2
  TOP w0.102: R427.1 17.02,137.22 L10.1 17.39,137.59 17.9,137.59 v1(18.03,137.47) ; UH4.G32 20.7,119.7 v5(20.36,119.36)
  IN3 w0.102: v5(20.36,119.36) 20.27,119.36 20.08,119.55 20.08,119.71 19.98,119.81 19.98,120.31 19.68,120.6 18.98,120.6 18.52,121.07 18.52,124.36 17.6,125.28 17.6,126.62 19.79,128.8 19.79,129.35
  IN3 w0.14: v1(18.03,137.47) 18.02,137.47 17.66,137.83 17.49,137.83 16.67,137.01 16.56,137.01 16.3,136.75 16.3,136.38 16.64,136.04 16.64,135.18 15.73,134.28 15.73,133.85 17.35,132.23 17.42,132.23 17.91,131.74 19.25,131.74 19.79,131.2 19.79,129.35
USBP12_D+: length 14.4
  TOP w0.102: R428.2 15.69,138.24 L10.3 15.21,138.13 14.95,137.87 14.82,137.87 13.99,137.05 12.57,137.05 11.81,137.81 11.48,137.81 11.25,138.03 D87.2 10.43,137.87 10.07,137.87 9.51,137.31 v1(9.51,136.31) 9.51,134.18 9.1,133.77 8.34,133.77 7.91,134.2 JCAM1.19
USBP12_D-: length 14.4
  TOP w0.102: R427.2 15.69,137.22 L10.2 15.19,137.33 15.07,137.45 15.07,137.58 15,137.66 14.91,137.66 14.08,136.83 12.48,136.83 11.72,137.59 11.51,137.59 11.25,137.33 D87.3 10.36,137.66 10.16,137.66 9.73,137.22 9.73,136.6 9.74,136.59 9.74,136.04 9.73,136.03 9.73,134.09 9.18,133.54 v1(8.85,133.54) 8.44,133.54 8.1,133.2 JCAM1.17
USBP13+: length 19.2
  TOP w0.102: v1(16.78,120.23) 16.7,120.15 16.7,119.94 16.83,119.81 17.86,119.81 UH4.A32 ; R430.1 6.4,117.14 L11.1 7.1,117.14 7.2,117.23 7.2,117.53 7.24,117.56 7.3,117.56 7.78,117.08 8.9,117.08 8.99,116.99 8.99,116.97 8.67,116.65 v3(8.62,116.65)
  IN1 w0.102: 16.36,117.32 16.5,117.32 16.66,117.15 17.7,117.15 17.99,117.45 17.99,119.59 17.78,119.8 17.21,119.8 v1(16.78,120.23)
  IN1 w0.135: 16.36,117.32 14.63,117.32 14.15,117.79 11.24,117.79 10.89,117.43 10.01,117.43 9.63,117.06 9.03,117.06 v3(8.62,116.65)
USBP13-: length 19.1
  TOP w0.102: v1(9.26,116.6) 9.26,116.7 9.21,116.75 9.21,117.08 8.99,117.3 7.9,117.3 v1(7.67,117.53) 7.4,117.79 7.09,117.79 6.94,117.94 L11.4 6.4,117.94 R429.1 ; UH4.C32 18.32,119.82 17.99,120.14 17.52,120.14 17.42,120.23 v1(17.42,120.23)
  IN1 w0.102: v1(17.42,120.23) 17.42,120.23 17.58,120.08 17.9,120.08 18.24,119.74 18.24,117.3 17.81,116.87 16.55,116.87 16.42,117.01 16.36,117.01
  IN1 w0.135: v1(9.26,116.6) 9.26,116.45 9.38,116.32 9.66,116.32 9.75,116.41 9.75,116.74 10.14,117.12 11.01,117.12 11.37,117.48 14.02,117.48 14.5,117.01 16.36,117.01
USBP13_D+: length 13.2
  TOP w0.102: R430.2 5.23,117.14 L11.2 4.77,117.41 4.42,117.41 v1(4.01,117.82) 3.86,117.97 3.86,118.57 4.29,119 4.29,119.19 3.71,119.77 D86.2 3.99,120.08 4.55,120.08 4.61,120.14 4.61,120.59 5.36,121.34 5.36,123.1 5.05,123.41 5.05,125.39 5.7,126.04 6.17,126.04 6.34,126.2 JCAM1.3
USBP13_D-: length 13.2
  TOP w0.102: R429.2 5.23,117.94 L11.3 4.73,117.63 4.53,117.63 4.08,118.08 4.08,118.48 4.9,119.3 5.14,119.3 D86.3 5.36,120.08 4.93,120.08 4.84,120.17 4.84,120.51 5.57,121.25 5.57,123.19 5.27,123.5 5.27,125.3 5.79,125.82 6.07,125.82 6.2,125.69 6.2,125.31 6.31,125.2 JCAM1.1
USBRBIAS: length 5.5
  TOP w0.102: UH4.C33 UH4.B33 18.12,120.5 17.73,120.5 17.55,120.68 16.6,120.68 16.57,120.65 15.91,120.65 v2(15.37,120.1) 15.34,120.08 14.59,120.08 14.35,119.84 RH151.1
USH_DET#: length 408.6
  TOP w0.102: RH164.2 15.15,127.57 v1(15.37,127.35) 15.62,127.1 15.62,125.68 16.37,124.93 17.36,124.93 17.4,124.89 17.74,124.89 UH4.A42 ; JUSH1.20 120.11,27.3 119.54,26.73 119.54,23.88 121.23,22.2 121.23,19.44 122.53,18.14 122.53,16.71 121.31,15.49 121.31,13.39 121.64,13.06 121.64,12.73 121.98,12.38 122.43,12.38 123.3,11.51 126.35,11.51 127.15,10.71 132.85,10.71 133.97,11.82 144.96,11.82 145.76,11.02 154.77,11.02 155.22,11.47 175.5,11.47 v1(176.49,12.46)
  IN1 w0.109: v1(178,88.51) 177.46,87.97 177.46,83.79 179.67,81.59 179.67,75.73 181.38,74.02 181.38,69.3 179.55,67.48 179.55,63.79 177.33,61.57 177.33,54.22 178.14,53.41 178.14,51.38 166.3,39.55 166.3,25.73 176.26,15.77 176.26,12.69 v1(176.49,12.46)
  IN2 w0.127: v1(194.56,91.86) 194.58,91.87 194.58,92.45 190.21,96.82 190.21,97.83 188.15,99.89 188.15,102.15 182.31,107.99 182.31,110.89 181.7,111.5 181.7,111.79 176.18,117.31 176.17,117.31 175.42,118.06 175.42,122.24 169.24,128.42 159.04,128.42 158.37,129.09 156.68,129.09 151.79,133.99 138.14,133.99 137.35,133.2 132.71,133.2 132.01,132.5 114.23,132.5 113.59,131.85 107.4,131.85 106.2,133.06 85.09,133.06 83.88,134.26 80.97,134.26 80.64,133.93 74.78,133.93 72.67,136.04 70.76,136.04 70.35,136.46 70.21,136.46 68.17,138.49 65.17,138.49 64.73,138.94 61.36,138.94 60.96,138.54 60.83,138.4 54.94,138.4 54.79,138.25 47.51,138.25 45.87,136.61 43.96,136.61 42.85,135.5 36.57,135.5 35.93,136.14 33.65,136.14 31.96,137.83 28.74,137.83 28.32,138.25 27.63,138.25 26.79,139.09 25.92,139.09 25.56,139.45 24.39,139.45 24.25,139.31 22.26,139.31 22.24,139.29 22.18,139.29 22.17,139.28 22.16,139.28 20.78,137.9 20.78,137.9 20.78,137.66 19.44,136.32 17.68,136.32 17.27,135.92 17.09,135.92 16.94,135.76 16.94,133.64 16.78,133.48 16.78,132.42 16.37,132.02 16.37,130.82 15.95,130.4 15.95,127.81 15.49,127.35 v1(15.37,127.35)
  IN3 w0.127: v1(194.56,91.86) 193.76,92.66 185.04,92.66 184.62,92.25 181.75,92.25 v1(178,88.51)
  BOTTOM w0.102: v2(177.34,11.65) 177.3,11.65 v1(176.49,12.46)
USH_PWR_ON: length 1.4
  BOTTOM w0.102: U46.A18 230.39,68.95 T117.1
USH_PWR_STATE#: length 185.1
  TOP w0.102: v1(125.27,17.21) 125.37,17.3 125.37,17.84 125.53,18.01 125.53,19.19 124.76,19.96 124.76,21.34 122.71,23.39 122.71,26.31 122.35,26.67 122.35,28.26 121.31,29.3 JUSH1.16
  IN3 w0.127: v1(233.35,78.37) 233.35,77.1 232.34,76.1 232.34,74.07 233.59,72.82 233.86,72.82 234.28,72.41 234.28,68.09 233.5,67.32 229.82,67.32 228.14,65.65 205.87,65.65 202.98,62.76 202.47,62.76 199.91,60.2 191.74,60.2 189.98,58.43 186.04,58.43 183.86,56.25 183.86,55.36 183.58,55.08 175.55,55.08 162.49,42.02 162.49,20.78 157.8,16.08 157.8,13.28 157.06,12.55 128.17,12.55 126.88,13.83 123.63,13.83 123.25,13.45 v1(123.25,12.73)
  BOTTOM w0.102: R102.2 232.64,79.05 233.31,78.37 v1(233.35,78.37) 233.58,78.14 U46.A34 ; v1(125.27,17.21) 125.4,17.08 125.4,13.22 v2(124.48,12.31) 123.61,12.31 123.25,12.66 v1(123.25,12.73)
USH_SMBCLK: length 220.2
  TOP w0.102: U54.A50 169.97,152.91 170.5,153.43 170.5,153.81 R589.2 ; v1(186.54,96.28) 186.54,97.93 185.6,98.87 185.6,101.12 184.97,101.74 182.67,101.74 182.23,102.18 182.23,102.76 182.92,103.44 183.7,103.44 184.16,103.9 184.16,104.53 183.45,105.25 183.45,111.63 183.62,111.8 183.62,112.99 183.18,113.42 181.65,113.42 179.53,115.55 179.53,128.83 179.94,129.25 179.94,135.52 v1(179.54,135.93) ; v1(118.91,33.41) 118.91,33.93 118.74,34.1 118.74,34.67 118.61,34.8 JUSH1.5
  TOP w0.127: v1(170.93,153.95) 170.6,154.28 R589.2
  IN1 w0.109: v1(170.93,153.95) 170.89,153.95 170.66,153.72 170.66,152.72 171.41,151.97 175.18,151.97 175.71,151.44 175.71,148.87 177.6,146.98 177.6,146.58 179.11,145.06 179.11,139.84 178.99,139.72 178.99,137.33 179.36,136.96 179.36,136.11 v1(179.54,135.93)
  IN3 w0.127: v1(186.54,96.28) 186.28,96.28 185.8,95.8 185.8,95.64 185.29,95.13 178.72,95.13 178.13,95.72 177.65,95.72 176.09,97.27 170.36,97.27 170.22,97.41 159.92,97.41 159.57,97.07 152.07,97.07 151.72,97.41 144.52,97.41 138.96,91.86 130.28,91.86 127.56,94.58 116.51,94.58 115.89,95.2 v1(115.89,95.35)
  BOTTOM w0.102: v1(115.89,95.35) 116.01,95.23 v2(116.01,94.67) 116.01,80.87 120.27,76.62 120.27,65.04 118.69,63.46 118.69,57.98 118.88,57.79 118.88,56.12 122.01,52.99 122.01,36.47 119.24,33.71 119.2,33.71 v1(118.91,33.41)
USH_SMBDAT: length 216.3
  TOP w0.102: U54.B53 170.22,151.44 169.94,151.16 v1(169.94,150.86) ; v1(178.9,135.93) 179.69,135.14 179.69,129.35 179.27,128.93 179.27,115.44 181.54,113.17 183.08,113.17 183.36,112.89 183.36,111.9 183.2,111.74 183.2,105.14 183.91,104.43 183.91,104 183.6,103.7 182.81,103.7 181.98,102.86 181.98,102.07 182.56,101.49 184.87,101.49 185.34,101.01 185.34,98.69 186.19,97.84 186.19,96.86 v1(186.08,96.75) ; v1(119.62,33.41) 120.51,34.3 JUSH1.6
  IN1 w0.109: v1(178.9,135.93) 179.11,136.13 179.11,136.85 178.75,137.21 178.75,139.81 178.86,139.92 178.86,144.96 177.34,146.48 177.34,146.88 175.46,148.76 175.46,148.79 175.41,148.84 175.41,151.38 175.06,151.74 171.25,151.74 170.87,152.12 170.69,152.12 170.03,151.46 170.03,150.95 v1(169.94,150.86)
  IN3 w0.127: v1(116.72,95.29) 117.04,94.97 127.8,94.97 130.48,92.29 139.03,92.29 144.41,97.67 151.83,97.67 152.17,97.32 159.47,97.32 159.82,97.67 170.32,97.67 170.47,97.52 176.2,97.52 177.75,95.97 178.23,95.97 178.82,95.38 185.18,95.38 185.55,95.75 185.55,95.95 186.08,96.48 v1(186.08,96.75)
  BOTTOM w0.102: v1(116.72,95.29) 116.51,95.07 v2(116.51,92.79) 116.51,80.98 120.62,76.86 120.62,64.96 118.95,63.28 118.95,58.08 119.14,57.89 119.14,56.22 122.26,53.1 122.26,36.16 119.62,33.52 v1(119.62,33.41) ; v1(169.94,150.86) 169.94,151.58 R585.2
VAXG_VAL_SENSE: length 16.5
  TOP w0.254: v1(70.38,69.89) 69.95,69.45 JCPU1.AJ31
  BOTTOM w0.254: v1(70.38,69.89) 70.38,69.87 69.84,69.32 68.24,69.32 67.73,69.83 v2(67.07,69.83) 66.3,69.83 60.64,75.49 59.68,75.49 RC55.1 59.01,74.92 RC54.2
VCI_IN1#: length 3
  TOP w0.102: U54.A63 163.47,153.46 R1156.1 v2(161.66,154.28)
VCP2: length 4.4
  TOP w0.254: U18.45 136.99,158.58 v2(136.66,158.26) 135.95,157.54 R388.1
VFB:
  vias: v2(180.2,28.61)
VGA_ID: length 7.7
  IN4 w0.109: v1(240.64,72.4) 240.94,72.7 242.95,72.7 243.58,73.33 243.83,73.33 v1(243.85,73.3)
  BOTTOM w0.102: U46.B59 241.21,72.7 241.06,72.55 240.79,72.55 v1(240.64,72.4) ; R800.2 R803.1 244.46,72.45 244.14,72.77 244.14,73.13 243.97,73.3 v1(243.85,73.3) 243.85,73.55 v2(243.51,73.89)
VIDALERT_N: length 72.3
  TOP w0.102: v1(47.17,94.41) 47.17,94.62 47.57,95.02 v2(48,95.02) 48.32,95.02 48.39,94.96 50.85,94.96 51.85,93.96 55.27,93.96 57.22,92 59.57,92 62.42,89.15 62.42,85.01 62.81,84.62 RC63.2 62.81,83.95 62.84,83.91 RC64.2 ; PR725.1 v1(20.55,78.04)
  IN3 w0.127: v1(47.17,94.41) 47.17,94.49 46.56,95.1 45.83,95.1 44.14,93.41 36.67,93.41 34.99,95.1 33.94,95.1 32.56,96.48 30.28,96.48 30.12,96.33 28.23,96.33 27.94,96.04 25.44,96.04 22.51,93.11 22.51,90.39 21.63,89.51 20.87,89.51 18.13,86.78 18.13,81.22 19.66,79.69 20.67,79.69 21.06,79.31 21.06,78.55 v1(20.55,78.04)
VIDSCLK: length 93.9
  TOP w0.089: v5(71.4,69.08) 71.27,69.08 JCPU1.AJ30
  TOP w0.102: v1(47.8,94.43) 47.99,94.43 49.05,93.37 v2(50.2,93.37) 55.01,93.37 57.01,91.38 59.4,91.38 61.86,88.92 61.86,85.83 61.09,85.05 61.09,82.87 61.38,82.58 v1(61.38,81.6) ; PR722.1 v1(20.48,79.06)
  IN3 w0.127: v1(47.8,94.43) 47.8,95.06 47.1,95.76 45.82,95.76 43.94,93.88 36.87,93.88 35.18,95.57 34.14,95.57 32.69,97.02 30.14,97.02 29.92,96.8 28.03,96.8 27.79,96.56 25.29,96.56 22.04,93.31 22.04,90.58 21.44,89.98 20.67,89.98 17.63,86.93 17.63,80.96 19.53,79.06 v1(20.48,79.06)
  BOTTOM w0.102: v1(61.38,81.6) 61.38,80.56 60.46,79.64 60.46,76.83 65.02,72.27 65.02,71.73 66.41,70.35 66.71,70.35 66.72,70.33 69.81,70.33 69.85,70.3 70.62,70.3 70.88,70.04 70.88,69.6 v5(71.4,69.08)
VIDSOUT: length 99.1
  TOP w0.089: v1(72.39,69.94) 72.88,69.45 JCPU1.AJ28
  TOP w0.102: PR727.1 20.9,77.34 v1(20.53,77.34) ; v1(45.87,94.41) 45.87,94.46 47.01,95.61 48.58,95.61 48.64,95.54 51.12,95.54 52.12,94.54 v2(53.59,94.54) 55.54,94.54 57.15,92.93 59.43,92.93 62.98,89.38 62.98,85.24 63.4,84.82 63.4,82.24 62.93,81.78 v1(62.71,81.78)
  IN3 w0.127: v1(45.87,94.41) 45.87,93.59 45.15,92.86 36.56,92.86 34.83,94.59 33.78,94.59 32.39,95.99 31.22,95.99 31,95.77 28.34,95.77 28.13,95.56 25.63,95.56 22.98,92.91 22.98,90.19 21.83,89.04 21.13,89.04 18.64,86.55 18.64,81.47 19.91,80.2 21.18,80.2 21.56,79.82 21.56,78.37 v1(20.53,77.34)
  BOTTOM w0.102: v1(62.71,81.78) 62.71,79.63 61.73,78.65 RC65.2 62.54,78.47 64.54,78.47 64.87,78.14 65.02,78.14 65.77,77.39 65.77,76.33 65.28,75.83 65.28,74.4 65.89,73.79 65.89,72.59 66.11,72.37 66.5,72.37 66.72,72.14 66.72,71.92 67.18,71.46 70.45,71.46 70.86,71.04 70.86,70.9 71.22,70.54 71.35,70.54 71.86,70.04 72.29,70.04 v1(72.39,69.94)
VOL_DOWN: length 322.3
  TOP w0.102: JIO1.75 30.13,23.35 29.25,22.47 29.25,21.51 v1(29.59,21.17) ; v1(180.2,51.21) 180.73,51.74 180.73,63.36 182.17,64.8 184.79,64.8 185.85,65.86 185.85,75.24 178.84,82.25 176.99,82.25 170.2,89.03 162.92,89.03 160.12,91.83 160.12,102.34 v4(160.51,102.74) 160.83,103.05 160.83,110.6 162.05,111.82 162.05,133.17 161.73,133.49 161.73,136.5 160.88,137.35 R1197.1 R887.2
  IN1 w0.109: v1(174.85,14.94) 171.91,11.99 158.77,11.99 156.77,14 154.84,14 153.15,12.3 132.26,12.3 131.68,11.72 122.24,11.72 119.63,9.12 112.82,9.12 112.08,9.86 109.7,9.86 108.96,9.12 108.65,9.12 107.56,8.02 35.93,8.02 33.24,10.71 32.03,10.71 30.24,12.5 30.24,20.52 v1(29.59,21.17)
  IN2 w0.127: v1(174.85,14.94) 174.85,15.97 166.79,24.03 166.79,24.16 165.09,25.86 165.09,32.75 165.9,33.56 165.9,41.67 172.67,48.44 176.57,48.44 179.39,51.26 180.15,51.26 v1(180.2,51.21)
VOL_MUTE: length 299.8
  TOP w0.102: v1(155.93,150.56) 155.93,150.38 155.68,150.12 155.68,145.62 v2(155.32,145.26) 154.11,144.05 154.11,139.98 157.43,136.65 157.83,136.65 159.21,135.28 159.21,131.51 160.13,130.58 160.13,112.54 160.01,112.41 159.99,112.41 158.84,111.25 158.84,105.85 158.15,105.16 158.15,103.53 158.85,102.83 158.85,94.82 157.97,93.94 157.97,93.52 158.48,93.02 v1(158.56,93.02) ; v1(29.7,21.95) 29.7,22.23 30.23,22.75 JIO1.77
  IN1 w0.109: v1(155.5,14.97) 153.06,12.53 132.16,12.53 131.58,11.95 121.9,11.95 121.7,12.15 120,12.15 116.96,15.2 114.58,15.2 111.9,12.52 110.66,12.52 109.52,11.39 109.52,10.05 108.82,9.35 108.48,9.35 107.38,8.25 36.07,8.25 33.25,11.06 32,11.06 30.48,12.59 30.48,21.17 v1(29.7,21.95)
  IN3 w0.127: v1(155.5,14.97) 155.42,14.97 155.09,15.3 155.09,16.32 158.19,19.42 158.19,24.18 159.82,25.81 159.82,26.96 160.46,27.61 160.46,43.26 161.68,44.48 161.68,45.09 161.68,47.78 165.38,51.47 166.39,51.47 167.26,52.34 167.26,53.52 169.63,55.9 169.63,65.8 166.89,68.54 166.89,82.4 158.05,91.24 158.05,92.51 v1(158.56,93.02)
  BOTTOM w0.102: R1177.1 157.35,151.44 R884.2 157,150.61 156.84,150.76 156.14,150.76 155.94,150.56 v1(155.93,150.56)
VOL_UP: length 290.9
  TOP w0.102: v1(155.19,141.11) 155.19,139.22 157.47,136.94 157.93,136.94 159.46,135.41 159.46,131.64 160.4,130.69 160.4,112.46 159.07,111.13 159.07,105.75 158.38,105.06 158.38,103.62 159.08,102.92 159.08,94.7 158.49,94.12 v1(158.49,93.69) ; v1(32.28,23.01) 32.28,23.48 31.81,23.95 JIO1.73
  IN1 w0.109: v1(154.18,14.94) 154.06,14.94 152.12,12.99 131.97,12.99 131.39,12.41 128.01,12.41 126.87,13.55 119.31,13.55 117.21,15.65 114.39,15.65 111.71,12.98 110.47,12.98 109.48,11.99 108.82,11.99 107.7,10.87 106.58,10.87 104.42,8.71 36.71,8.71 34.11,11.31 34.11,11.84 33.53,12.42 32.84,12.42 32.82,12.4 31.7,12.4 31.08,13.02 31.08,21.81 v1(32.28,23.01)
  IN3 w0.127: v1(154.18,14.94) 154.3,15.06 154.3,15.89 157.92,19.51 157.92,24.32 159.38,25.78 159.38,26.96 160.23,27.81 160.23,43.36 161.45,44.57 161.45,44.99 161.45,48.04 169.38,55.97 169.38,65.63 166.65,68.36 166.65,82.18 157.78,91.05 157.78,93.03 158.44,93.69 v1(158.49,93.69)
  BOTTOM w0.102: v1(155.19,141.11) v2(155.19,142.25) 155.19,143.92 156.63,145.35 R1118.1 R886.2
VR_EN: length 6.8
  TOP w0.102: PR731.2 22.17,75.16 22.96,75.96 v1(22.96,76.15) 22.96,76.2 24.15,77.39 PU702.9
  BOTTOM w0.102: v2(24.43,76.66) 23.47,76.66 22.96,76.15 v1(22.96,76.15) 22.96,76 22.17,75.2 PR731.2
VR_HOT#: length 3.1
  TOP w0.102: PR729.2 22.18,76.01 v2(23.16,76.99) 23.38,77.22 23.54,77.22 24.12,77.79 PU702.8
VSB_N_001: length 7.1
  TOP w0.102: v2(130.83,125.84) 131.39,125.29 PR15.2
  TOP w0.254: PR17.2 132.51,123.89 131.62,124.78 PR15.2 131.39,124.13 131.62,123.89 PC7.2 131.62,122.28 131.88,122.02 PQ4.2
VSB_N_002: length 5.7
  TOP w0.102: PQ7.2 135.23,120.71 v2(135.46,120.49)
  TOP w0.254: PQ7.2 135.23,124.1 PC16.1 PR21.2 PR23.2
VSB_N_003: length 4.3
  TOP w0.102: v2(133.44,120.43) 133.95,120.95 PQ7.1
  TOP w0.254: PQ7.1 133.85,121.68 133.46,121.68 132.8,122.34 PR17.1
VSET_4002: length 5.1
  TOP w0.102: R406.1 C333.1 134.18,159.83 135.9,159.83 136.15,160.08 v2(136.61,160.08) U18.42
VSUM+: length 22.8
  TOP w0.203: PU702.14 26.47,75.73 26.16,75.43 26.16,74.13 26.47,73.83 v1(26.52,73.83)
  TOP w0.254: PR761.1 28.18,66.84 28.74,67.4 28.74,67.97 28.29,68.42 PR746.1 27.81,68.77 27.71,68.87 26.9,68.87 26.63,68.61 26.06,68.61 v1(26.03,68.63) 25.72,68.95 24.52,68.95 24.22,68.64 PR724.1
  IN3 w0.254: v1(26.52,73.83) 24.97,72.28 24.97,69.7 v1(26.03,68.63)
  BOTTOM w0.254: PR753.1 25.98,74.36 v1(26.52,73.83) 26.26,73.57 PR754.1 26.27,72.92 26.95,72.92 v2(27.23,73.21) 27.47,73.45 PC751.1 28.32,73.44 PC752.1 PC750.1
VSUM-: length 133
  TOP w0.254: PC738.2 PC739.2 24.23,71.98 25.25,71.98 PC742.2 25.25,71.79 25.63,71.41 v1(25.63,71.3) ; PH704.2 v1(53.95,69.23)
  IN3 w0.254: v1(25.63,71.3) 26.69,71.3 28.32,69.67 29.98,69.67 31.44,68.21 v1(31.44,68.1)
  IN4 w0.254: v1(25.63,71.3) 25.63,71.3 24.6,72.33 21.44,72.33 20.8,71.69 20.8,67.31 30.2,57.91 30.2,54.06 37.18,47.07 37.18,44.51 41.44,40.26 56.81,40.26 61.25,44.7 61.25,54.74 61.7,55.18 61.7,70.42 58.52,73.6 56.99,73.6 56.38,72.99 56.38,71.34 54.86,69.81 54.53,69.81 v1(53.95,69.23)
  BOTTOM w0.254: PR728.2 27.63,67.37 26.96,68.05 26.96,68.66 27.41,69.1 v2(27.41,69.11) 28.42,70.13 29.4,70.13 30.1,70.83 PR751.2 30.46,71.52 30.33,71.65 PC750.2 PC752.2 28.33,72.49 PC751.2 27.41,72.5 26.89,71.98 PR754.2 PC742.2 PC739.2 24.23,71.68 24.86,71.05 PR760.1 25.15,70.81 25.63,71.29 v1(25.63,71.3) ; v1(31.44,68.1) PR763.2
VSUMG+: length 17.8
  TOP w0.254: v1(24.09,81.17) 23.99,81.06 23.99,80.79 24.19,80.59 PU702.1 ; v1(23.72,84.77) 22.63,84.77 PR767.2
  IN4 w0.254: v1(20.17,84.46) 20.8,84.46 21.12,84.14 23.09,84.14 v1(23.72,84.77)
  BOTTOM w0.254: v1(24.09,81.17) v2(23.47,81.17) 22.24,81.17 PC707.1 ; v1(23.72,84.77) 22.91,83.96 PC708.1 22.91,83.26 22.17,82.51 PC709.1 PC707.1 ; PC707.1 PR708.1 PR706.1 ; PR772.1 18.08,85.2 18.77,84.52 20.1,84.52 v1(20.17,84.46)
VSUMG-: length 68.8
  TOP w0.254: PH701.2 54.39,85.38 54.39,90.17 53.5,91.06 53.15,91.06 52.83,91.38 52.83,91.81 51.92,92.72 48.35,92.72 47.47,93.6 35.67,93.6 34.4,92.33 30.32,92.33 30.03,92.62 26.62,92.62 22.72,88.72 20.43,88.72 18.77,87.06 18.77,83 19.85,81.92 20.32,81.92 20.55,81.69 v1(20.55,81.66) 20.65,81.56 20.65,81.34 20.9,81.09 PC720.2 PC719.2 PR710.1 PR712.1 21.06,84.14 20.67,84.52 20.67,85.19 PR768.1 21.38,85.89 23.02,85.89 PR773.2
  BOTTOM w0.254: v1(20.55,81.66) 20.55,81.41 20.86,81.09 PC720.2 ; PC720.2 PC719.2 21.22,82.55 21.96,83.29 PC708.2 v2(20.86,83.63) 20.16,82.93 PC718.1 ; PC720.2 PR708.2
VSYNC: length 4.7
  TOP w0.102: RH124.2 20.86,131.67 22.08,130.44 22.08,130.24 22.75,129.57 22.75,129.24 23.23,128.76 UH4.M49
VSYNC_BUF: length 12.7
  TOP w0.102: R44.1 68.93,164.61 68.26,163.93 66.08,163.93 v1(64.97,162.83)
  BOTTOM w0.102: v1(64.97,162.83) v2(64.15,162) 61.44,159.3 61.44,157.26 61.77,156.94 U19.36
VSYNC_DOCK: length 66.3
  IN3 w0.127: v1(98.96,122.77) 98.56,122.38 97.53,122.38 97.1,122.81 97.1,125.76 90.84,132.02 87.05,132.02 85.3,133.77 85.3,135.6 83.91,137 80.71,137 77.79,139.92 77.79,142.15 76.9,143.04 73.93,143.04 72.51,144.46 70.98,144.46 68.71,146.74 68.71,147.74 66.67,149.77 63.92,149.77 59.54,154.15 58.02,154.15 57.5,154.67 v3(57.5,154.92)
  BOTTOM w0.102: v1(98.96,122.77) 99.24,122.49 JDOCK1.67 ; v3(57.5,154.92) 57.5,154.6 57.81,154.29 58.33,154.29 58.62,154.59 U19.27
VSYNC_L: length 15.9
  TOP w0.102: v2(69.89,165.95) 69.7,166.14 69.7,167.28 70.2,167.79 R50.2 69.06,167.92 L5.2 68.93,169.45 C18.1 68.97,171.16 68.27,171.86 65.04,171.86 64.59,171.41 62.93,171.41 62.6,171.74 62.6,173.04 JCRT1.14
VTT_SENSE: length 54.9
  TOP w0.081: JCPU1.B10 90.4,41.95 90.4,38.66 91.03,38.02 v2(91.03,37.03) RC70.2 91.01,36.08 90.42,36.08 90.33,36.17 90.33,37 90.19,37.14 v1(89.55,37.14)
  IN1 w0.089: v1(89.55,37.14) 88.26,35.85 85.67,35.85 77.47,27.65 57.53,27.65 53.38,23.5 53.38,20.51 v1(53.47,20.42)
  BOTTOM w0.081: PR509.2 v1(53.47,20.42)
WIGI_RADIO_DIS#: length 98.5
  TOP w0.102: v1(184.38,81.32) 185.05,81.32 185.72,81.99 187.11,81.99 187.98,81.12 195.03,81.12 198.12,78.03 198.12,70.26 199.47,68.91 202.49,68.91 206.88,64.52 227.98,64.52 228.98,63.51 230.87,63.51 231.38,63.01 235.77,63.01 236.14,63.37 239.14,63.37 240.99,65.23 v1(240.99,66.21)
  IN1 w0.109: v1(187.43,100.99) 187.18,100.75 187.18,95.09 184.55,92.46 184.55,84.15 183.77,83.36 183.77,82.47 184.38,81.86 v1(184.38,81.32)
  BOTTOM w0.102: v2(242.45,65.34) 241.59,66.21 v1(240.99,66.21) 240.71,66.21 240.58,66.34 U46.A1 ; v1(187.43,100.99) 186.92,101.5 D29.1 187.55,101.66 187.93,101.28 R690.1 188.07,101.3 R692.2
WIGI_RADIO_DIS#_R: length 3
  BOTTOM w0.102: R690.2 187.99,100.26 D29.2 186.69,100.04 JMINI2.32
WIMAX_LED#: length 8
  TOP w0.102: v1(184.44,95.85) 183.52,96.77 Q124.4 183.38,97.35 v2(183.7,97.67) 183.74,97.71 R706.1 R705.1
  BOTTOM w0.102: v1(184.44,95.85) 183.53,96.76 183.49,96.76 182.69,97.56 JMINI2.42
WIRELESS_LED#: length 310.8
  TOP w0.102: Q124.6 182.08,96.21 182.62,95.66 183.12,95.66 183.38,95.4 Q124.3 183.38,93.06 183.67,92.77 v2(184.24,92.77) 184.63,92.77 185.18,92.22 v1(185.22,92.22) ; Q77.1 v1(103.29,160.57)
  IN1 w0.109: v1(240.14,79.02) 239.72,79.02 239.62,79.12 238.3,79.12 237.31,80.11 233.5,80.11 232.45,79.06 231.22,79.06 230.87,78.7 230.87,78.08 231.47,77.48 231.47,74.13 231.09,73.75 229.58,73.75 228.13,72.3 228.13,67.3 227.06,66.24 v1(227.06,63.32)
  IN2 w0.127: v1(103.29,160.57) 103.29,159.61 103.92,158.98 108.79,158.98 112.25,155.51 116.51,155.51 117.34,154.69 120.7,154.69 121.76,153.63 125.16,153.63 129.91,158.38 133.28,158.38 134.53,159.63 136.52,159.63 136.8,159.35 150.13,159.35 151.1,158.37 153.24,158.37 158.29,163.42 172.14,163.42 172.88,162.68 174.2,162.68 176.25,160.63 182.22,160.63 183.35,161.76 185.68,161.76 186.25,161.19 191.84,161.19 193.11,159.92 195.11,159.92 196.23,161.04 196.68,161.04 200.77,156.95 205.74,156.95 209.83,152.85 209.83,147.22 210.53,146.53 210.53,104.79 211.56,103.76 212.99,103.76 217.18,99.57 217.18,97.98 227.1,88.07 228.01,88.07 231.76,84.32 231.76,83.8 232.3,83.26 233.04,83.26 233.2,83.41 234.4,83.41 235.09,82.73 235.09,81.01 235.67,80.43 238.98,80.43 240.14,79.27 v1(240.14,79.02) ; v1(227.06,63.32) 225.86,64.53 225.86,68.54 223.06,71.34 218.63,71.34 215.06,74.91 215.06,78 214.15,78.91 203.32,78.91 201.28,80.95 197.24,80.95 191.06,87.14 189.96,87.14 189.37,87.73 189.37,88.23 188.41,89.19 187.9,89.19 185.23,91.87 185.23,92.21 v1(185.22,92.22)
  BOTTOM w0.102: R944.2 227.18,61.92 227.06,62.03 Q78.4 v1(227.06,63.32) ; v1(240.14,79.02) 240.08,78.96 U46.A47
WIRELESS_ON#/OFF: length 143.3
  IN1 w0.109: v1(231.82,64.87) 231.82,65.84 232.89,66.9 233.51,66.9 234.83,68.22 v1(234.83,68.38)
  IN2 w0.127: v1(231.82,64.87) 231.84,64.87 233.26,63.45 239.69,63.45 241.18,64.94 245.48,64.94 246.25,64.16 247.33,64.16 v1(249.46,62.03) 250.48,61.01 260.67,61.01 262.52,62.87 262.52,67.06 263.47,68.01 273.24,68.01 274.03,67.22 275.93,67.22 277.11,68.4 289.72,68.4 291.54,66.59 291.54,57.28 295.36,53.45 295.36,22.61 281.62,8.86 v1(281.62,8.66)
  BOTTOM w0.102: v1(234.83,68.38) U46.B13 ; R2158.2 v1(249.46,62.03) ; v1(281.62,8.66) v2(281.62,9.36) ; v1(231.82,64.87) 232.26,64.44 R766.2
  vias: v1(280.92,8.5) v1(280.91,7.76) v1(280.91,7.06) v1(280.95,9.27) v1(281.62,5.98)
WLAN_LAN_DISB#: length 205.7
  TOP w0.102: v2(130.28,153.71) v1(130.28,154.65) 130.28,154.86 U15.4
  IN2 w0.127: v1(130.28,154.65) 130.28,154.33 130.78,153.83 135.07,153.83 135.23,154 135.23,155.96 136.31,157.04 144.28,157.04 144.87,156.45 146.82,156.45 147.49,155.78 152.7,155.78 159.24,162.32 169.75,162.32 171.5,160.57 174.99,160.57 175.61,159.94 182.55,159.94 182.76,160.16 191.9,160.16 193.23,158.83 197.47,158.83 200.05,156.25 201.69,156.25 206.22,151.72 206.22,131.07 205.83,130.68 205.83,120.14 206.77,119.2 206.77,117.03 208.3,115.5 208.3,109.84 208,109.54 207,109.54 206.75,109.3 206.75,103.28 208.61,101.42 208.61,96.4 211.12,93.89 220.63,93.89 227.83,86.69 228.86,86.69 231.5,84.05 231.5,83.74 232.21,83.03 233.14,83.03 233.29,83.19 234.31,83.19 234.86,82.63 234.86,80.91 235.57,80.2 236.38,80.2 237.31,79.27 v1(237.31,79.29)
  IN3 w0.127: v1(237.31,79.29) 238.14,80.11 243.25,80.11 243.43,79.93 243.92,79.93 245.22,78.63 245.22,72.2 244.69,71.67 244.69,69.45 243.91,68.67 243.68,68.67 243.46,68.45 v1(243.08,68.45)
  BOTTOM w0.102: v1(243.08,68.45) 243.08,68.45 U46.A64
WLAN_LED: length 257.3
  TOP w0.102: JIO1.94 37.18,17.95 v1(37.45,18.23)
  IN1 w0.109: v1(37.45,18.23) 37.14,17.92 34.84,17.92 34.02,18.73 33.25,18.73 33.07,18.56 33.07,14.44 37.76,9.74 104.16,9.74 106.2,11.79 107.33,11.79 108.47,12.93 109.05,12.93 110.02,13.89 111.3,13.89 113.97,16.57 117.75,16.57 119.78,14.53 127.77,14.53 128.27,14.03 150.09,14.03 152.39,16.33 156.12,16.33 159.32,13.13 168.31,13.13 v1(170.33,15.15)
  IN3 w0.127: v1(226.74,59.89) 223.02,59.89 220.93,61.99 209.04,61.99 201.17,54.12 193.9,54.12 193.78,53.99 193.78,53.98 190.76,50.96 187.98,50.96 187.38,50.37 182.13,50.37 180.21,48.45 174.45,48.45 166.74,40.75 166.74,35.43 166.11,34.8 166.11,24.62 170.33,20.41 v1(170.33,15.15)
  BOTTOM w0.102: R939.2 226.71,60.95 226.71,59.93 v1(226.74,59.89) ; v1(37.45,18.23) 36.14,18.23 v2(35.98,18.39)
WLAN_LED#: length 5.9
  TOP w0.102: Q124.1 182.08,94.99 181.48,95.58 v1(181.48,96.93) 181.48,97.07 181.71,97.3 v2(181.71,97.69) R718.1
  BOTTOM w0.102: JMINI2.44 181.89,97.48 181.48,97.07 v1(181.48,96.93)
WLAN_RADIO_DIS#: length 66.5
  IN1 w0.109: v1(240.58,78.55) 240.58,78.83 240.59,78.84 240.59,79.21 240.33,79.47 239.94,79.47 239.56,79.85 239.56,79.85 239.3,80.11 238.93,80.11 238.67,79.85 238.1,79.85 237.62,80.34 228.83,80.34 v1(228.4,80.77)
  IN2 w0.127: v1(228.4,80.77) 227.16,80.77 226.63,80.24 225.75,80.24 224.31,81.68 224.31,82.72 224.56,82.97 224.56,83.55 222.97,85.14 220.51,85.14 219.48,86.17 218.67,86.17 216.47,88.37 212.93,88.37 212.71,88.58 208.89,88.58 208.05,89.42 203.11,89.42 202.07,90.46 199.48,90.46 197.88,92.06 197.88,94.23 196.61,95.5 196.19,95.5 193.62,98.08 v3(193.62,98.53)
  BOTTOM w0.102: v1(240.58,78.55) U46.A48 ; D31.1 192.1,102.65 R700.1 193.42,102.65 193.67,102.4 193.67,101.37 193.15,100.85 193.15,99 v3(193.62,98.53)
WLAN_RADIO_DIS#_R: length 4.4
  BOTTOM w0.102: R700.2 192.92,101.47 D31.2 191.49,101.09 JMINI2.20
WWAN_RADIO_DIS#: length 195.7
  TOP w0.102: v1(230.49,76.36) 230.88,76.36 231.96,77.45 232.65,77.45 232.76,77.33 237.93,77.33 238.61,76.66 238.61,74.98 239.09,74.5 239.5,74.5 240.11,73.89 241.03,73.89 241.77,73.15 v2(242.01,73.15) 242.09,73.15 v1(243.74,74.8)
  IN2 w0.127: v1(230.49,76.36) 230.29,76.56 229.44,76.56 229.27,76.38 225.48,76.38 224.85,77 224.85,78.6 222.06,81.39 216.58,81.39 214.6,83.38 210.24,83.38 208.84,84.77 200.51,84.77 199.55,85.73 198.92,85.73 198.92,85.72 197.91,85.72 195.43,88.21 195.43,89.89 194.12,91.2 194.12,92.46 189.98,96.6 189.98,97.73 187.92,99.79 187.92,102.02 182.08,107.86 182.08,110.71 175.04,117.74 175.04,120.99 168.29,127.74 164.81,127.74 164.43,127.36 157.01,127.36 151.65,132.72 138.15,132.72 137.72,132.28 133.3,132.28 132.65,131.64 130.57,131.64 130.09,131.15 123.29,131.15 122.99,130.85 122.99,130.77 v1(123.01,130.75)
  BOTTOM w0.102: R774.2 244.05,74.49 v1(243.74,74.8) 242.88,73.95 U46.A53 ; JMINI1.20 108.9,151.05 109.4,150.55 109.4,147.65 110.88,146.17 110.88,139.85 109.43,138.41 109.43,132.31 109.96,131.79 121.99,131.79 122.99,130.8 122.99,130.77 v1(123.01,130.75)
WWAN_SMBCLK: length 3.5
  TOP w0.102: R1159.2 R1157.1 106.72,155 v3(106.63,154.92)
  BOTTOM w0.102: JMINI1.30 106.76,155.05 v3(106.63,154.92)
WWAN_SMBDAT: length 3.5
  TOP w0.102: R1158.1 R1160.2 109.38,156.02 v3(109.47,155.93)
  BOTTOM w0.102: v3(109.47,155.93) 109.39,155.85 JMINI1.32
XCLK_RCOMP: length 5
  TOP w0.152: RH100.1 27.15,130.78 v2(27.15,130.58) 27.15,129.34 26.83,129.02 26.83,128.05 27.06,127.82 27.06,127.4 UH4.Y47
XDP_DBRESET#: length 133.2
  TOP w0.102: v1(64.69,104.51) 64.69,104.49 65.06,104.12 JXDP2.48 65.06,101.22 60.15,96.3 54.67,96.3 54.41,96.57 51.66,96.57 51.44,96.36 49,96.36 48.93,96.42 v2(45.95,96.42) 42.72,96.42 v1(42.63,96.51) ; v1(57.85,78.98) 58.28,78.55 RC28.2 ; UC3.1 19.26,96.24 19.66,96.63 19.66,97.98 19.51,98.13 19.51,98.59 20.17,99.25 v1(20.17,99.51) 20.17,99.58 20.18,99.58 20.2,99.61 20.2,100.13 RH359.1
  IN1 w0.109: v1(65.7,94.65) 65.53,94.49 56.06,94.49 55.54,95.01 54.68,95.01 54.68,95.01 54.32,95.01 53.33,96 45.99,96 45.23,96.75 42.88,96.75 v1(42.63,96.51) 42.4,96.74 36.07,96.74 35.79,97.02 33.27,97.02 32.76,96.51 25.23,96.51 22.86,98.88 22.86,99.46 22.5,99.82 20.96,99.82 20.95,99.81 20.47,99.81 v1(20.17,99.51)
  BOTTOM w0.102: v1(65.7,94.65) 65.7,95.11 66.06,95.48 68.41,95.48 70.88,93 72.85,93 72.95,93.1 76.9,93.1 77.13,92.87 77.13,92.51 77.15,92.49 JXDP1.18 77.15,90.93 77.42,90.67 77.42,88.13 RC30.1 ; v1(57.85,78.98) 58.04,78.98 61.07,82.02 61.17,82.02 61.52,82.36 62.84,82.36 64.24,83.76 64.24,86.48 64.74,86.98 64.74,93.28 61.89,96.14 61.89,98.53 64.1,100.74 64.1,103.91 v1(64.69,104.51)
