# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Library data of the parts (continued)
C476 C477 = C_0402: room: +3.3V_LAN SOURCE
C479-C481 C484 C486 = C_0603: room: LOM
C482 = C_0805: room: DP
C483 C1167 = C_0402: room: LOM
C485 = C_1808: room: LOM
C498 C771 C775 PC30 = C_0805
C593 C594 C597 C599 C610-C612 C614 C644 = C_0402: room: WWAN
C595 C596 C598 C600-C607 C632 = C_0402: room: WLAN
C608 = C_0603: room: WLAN
C609 C617 C618 C620 C621 C623 C652 = C_0402: room: FLASH
C613 = C_0805: room: WWAN
C615 C1176 = C_D2E: room: WWAN
C616 C628-C631 = C_0402: room: SIM
C619 = C_V: room: FLASH
C622 = C_0805: room: FLASH
C624-C626 C634-C639 C651 = C_0402: room: WPAN
C633 = C_0603: room: WPAN
C667 = C_D2: room: ESATA
C668 C671-C675 = C_0402: room: ESATA
C669 = C_0805: room: USB3.0
C676 = C_0805: room: ESATA
C695-C701 C704 CE8 CE9 = C_0402: room: DOCKING
C702 C703 = C_0603: room: DOCKING
C708-C713 C716-C719 = C_0402: room: SIO
C714 = C_0603: room: SIO
C721-C725 C763 = C_0402: room: IO
C730 C740 = C_0603: room: KBC
C748 C753 C754 = C_0402: room: BT
C756 C758 = C_0402: room: KB
C759 = C_0402: room: TOUCH.PAD
C760 = C_0603: room: +3.3V_ALW_PCH SOURCE
C761 C764 = C_0402: room: +3V_5V_RUN SOURCE
C762 = C_0402: room: +3.3V_ALW_PCH SOURCE
C765 = C_0603: room: +3.3V_SUS SOURCE
C767 = C_0402: room: +3.3V_SUS SOURCE
C768 = C_0603: room: +3.3VM SOURCE
C770 = C_0402: room: +3.3VM SOURCE
C772 = C_0603: room: +1.05VRUN_SOURCE
C773 = C_0402: room: +1.05VRUN_SOURCE
C774 = C_0402: room: MXM_PWR_SRC SOURCE
C776 = C_1206: room: MXM_PWR_SRC SOURCE
C778 = C_0402: room: LED
C787 C788 = C_0402: room: FLASH ROM
C793 C794 = C_0603: room: USB3.0
C1145 C1146 C1149 C1159 = C_0402: room: LVDS SW
C1177 = C_0805: room: LAN
C1178 = C_0805: room: +3.3V_LAN SOURCE
C1182 = C_0603: room: CRT
CC1-CC65 CC68 CC69 CC72-CC74 CC82 CC89 CC90 = C_0402: room: CPU
CC66 CC67 = C_0402: room: XDP1
CC70 = C_0805: room: +1.5V_CPU_VDDQ SOURCE
CC71 = C_0603: room: +1.5V_CPU_VDDQ SOURCE
CC75-CC80 CC83-CC86 CC88 = C_0603: room: CPU
CC81 CC87 CC91 PC1166-PC1168 = C_D2: room: CPU
CD1-CD6 CD15-CD28 CD37-CD50 CD59-CD72 CD81-CD88 = C_0402: room: MEMORY
CD7-CD13 CD29-CD35 CD51-CD57 CD73-CD79 = C_0603: room: MEMORY
CD14 CD36 CD58 CD80 = C_SX: room: MEMORY
CE6 = C_0805: room: DOCKING
CH1 = C_0402: room: XDP2
CH30 CH36 CH40 CH44 CH58 CH70 CH71 CH73 CH80 CH85 CH106 = C_0603: room: PCH
CH64 CH65 CH105 = C_0805: room: PCH
CH94 CH95 = C_B2: room: PCH
CMOS1 ME1 = SHORTPADS: User Part Number: PART#; room: PCH
D6 = BAT54CW_SOT323-3: room: LVDS
D7 D8 D18 D19 D68 D71 = RB751VM-40TE-17_SOD323-2
D9 = BAT1000-7-F_SOT23-3: room: CRT
D10 D11 = PESD5V0U2BT_SOT23-3: room: CRT
D12 = BAT1000-7-F_SOT23-3: room: HDMI
D13 D86 D87 = PESD5V0U2BT_SOT23-3: room: CAM
D14 D16 = IP4292CZ10-TBR_XSON10_2P5X1: room: USB3.0
D15 D17 = PESD5V0U2BT_SOT23-3: room: USB3.0
D28-D30 D90 D103 = RB751S40T1_SOD523-2
D31 = RB751S40T1_SOD523-2: room: WLAN
D32 = RB751S40T1_SOD523-2: room: DOCKING
D33 = PESD24VS2UT_SOT23-3: room: DOCKING
D34 = RB751S40T1_SOD523-2: room: SIO
D53 D64 D66 D67 D69 = RB751VM-40TE-17_SOD323-2: room: LVDS
D59 D60 D62 D63 = RB751S40T1_SOD523-2: room: LED
D70 = RB751V-40GTE-17_SOD323-2: room: HDMI
D73 = PESD5V0U2BT_SOT23-3: room: ESATA
DH2 DH3 = RB751S40T1_SOD523-2: room: PCH
F3 = F_1206L150PR: room: DP
F4 = F_SMD1812P200TF: room: HDMI
F5 = F_SMD1812P200TF: room: CRT
FD1-FD4 = FIDUCIAL_C40M80: room: LED
H1 H4 H5 H9 H10 H13 H14 H17 H20 = H_3P0: room: LED
H2 H3 H6 H7 = H_3P6: room: LED
H8 = H_5P2: room: LED
H11 H12 = H_3P8: room: LED
H15 H16 H18 H19 = H_4P2: room: LED
H21 = H_4P2N
H22-H25 = H_1P2
H26 = H_3P0X3P6
JBT1 = ACES_50228-0127N-001_12P: room: BT
JCAM1 = ACES_50238-0207N-002_20P-T: room: CAM
JCPU1 = TYCO_2134146-3_989P: room: CPU
JCRT1 = SUYIN_070449HR015M221ZR_15P-T: room: CRT
JDEG2 = ACES_87153-10411_10P: room: KBC
JDIMM1 = TYCO_2-2013311-1_204P: room: DDR3
JDIMM2 JDIMM3 = TYCO_2-2013290-1_204P: room: MEMORY
JDIMM4 = TYCO_2-2013289-1_204P: room: MEMORY
JDOCK1 = JAE_WD2F144WB5R400_144P-T: room: DOCKING
JDP1 = FOX_3V1121C-N1YD7-7H_20P-T: room: DP
JEDP1 = ACES_50398-04071-001_40P: room: EDP
JESA1 = FOX_3Q38111-C35C5B-7H_11P-T: room: ESATA
JFAN1 JFAN2 = ACES_50271-0040N-001_4P: room: THERMAL
JHDMI1 = FOX_QJ1119L-BT11-7H_19P-T: room: HDMI
JIO1 = FOX_QTS01401-A021-9H_140P-T: room: IO
JKB1 = AMPHE_G281010112CHR_10P: room: KB
JLOM1 = TYCO_2041333-1_13P: room: LOM
JLVDS1 = ACES_50398-04071-001_40P: room: LVDS
JMINI1 = BELLW_80003-1121_52P: room: WWAN
JMINI2 = LCN_DAN08-52526-0100_52P: room: WLAN
JMINI3 = LCN_DAN08-52526-0100_52P: room: WPAN
JMINI4 = LCN_DAN08-52526-0100_52P: room: FLASH
JMXM1 = JAE_MM70-314-310B1-1-_310P-S: room: MXM
JODD1 = FOX_LN21131-D008-9H_13P-T: room: ODD
JPB1 = ACES_50228-0067N-001_6P: room: ETY-ROOM
JRTC1 = ACES_50271-0020N-001_2P: room: ETY-ROOM
JSATA1 JSATA2 = SUYIN_127043HB022M26GZL_22P-T: room: HDD
JSIM1 = SUYIN_254070FB008S205ZL_8P: room: SIM
JSPI1 = TYCO_1-2041070-6_16P: room: FLASH ROM
JTAG1 = SHORTPADS: User Part Number: PART#; room: KBC
JUSB1 JUSB2 = LOTES_AUSB0041-P001A_9P-T: room: USB3.0
JUSH1 = ACES_50554-02001-001_20P-T: room: USH
JWL1 = ACES_50228-0037N-001_3P-T: room: ETY-ROOM
JXDP1 = MOLEX_52435-2671_26P-T: room: XDP1
JXDP2 = SAMTE_BSH-030-01-L-D-A_60P: room: XDP2
L1-L3 = MURAT_BLM18PG330SN1D_2P: room: CRT
L4 L5 = MURAT_BLM18AG121SN1D_L0603_2P: room: CRT
L10 L11 = MURAT_DLW21SN121SQ2L_4P: room: CAM
L19 L23-L25 = MURAT_DLW21SN900HQ2L_0805_4P: room: HDMI
L29 = TAIYO_CBC2012T4R7M_2P: room: LAN
L30-L37 = DELTA_0603CS-120EJTS_2P: room: LAN
L39 = MURAT_DLW21SN900SQ2L_0805_4P: room: USB
L40 L42-L44 = MURAT_DLW21SN900HQ2L_0805_4P: room: USB3.0
L41 = CHENG_OCE2012120YZF_4P: room: USB
L51 = MURAT_DLW21SN900SQ2L_0805_4P: room: ESATA
LH1 = TDK_GLFR1608T1R0M-LR_2P: room: PCH
LH3 LH5-LH7 = TAIYO_LBR2012T100M_2P: room: PCH
LH8 = TAIYO_HK1608R10J-T_L0603_2P: room: PCH
PBATT1 = SUYIN_200045GR009M28QL_9P-T: room: P_DCIN
PC1 = C_25CE100AX: room: DCIN_DETECTOR
PC2 PC3 PC10-PC13 PC15 = C_0603: room: P_DCIN
PC4 PC5 = C_0402: room: P_DCIN
PC7 PC8 = C_0603: room: VSB
PC9 PC14 = C_0805: room: P_DCIN
PC16 = C_0402: room: VSB
PC100 PC101 PC110 PC114-PC116 PC118 PC119 PC205 PC208 PC211 PC212 PC306 PC312 PC405 PC408 PC409 PC505 PC506 PC509 PC603 PC616 PC712 PC734 PC754 PC764 PC771 PC934 = C_0603: room: ETY-ROOM
PC102 PC103 PC106 PC107 PC203 PC204 PC210 PC213-PC217 PC302 PC305 PC308 PC311 PC401 PC402 PC407 PC501 PC502 PC507 PC510 PC606 PC609 PC612 PC613 PC617 PC618 PC905 PC938 PC939 = C_0402: room: ETY-ROOM
PC104 PC105 PC108 PC109 PC117 PC201 PC202 PC206 PC207 PC301 PC303 PC304 PC307 PC309 PC310 PC403 PC404 PC503 PC504 = C_0805: room: ETY-ROOM
PC112 PC113 = C_MP6VLPS220MC4R2: room: 3V5V
PC209 PC508 = C_MP2VLPS330MC4R2: room: ETY-ROOM
PC406 PC1157 PC1158 PC1173-PC1178 = C_D2: room: ETY-ROOM
PC601 PC602 = C_0603: room: 0.8V_VCC
PC604 PC605 PC607 PC608 PC610 PC611 PC1120-PC1124 PC1144-PC1148 PC1161-PC1165 PC1169 PC1170 = C_0805: room: 1P8V
PC614 PC615 = C_0805: room: 0.8V_VCC
PC619 = C_0402: room: 0.8V_VCC
PC701 = C_0402: room: DDR_VTT
PC702-PC709 PC711 PC717-PC720 PC730 PC732 PC733 PC735 PC736 PC738-PC742 PC748 PC750-PC752 PC755 PC756 PC762 PC770 = C_0402: room: CPU_CORE
PC710 PC716 PC721-PC723 PC731 PC737 PC747 PC757 PC761 PC763 PC765 PC769 PC772 = C_0603: room: CPU_CORE
PC713-PC715 PC727-PC729 PC744-PC746 PC758 PC759 PC766 PC767 = C_0805: room: CPU_CORE
PC724-PC726 = C_EEEFK1E101YP: room: CPU_CORE
PC901 PC903 PC908 PC910 PC911 PC913 PC924 = C_0603: room: CHARGER
PC902 PC904 PC906 PC909 PC912 PC916 PC917 PC919-PC922 PC927 PC928 PC933 PC935-PC937 PC940 PC941 = C_0402: room: CHARGER
PC907 PC914 PC915 PC930-PC932 PC1004 = C_0805: room: CHARGER
PC925 = C_0603: room: ADP3209
PC1001 = C_0805: room: SELECTOR
PC1002 PC1009 = C_0402: room: SELECTOR
PC1003 PC1005-PC1008 = C_0603: room: SELECTOR
PC1101-PC1119 PC1125-PC1141 PC1149-PC1156 = C_0805: room: CPU
PD1 = RB715FGT106_UMD3: room: ETY-ROOM
PD2 PD3 = PESD24VS2UT_SOT23-3: room: SWITCH
PD5 = SDMK0340L-7-F_SOD323-2: room: P_DCIN
PD7 = DA204U_SOT323-3
PD100 = RB751V_SOD323-2: room: P_SELECTOR
PD901 = SBR3A40SA-13_SMA2: room: ETY-ROOM
PD902 = RB717F_SOT323-3: room: ETY-ROOM
PD903 = RB751V-40_SOD323-2: room: ETY-ROOM
PD1001 PD1002 = PDS5100H-13_POWERDI5-3: room: ETY-ROOM
PH701 PH704 PR702-PR708 PR710 PR712 PR714 PR715 PR717 PR719 PR720 PR726 PR728 PR730 PR732 PR733 PR735-PR737 PR740 PR742 PR743 PR745 PR747-PR751 PR753 PR754 PR757 PR759 PR760 PR762 PR763 PR768 PR769 PR773 PR774 PR1013 = R_0402: room: CPU_CORE
PH702 PH703 PR101-PR104 PR106 PR107 PR112 PR115 PR117 PR202 PR208-PR210 PR215 PR301 PR303-PR306 PR308 PR310 PR312 PR313 PR512 PR605 PR610 PR701 PR752 PR907 PR908 PR913 PR920 PR930 PR932 PR933 PR940 PR941 PR945 PR1001 PR1003 PR1018 PR1028 = R_0402: room: ETY-ROOM
PJP28 = JUMP_43X39: room: KBC
PJP29 = JUMP_43X39: room: CODEC
PJP30 = JUMP_43X79: room: USB3.0
PJP31 = JUMP_43X79: room: ESATA
PJP32 = JUMP_43X79: room: +5VMOD SOURCE
PJP33 = JUMP_43X79: room: +5V_HDD SOURCE
PJP34 PJP35 PJP204 = JUMP_43X39
PJP70 = JUMP_43X39: room: PCH
PJP77 = JUMP_43X39: room: TPM
PJP78 PJP79 = JUMP_43X118
PJP102-PJP105 PJP201-PJP203 PJP402 PJP501 PJP502 = JUMP_43X118: room: ETY-ROOM
PJP205 PJP301 PJP302 = JUMP_43X79: room: ETY-ROOM
PJP401 = JUMP_43X118: room: P_DCIN
PJP601 PJP602 = JUMP_43X118: room: 0.8V_VCC
PJP603 = JUMP_43X39: room: 0.8V_VCC
PJP902 = JUMP_43X39: room: CHARGER
PJPDC1 = ACES_50290-01101-001_11P: room: P_DCIN
PL1 = CHT_C8BBPH853025_2P: room: DCIN_DETECTOR
PL2 = TAIYO_FBMJ4516HS720NT_2P: room: ETY-ROOM
PL3 = MURAT_BLM18BD102SN1D_L0603_2P: room: P_DCIN
PL4 = CHT_C8BBPH853025_2P: room: ETY-ROOM
PL6 = TAIYO_FBMJ4516HS720NT_2P
PL100 = CYNTE_PCMB053T-1R0MS_2P
PL102 = TOKO_FDV0630-3R3M-P3_2P: room: VDDCI
PL103 = TOKO_FDSD0630-H-2R2M-P3_2P
PL201 = CYNTE_PCMC104T-1R0MN_2P: room: ETY-ROOM
PL301 PL303 = TAI-T_HCB1608KF-121T3_L0603_2P: room: ETY-ROOM
PL302 PL304 = TAIYO_NRS4018T1R0NDGJ_2P: room: ETY-ROOM
PL401 PL501 PL601 = TAI-T_VMPI0703AR-1R0M-Z01_2P: room: VDDCI
PL701-PL705 = NEC_MPC0740LR42C_2P: room: ETY-ROOM
PL710 = KC_FBMA-L11-453215-121LMA90T_2
PL901 = CYNTE_PCMB053T-1R0MS_2P: room: ETY-ROOM
PL902 = TOKO_FDVE1040-H-5R6M-P3_2P: room: ETY-ROOM
PQ1 = FDN338P_NL_SOT23-3: room: P_DCIN
PQ2 = FDV301N_NL_SOT23-3: room: P_DCIN
PQ3 = MMST3904-7-F_SOT323-3: room: P_DCIN
PQ4 = TP0610K-T1-E3_SOT23-3: room: VSB
PQ5 PQ907 PQ1003 PQ1004 = SI7447DP_SO8_5P: room: ETY-ROOM
PQ7 PQ503 PQ909 PQ910 = SSM3K7002FU_SC70-3: room: ETY-ROOM
PQ101-PQ104 PQ401 PQ402 PQ501 PQ502 = SI7326DN-T1-E3_PAK1212-8: room: ETY-ROOM
PQ105 = DTC115EUA_SC70-3: room: ETY-ROOM
PQ106 PQ1005 = 2N7002DW-T-R7_SOT363-6
PQ201 = FDMS7696A_POWER56-8-5: room: ETY-ROOM
PQ202 = FDMS0309S_POWER56-8-5: room: ETY-ROOM
PQ204 PQ205 = 2N7002DW-T-R7_SOT363-6: room: ETY-ROOM
PQ701-PQ705 PQ707 PQ708 = CSD86350Q5D_SON8: room: ETY-ROOM
PQ706 = CSD86350Q5D_SON8
PQ901 = SI7447DP_SO8_5P: room: CHARGER
PQ902 PQ903 = NTR4502PT1G_SOT23-3: room: ETY-ROOM
PQ904 = NTGD4161PT1G_TSOP6: room: ETY-ROOM
PQ905 = SIR472DP-T1-GE3_POWERPAK8-5: room: ETY-ROOM
PQ906 = SI7716ADN-T1-GE3_POWERPAK8-5: room: ETY-ROOM
PQ908 = 2N7002DW-T-R7_SOT363-6: room: P_SELECTOR
PQ1002 = SI4835DDY-T1-E3_SO8: room: ETY-ROOM
PR1-PR5 PR7-PR13 PR16 PR18 PR20 PR22 = R_0402: room: P_DCIN
PR6 = R0402_0OHM: room: P_DCIN
PR14 PR24 PR26-PR31 PR113 PR314 PR514 PR723 PR744 R6 R9 R38-R42 R46 R51 R58 R61 R63-R95 R102-R114 R340 R341 R409 R415 R431 R518 R519 R575-R578 R690-R694 R708 R747 R773 R779 R809 R813 R826 R830-R833 R906 R912 R920 R921 R956 R1161 R1523 R1530 R1532 R1537-R1539 R1627 R1630 R1631 R2151-R2193 R2200-R2203 RH32 RH101 RH179 RH275 RH340 RH357 = R_0402
PR15 PR17 PR21 PR114 = R_0402: room: VSB
PR19 = R_0805: room: P_DCIN
PR23 PR613 PR614 R1633 R1976 = R0402_0OHM
PR25 = R_1206_4P-D
PR105 PR118 PR214 PR226 PR307 PR311 PR404 PR504 PR509 PR603 PR606 PR611 PR902 PR903 PR910 PR938 = R0402_0OHM: room: ETY-ROOM
PR108 PR109 PR201 PR402 PR502 PR607 PR709 PR711 PR716 PR718 PR724 PR738 PR746 PR755 PR758 PR761 PR764 PR766 PR767 PR771 PR772 PR775 PR776 = R_0603: room: CPU_CORE
PR110 PR111 PR203 PR302 PR309 PR405 PR505 PR608 PR1005 = R_1206: room: ETY-ROOM
PR204 PR919 = R_0603: room: ETY-ROOM
PR205 PR401 PR403 PR406-PR408 PR501 PR503 PR506 PR508 PR511 PR602 PR612 = R_0402: room: 1P5V
PR206 = R0402_0OHM: room: GPU_CORE
PR211 PR213 PR216-PR225 = R_0402: room: GPU_CORE
PR510 = R0402_0OHM: room: VGA_CORE
PR515 = R_0402: room: 1P05V
PR601 PR604 PR609 = R_0402: room: 0.8V_VCC
PR713 PR722 PR725 PR727 PR729 PR731 PR734 PR1002 PR1004 PR1006-PR1010 PR1012 PR1014-PR1017 PR1019-PR1025 PR1027 PR1029 = R0402_0OHM: room: CPU_CORE
PR721 PR739 PR756 PR765 PR770 = R_1206: room: CPU_CORE
PR741 R213 = R_0603
PR901 = R_2512_4P: room: ETY-ROOM
PR904-PR906 PR911 PR912 PR914 PR916 PR921 PR922 PR924-PR927 PR931 PR934 PR936 PR937 PR939 PR942-PR944 = R_0402: room: CHARGER
PR909 PR1011 = R_0805: room: CPU_CORE
PR915 PR928 PR935 = R0402_0OHM: room: CHARGER
PR917 PR918 = R_0603: room: CHARGER
PR923 = R_1206_4P-D: room: ETY-ROOM
PR929 = R_1206: room: CHARGER
PU1 = TS5A63157DCKR_SC70-6: room: P_DCIN
PU2 = LM393DR_SO8
PU101 = RT8205EGQW_WQFN24_4X4: room: ETY-ROOM
PU201 = RT8207MZQW_WQFN20_3X3: room: ETY-ROOM
PU301 PU302 = SY8033BDBC_DFN10_3X3: room: ETY-ROOM
PU401 PU501 = TPS51218DSCR_SON10_3X3: room: ETY-ROOM
PU601 = TPS51461RGER_QFN24_4X4: room: ETY-ROOM
PU701 PU703 = ISL6208BCRZ-T_QFN8_2X2: room: CPU_CORE
PU702 = ISL95835HRTZ-T_TQFN40_5X5: room: CPU_CORE
PU901 = BQ24745RHDR_QFN28_5X5: room: ETY-ROOM
PU902 = LM393DR_SO8: room: ETY-ROOM
PU903 UH3 = TC7SH08FU_SSOP5: room: PCH
PU1001 = CD3301RHHR_QFN36_6X6: room: ETY-ROOM
PWRSW1 = SHORTPADS: User Part Number: PART#; room: TOUCH.PAD
Q4 Q5 = SSM3K7002FU_SC70-3: room: MXM
Q12 = FDC655BN_NL_SSOT6: room: EDP
Q13 = DMN66D0LDW-7_SOT363-6: room: EDP
Q14-Q17 Q26 Q33 = MMBT3904WT1G_SC70-3: room: THERMAL
Q18 = SI3456DDV-T1-GE3_TSOP6: room: LVDS
Q19 = DMN66D0LDW-7_SOT363-6: room: LVDS
Q20 = PDTC124EU_SC70-3: room: LVDS
Q21 = FDC654P-G_SSOT-6: room: LVDS
Q22 = SSM3K7002FU_SC70-3: room: LVDS
Q23 = PDTC124EU_SC70-3: room: EDP
Q24 = PMV65XP_SOT23-3: room: CAM
Q25 = SI4800BDY-T1-E3_SO8: room: +3V_MXM SOURCE
Q27 = SI3456DDV-T1-GE3_TSOP6: room: +5V_HDD SOURCE
Q28 Q115 = PMST3904_SOT323-3: room: THERMAL
Q29 = DMN66D0LDW-7_SOT363-6: room: FFS
Q30 = SI3456DDV-T1-GE3_TSOP6: room: +5VMOD SOURCE
Q34 = SI3456DDV-T1-GE3_TSOP6: room: +3.3V_LAN SOURCE
Q36 = SSM3K7002FU_SC70-3: room: +5V_MXM SOURCE
Q38 = SI3456DDV-T1-GE3_TSOP6: room: WLAN
Q40 = SI3456DDV-T1-GE3_TSOP6: room: WWAN
Q44 = SI3456DDV-T1-GE3_TSOP6: room: WPAN
Q45 Q47 Q52 = SSM3K7002FU_SC70-3: room: KBC
Q46 = SI3456DDV-T1-GE3_TSOP6: room: FLASH
Q48 Q50 Q60 Q65-Q72 = SSM3K7002FU_SC70-3: room: DISCHARGE
Q49 = SI3456DDV-T1-GE3_TSOP6: room: +3.3V_ALW_PCH SOURCE
Q51 Q56 = DMN3030LSS-13_SOP8L-8
Q54 = SI3456DDV-T1-GE3_TSOP6: room: +3.3V_SUS SOURCE
Q55 = SSM3K7002FU_SC70-3: room: USB3.0
Q58 = SI3456DDV-T1-GE3_TSOP6: room: +3.3VM SOURCE
Q59 Q61 Q85 Q88 Q338 QH6 = SSM3K7002FU_SC70-3
Q63 = SI4164DY-T1-GE3_SO8: room: +1.05VRUN_SOURCE
Q73 Q77 = SSM3K7002FU_SC70-3: room: WWAN
Q74 Q78 Q84 Q318 Q321 = DMN66D0LDW-7_SOT363-6: room: LED
Q75 Q79 Q80 Q86 = PDTA114EU_SC70-3: room: LED
Q76 = SI4800BDY-T1-E3_SO8: room: +5V_MXM SOURCE
Q87 = SSM3K7002FU_SC70-3: room: MXM_PWR_SRC SOURCE
Q90 Q91 = PMV65XP_SOT23-3
Q110 Q113 Q326 Q335-Q337 Q339 Q340 = DMN66D0LDW-7_SOT363-6
Q124 Q310 = DMN66D0LDW-7_SOT363-6: room: WLAN
Q186 = SI4835DDY-T1-GE3_SO8: room: MXM_PWR_SRC SOURCE
Q294 = DMN66D0LDW-7_SOT363-6: room: +3V_MXM SOURCE
Q295 = DMN66D0LDW-7_SOT363-6: room: MXM
Q297 = DMN66D0LDW-7_SOT363-6: room: +3.3V_LAN SOURCE
Q300 = DMN66D0LDW-7_SOT363-6: room: +5V_HDD SOURCE
Q301 = DMN66D0LDW-7_SOT363-6: room: +5VMOD SOURCE
Q303 = DMN66D0LDW-7_SOT363-6: room: +3.3V_SUS SOURCE
Q304 = DMN66D0LDW-7_SOT363-6: room: +1.05VRUN_SOURCE
Q305 = DMN66D0LDW-7_SOT363-6: room: +3.3V_ALW_PCH SOURCE
Q306 = DMN66D0LDW-7_SOT363-6: room: +3.3VM SOURCE
Q311 = DMN66D0LDW-7_SOT363-6: room: WWAN
Q312 = DMN66D0LDW-7_SOT363-6: room: WPAN
Q313 = DMN66D0LDW-7_SOT363-6: room: FLASH
Q322 = DMN66D0LDW-7_SOT363-6: room: FLASH SW
QC1 = SSM3K7002FU_SC70-3: room: CPU
QC2 = BSS138W-7-F_SOT323-3: room: CPU
QC3 = AO4304L_SO8: room: +1.5V_CPU_VDDQ SOURCE
QC4 = NTR4503NT1G_SOT23-3: room: CPU
QC5 = DMN66D0LDW-7_SOT363-6: room: +1.5V_CPU_VDDQ SOURCE
QD1 QD2 = BSS138-G_SOT23-3: room: MEMORY
QH1 = BSS138W-7-F_SOT323-3: room: PCH
QH2 QH4 QH7 = SSM3K7002FU_SC70-3: room: PCH
QH5 = DMN66D0LDW-7_SOT363-6: room: PCH
R1-R5 R7 R8 R10 R11 R36 R37 R1971 R1972 = R_0402: room: MXM
R12 R15 R16 R18 R21-R34 R743-R746 R748-R754 R764 R784 R816 R1191 R1207 R1613 R1614 R1626 = R_0402: room: USB3.0
R13 R17 R457 R760 R761 R763 R765-R770 R772 R774-R778 R780 R782 R786-R791 R793-R795 R798 R800 R802-R805 R807 R888 R1582 = R_0402: room: SIO
R14 R35 = R_0402: room: SENSOR
R43 R44 R47 R48 R50 R52-R55 R421 = R_0402: room: CRT
R45 = R_1206: room: HDMI
R49 = R_1206: room: CRT
R56 R57 R59 R60 R62 = R_0402: room: DP
R158 R161 R162 R222 R336 R339 = R_0402: room: EDP
R159 R160 R412-R414 R422 R423 R1137 R1138 R1632 = R_0402: room: LVDS
R184 = R_1206: room: DP
R207 R208 = R0603_0OHM
R268 R274 R916 R927 R929 = R_0603: room: DISCHARGE
R269 R294 R301 R305 = R_0402: room: +3V_MXM SOURCE
R275 R278 = R_0402: room: +5V_MXM SOURCE
R289 R385 R388-R393 R395-R408 = R_0402: room: THERMAL
R418 R420 R585 R589 R759 R799 R810-R812 R814 R817-R825 R827-R829 R835 R836 R838 R841 R843 R845-R852 R854 R856 R858-R861 R863 R864 R869-R872 R875 R876 R879-R887 R889 R892 R893 R1118 R1125 R1156 R1177-R1179 R1197 R1622 R1623 = R_0402: room: KBC
R419 R427-R430 = R_0402: room: CAM
R451-R456 R458-R461 R1128 R1164 R1165 R1169 = R_0402: room: HDMI
R491 R492 = R_0402: room: DP_SW
R499 R500 R504 R505 R1621 R1624 = R_0402: room: +5V_HDD SOURCE
R501-R503 R506 R513 = R_0402: room: FFS
R514-R517 = R_0402: room: +5VMOD SOURCE
R545-R547 R549 R553 R554 R557 R561 R562 = R_0402: room: LAN
R548 = R_0805: room: LAN
R551 R552 R555 R1144 R1187 = R0402_0OHM: room: LAN
R563 = R_1206: room: +3.3V_LAN SOURCE
R564 R565 R1638 = R_0402: room: +3.3V_LAN SOURCE
R571-R574 R1167 R1170 R1171 = R_0402: room: LOM
R656-R660 R873 RE5 RE6 = R_0402: room: TPM
R700 R705 R706 R715-R718 R720 R1620 = R_0402: room: WLAN
R702 R703 R707 R709 = R0402_0OHM: room: WLAN
R704 R1157 R1158 = R0402_0OHM: room: WWAN
R713 = R0402_0OHM: room: FLASH
R719 R721-R723 R727 R1159 R1160 R1625 = R_0402: room: WWAN
R724 R730 = R0402_0OHM: room: WPAN
R731-R733 R735 R1628 = R_0402: room: WPAN
R734 R737-R739 R1629 = R_0402: room: FLASH
R736 R742 R783 = R_0402: room: ESATA
R740 R785 = R_0402: room: FLASH SW
R741 R771 R797 = R0402_0OHM: room: SIO
R755-R758 RE11 RE12 = R_0402: room: DOCKING
R762 R909 = R_0402: room: +1.5V_RUN_SOURCE
R781 = R0402_0OHM: room: +1.5V_RUN_SOURCE
R792 R796 = R_0402: room: ODD
R801 = R_0603: room: DP
R806 R911 R914 R915 R1618 = R_0402: room: +3.3V_SUS SOURCE
R808 = R0402_0OHM: room: +3.3V_SUS SOURCE
R815 R853 R855 R862 R867 R1068 R1180 = R0402_0OHM: room: KBC
R890 R891 R894 R895 R897-R901 R936 R963 RH345-RH350 = R_0402: room: FLASH ROM
R904 R1133 R1134 = R_0402: room: BT
R905 R907 R908 R1619 = R_0402: room: +3.3V_ALW_PCH SOURCE
R910 R913 = R_0402: room: +3V_5V_RUN SOURCE
R917-R919 R1617 = R_0402: room: +3.3VM SOURCE
R922-R926 R928 = R_0402: room: DISCHARGE
R930 R931 R1611 = R_0402: room: +1.05VRUN_SOURCE
R932 R934 R937-R939 R941-R944 R955 = R_0402: room: LED
R935 R940 = R_0402: room: MXM_PWR_SRC SOURCE
R1121-R1124 = R_0402: room: LVDS SW
R1970 = R0402_0OHM: room: MXM
RC1 RC2 RC4-RC7 RC14-RC16 RC19 RC20 RC22 RC23 RC26 RC30 RC33 RC37 RC38 RC41-RC67 RC70-RC72 RC74 RC75 RC78 RC80 RC81 RC84-RC89 RH1-RH4 = R_0402: room: CPU
RC3 RC8-RC11 RC21 = R_0402: room: XDP1
RC17 RC18 RC24 RC25 RC27 RC28 RC68 RC69 = R0402_0OHM: room: CPU
RC73 RC76 RC77 RC79 RC82 = R_0402: room: +1.5V_CPU_VDDQ SOURCE
RC83 = R0402_0OHM: room: +1.5V_CPU_VDDQ SOURCE
RD1 RD2 RD7 RD10 RD11 RD14-RD16 RD21-RD25 RD30-RD34 RD39 RD40 = R0402_0OHM: room: MEMORY
RD3-RD6 RD8 RD9 RD12 RD13 RD17-RD20 RD26-RD29 RD35-RD38 = R_0402: room: MEMORY
RH5-RH10 RH12-RH14 RH16-RH21 RH24 RH26 RH34 RH51 RH53 RH283-RH285 = R_0402: room: XDP2
RH11 RH15 RH22 RH23 RH25 RH27-RH31 RH35 RH38-RH50 RH52 RH54 RH59 RH66 RH74-RH81 RH87 RH91 RH94 RH97-RH100 RH102 RH103 RH105 RH106 RH111 RH112 RH114 RH118 RH123 RH124 RH126 RH127 RH129 RH131-RH134 RH137-RH142 RH144 RH149 RH151 RH152 RH158 RH160 RH163 RH164 RH170-RH175 RH177 RH178 RH181 RH183 RH203 RH208 RH213 RH253 RH256 RH262 RH263 RH266-RH274 RH278 RH282 RH287 RH298-RH306 RH311 RH313-RH319 RH321 RH324-RH333 RH337 RH342 RH344 RH353-RH355 RH358 = R_0402: room: PCH
RH82 RH83 RH85 RH86 RH88 RH90 RH92 RH93 RH95 RH96 RH113 RH116 RH117 RH120-RH122 RH150 RH201 RH259 RH280 RH281 RH286 RH290 RH307-RH310 RH312 RH320 RH323 RH334-RH336 RH338 RH339 RH341 RH343 RH356 RH359 = R0402_0OHM: room: PCH
RH195 RH200 RH215 RH248 RH276 = R_0805: room: PCH
RH202 RH205 = R0603_0OHM: room: PCH
RH204 RH211 RH288 = R_0603: room: PCH
RH247 = TAIYO_LB2012T1R0M_2P: room: PCH
RPH1 RPH2 = RP_1206_8P4R: room: PCH
T1-T53 = TPC12: room: CPU
T55 T60 T61 T64 T68-T80 T107 T109 = TPC12
T56-T59 T62 T63 T104 T106 T108 = TPC12: room: PCH
T117 = TPC12: room: SIO
T142 T143 = TPC12: room: LAN
T156 = TAIMA_IH-115-F_24P: room: LOM
U2 = SLGC55584AVTR_TDFN8_2X2: room: USB3.0
U3 = TC7SH125FU_SSOP5: room: LVDS
U4 = RT9818A-44GU3_SC70-3: room: KBC
U7 U50 = TC7SH08FU_SSOP5: room: KBC
U8 = SN74AHC1G08DCKR_SC70-5: room: MXM
U9 = PS8336BQFN56GTR-A0_QFN56_7X7: room: DP/HDMI MUX
U10 = TC7SH08FU_SSOP5: room: THERMAL
U11 U13 = TS3DV20812RHHR_VQFN36_6X6: room: LVDS SW
U12 = PI2DBS212ZHEX_TQFN28_5P5X3P5: room: FLASH SW
U14 U25 U27 = SN74AHC1G08DCKR_SC70-5
U15 = TC7SH08FU_SSOP5: room: LAN
U16 = 74AHC1G09GW_TSSOP5: room: MXM
U17 = 74AHC1G09GW_TSSOP5: room: DP
U18 = EMC4002-HZH-C_QFN48_7X7: room: THERMAL
U19 = MAX14885EETLLFT_TQFN40_5X5: room: CRT
U20 = PI3C3125LEX_TSSOP14: room: DP_SW
U21 = TC7SET04FU_SSOP5
U22 = PS8330BQFN48GTR-A0_QFN48_7X7
U26 = PS8520BTQFN20GTR2_TQFN20_4X4: room: HDD
U31 = 82579_QFN48_6X6: room: LAN
U32 = PI3L720ZHEX_TQFN42_9X3P5: room: LAN
U37 = SSX44-B-D-T1_TSSOP28: room: TPM
U39 = AT97SC3204-X2A14-AB_TSSOP28: room: TPM
U40 = SRV05-4PTCT_SOT23-6: room: SIM
U45 = TPS2560DRCR-PG1P1_SON10_3X3
U46 = ECE5048-LZY_DQFN132_11X11: room: SIO
U47 = TC7SH08FU_SSOP5: room: SIO
U48 = TPS2560DRCR-PG1P1_SON10_3X3: room: ESATA
U52 = W25Q64CVSSIG_SO8: room: FLASH ROM
U53 = W25Q32BVSSIG_SO8: room: FLASH ROM
U54 = MEC5055-LZY_DQFN132_11X11: room: KBC
U58 = TC7SH08FU_SSOP5: room: LED
U59 = INA211AIDCKRG4_SC70-6
U60 = INA219AIDCNRG4_SOT23-8
U88 = LNG3DMTR_LGA16_3X3: room: FFS
U625 U626 = PS8710BTQFN24GTR-A1_TQFN24_4X4: room: USB3.0
U627 = SN74AHC1G02DCKR_SC70-5
UC1 = 74AHC1G09GW_TSSOP5: room: CPU
UC2 = SN74LVC1G07DCKR_SC70-5: room: CPU
UC3 = 74AHC1G09GW_TSSOP5: room: PCH
UC4 = TC7SH08FU_SSOP5
UH4 = BD82PPSM-QNHN-A0_BGA_989P: room: PCH
Y3 = Y_X3G025000DI1H-H_4P: room: LAN
Y6 = Y_Q13FC1350000_2P: room: KBC
YH1 = Y_Q13FC1350000_2P: room: PCH
YH2 = Y_Q22FA2380049900_4P: room: PCH

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-T-R7_SOT363-6
  oval 0.381x1.397 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.725) 5(0.65,1.725) 6(0,1.725)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
82579_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 4.394x4.394 smd: 49(2.2,2.975)
ACES_50228-0037N-001_3P-T
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0)
  rect 1.194x1.803 smd: 4(-1.3,2.625) 5(3.3,2.625)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50228-0127N-001_12P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0) 9(-8,0) 10(-9,0) 11(-10,0) 12(-11,0)
  rect 1.194x1.803 smd: 13(1.3,2.525) 14(-12.3,2.525)
ACES_50238-0207N-002_20P-T
  oval 0.61x1.6 smd: 1(0,0) 2(0,5.6) 3(1,0) 4(1,5.6) 5(2,0) 6(2,5.6) 7(3,0) 8(3,5.6) 9(4,0) 10(4,5.6) 11(5,0) 12(5,5.6) 13(6,0) 14(6,5.6) 15(7,0) 16(7,5.6) 17(8,0) 18(8,5.6) 19(9,0) 20(9,5.6)
  rect 0.838x1.803 smd: 21(-1.325,3.2) 22(10.325,3.2)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50290-01101-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_50398-04071-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.194x3.2 smd: 41(-21.9,1.95) 45(2.4,1.95)
  rect 2.311x1.295 smd: 42(-18.65,3.9) 43(-9.75,3.9) 44(-0.85,3.9)
ACES_50554-02001-001_20P-T
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3) 13(6,0) 14(6.5,3) 15(7,0) 16(7.5,3) 17(8,0) 18(8.5,3) 19(9,0) 20(9.5,3)
  rect 0.787x1.499 smd: 21(-1,0) 22(-1,3) 23(10.5,0) 24(10.5,3)
ACES_87153-10411_10P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3)
  rect 0.787x1.499 smd: 11(5.5,3) 12(5.5,0) 13(-1,0) 14(-1,3)
AMPHE_G281010112CHR_10P
  oval 0.61x1.651 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0) 13(6,0) 15(7,0) 17(8,0) 19(9,0)
  oval 0.61x1.854 smd: 2(0,3.75) 4(1,3.75) 6(2,3.75) 8(3,3.75) 10(4,3.75) 12(5,3.75) 14(6,3.75) 16(7,3.75) 18(8,3.75) 20(9,3.75)
AO4304L_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
AT97SC3204-X2A14-AB_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
BAT54CW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAT1000-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BD82PPSM-QNHN-A0_BGA_989P
  round 0.33 smd: A4(-1.431,0) A5(-2.031,0) A6(-2.631,0) A44(-20.996,0) A45(-21.596,0) A46(-22.196,0) B3(-0.914,0.517) B47(-22.713,0.517) BD1(0,20.996) BD49(-23.627,20.996) BE1(0,21.596) BE49(-23.627,21.596) BF1(0,22.196) BF49(-23.627,22.196) BG2(-0.457,22.653) BG48(-23.17,22.653) BH3(-0.914,23.11) BH47(-22.713,23.11) BJ4(-1.431,23.627) BJ5(-2.031,23.627) BJ6(-2.631,23.627) BJ44(-20.996,23.627) BJ45(-21.596,23.627) BJ46(-22.196,23.627) C2(-0.457,0.974) C48(-23.17,0.974) D1(0,1.431) D49(-23.627,1.431) E1(0,2.031) E49(-23.627,2.031) F1(0,2.631) F49(-23.627,2.631)
  round 0.305 smd: A8(-3.393,0) A10(-4.384,0) A12(-5.375,0) A14(-6.365,0) A16(-7.356,0) A18(-8.346,0) A20(-9.337,0) A22(-10.328,0) A24(-11.318,0) A26(-12.309,0) A28(-13.299,0) A30(-14.29,0) A32(-15.281,0) A34(-16.271,0) A36(-17.262,0) A38(-18.252,0) A40(-19.243,0) A42(-20.234,0) AA2(-0.447,9.832) AA3(-1.234,9.832) AA16(-7.394,9.832) AA17(-8.156,9.832) AA19(-8.969,9.832) AA21(-9.782,9.832) AA23(-10.594,9.832) AA24(-11.407,9.832) AA26(-12.22,9.832) AA27(-13.033,9.832) AA29(-13.846,9.832) AA31(-14.658,9.832) AA33(-15.471,9.832) AA34(-16.233,9.832) AA47(-22.393,9.832) AA48(-23.18,9.832) AB1(0,10.328) AB3(-0.892,10.328) AB4(-1.577,10.328) AB5(-2.212,10.328) AB7(-2.847,10.328) AB8(-3.482,10.328) AB10(-4.117,10.328) AB11(-4.752,10.328) AB12(-5.413,10.328) AB13(-6.099,10.328) AB14(-6.784,10.328) AB36(-16.843,10.328) AB37(-17.529,10.328) AB38(-18.214,10.328) AB39(-18.875,10.328) AB40(-19.51,10.328) AB42(-20.145,10.328) AB43(-20.78,10.328) AB45(-21.415,10.328) AB46(-22.05,10.328) AB47(-22.736,10.328) AB49(-23.627,10.328) AC2(-0.447,10.823) AC16(-7.394,10.645) AC17(-8.156,10.645) AC19(-8.969,10.645) AC21(-9.782,10.645) AC23(-10.594,10.645) AC24(-11.407,10.645) AC26(-12.22,10.645) AC27(-13.033,10.645) AC29(-13.846,10.645) AC31(-14.658,10.645) AC33(-15.471,10.645) AC34(-16.233,10.645) AC48(-23.18,10.823) AD1(0,11.318) AD3(-0.892,11.318) AD4(-1.577,11.318) AD5(-2.212,11.318) AD7(-2.847,11.318) AD8(-3.482,11.318) AD10(-4.117,11.318) AD11(-4.752,11.318) AD12(-5.413,11.318) AD13(-6.099,11.318) AD14(-6.784,11.318) AD16(-7.394,11.458) AD17(-8.156,11.458) AD19(-8.969,11.458) AD21(-9.782,11.458) AD23(-10.594,11.458) AD24(-11.407,11.458) AD26(-12.22,11.458) AD27(-13.033,11.458) AD29(-13.846,11.458) AD31(-14.658,11.458) AD33(-15.471,11.458) AD34(-16.233,11.458) AD36(-16.843,11.318) AD37(-17.529,11.318) AD38(-18.214,11.318) AD39(-18.875,11.318) AD40(-19.51,11.318) AD42(-20.145,11.318) AD43(-20.78,11.318) AD45(-21.415,11.318) AD46(-22.05,11.318) AD47(-22.736,11.318) AD49(-23.627,11.318) AE2(-0.447,11.814) AE3(-1.234,11.814) AE47(-22.393,11.814) AE48(-23.18,11.814) AF1(0,12.309) AF3(-0.892,12.309) AF4(-1.577,12.309) AF5(-2.212,12.309) AF7(-2.847,12.309) AF8(-3.482,12.309) AF10(-4.117,12.309) AF11(-4.752,12.309) AF12(-5.413,12.309) AF13(-6.099,12.309) AF14(-6.784,12.309) AF16(-7.394,12.271) AF17(-8.156,12.271) AF19(-8.969,12.271) AF21(-9.782,12.271) AF23(-10.594,12.271) AF24(-11.407,12.271) AF26(-12.22,12.271) AF27(-13.033,12.271) AF29(-13.846,12.271) AF31(-14.658,12.271) AF33(-15.471,12.271) AF34(-16.208,12.271) AF36(-16.843,12.309) AF37(-17.529,12.309) AF38(-18.214,12.309) AF39(-18.875,12.309) AF40(-19.51,12.309) AF42(-20.145,12.309) AF43(-20.78,12.309) AF45(-21.415,12.309) AF46(-22.05,12.309) AF47(-22.736,12.309) AF49(-23.627,12.309) AG2(-0.447,12.804) AG16(-7.394,13.084) AG17(-8.156,13.084) AG19(-8.969,13.084) AG21(-9.782,13.084) AG23(-10.594,13.084) AG24(-11.407,13.084) AG26(-12.22,13.084) AG27(-13.033,13.084) AG29(-13.846,13.084) AG31(-14.658,13.084) AG33(-15.471,13.084) AG34(-16.233,13.084) AG48(-23.18,12.804) AH1(0,13.299) AH3(-0.892,13.299) AH4(-1.577,13.299) AH5(-2.212,13.299) AH7(-2.847,13.299) AH8(-3.482,13.299) AH10(-4.117,13.299) AH11(-4.752,13.299) AH12(-5.413,13.299) AH13(-6.099,13.299) AH14(-6.784,13.299) AH36(-16.843,13.299) AH37(-17.529,13.299) AH38(-18.214,13.299) AH39(-18.875,13.299) AH40(-19.51,13.299) AH42(-20.145,13.299) AH43(-20.78,13.299) AH45(-21.415,13.299) AH46(-22.05,13.299) AH47(-22.736,13.299) AH49(-23.627,13.299) AJ2(-0.447,13.795) AJ3(-1.234,13.795) AJ16(-7.394,13.896) AJ17(-8.156,13.896) AJ19(-8.969,13.896) AJ21(-9.782,13.896) AJ23(-10.594,13.896) AJ24(-11.407,13.896) AJ26(-12.22,13.896) AJ27(-13.033,13.896) AJ29(-13.846,13.896) AJ31(-14.658,13.896) AJ33(-15.471,13.896) AJ34(-16.233,13.896) AJ47(-22.393,13.795) AJ48(-23.18,13.795) AK1(0,14.29) AK3(-0.892,14.29) AK4(-1.577,14.29) AK5(-2.212,14.29) AK7(-2.847,14.29) AK8(-3.482,14.29) AK10(-4.117,14.29) AK11(-4.752,14.29) AK12(-5.413,14.29) AK13(-6.099,14.29) AK14(-6.784,14.29) AK36(-16.843,14.29) AK37(-17.529,14.29) AK38(-18.214,14.29) AK39(-18.875,14.29) AK40(-19.51,14.29) AK42(-20.145,14.29) AK43(-20.78,14.29) AK45(-21.415,14.29) AK46(-22.05,14.29) AK47(-22.736,14.29) AK49(-23.627,14.29) AL2(-0.447,14.785) AL16(-7.394,14.709) AL17(-8.156,14.709) AL19(-8.969,14.709) AL21(-9.782,14.709) AL23(-10.594,14.709) AL24(-11.407,14.709) AL26(-12.22,14.709) AL27(-13.033,14.709) AL29(-13.846,14.709) AL31(-14.658,14.709) AL33(-15.471,14.709) AL34(-16.233,14.709) AL48(-23.18,14.785) AM1(0,15.281) AM3(-0.892,15.281) AM4(-1.577,15.281) AM5(-2.212,15.281) AM7(-2.847,15.281) AM8(-3.482,15.281) AM10(-4.117,15.281) AM11(-4.752,15.281) AM12(-5.413,15.281) AM13(-6.099,15.281) AM14(-6.784,15.281) AM36(-16.843,15.281) AM37(-17.529,15.281) AM38(-18.214,15.281) AM39(-18.875,15.281) AM40(-19.51,15.281) AM42(-20.145,15.281) AM43(-20.78,15.281) AM45(-21.415,15.281) AM46(-22.05,15.281) AM47(-22.736,15.281) AM49(-23.627,15.281) AN2(-0.447,15.776) AN3(-1.234,15.776) AN16(-7.394,15.522) AN17(-8.156,15.522) AN19(-8.969,15.522) AN21(-9.782,15.522) AN23(-10.594,15.522) AN24(-11.407,15.522) AN26(-12.22,15.522) AN27(-13.033,15.522) AN29(-13.846,15.522) AN31(-14.658,15.522) AN33(-15.471,15.522) AN34(-16.233,15.522) AN47(-22.393,15.776) AN48(-23.18,15.776) AP1(0,16.271) AP3(-0.892,16.271) AP4(-1.577,16.271) AP5(-2.212,16.271) AP7(-2.847,16.271) AP8(-3.482,16.271) AP10(-4.117,16.271) AP11(-4.752,16.271) AP12(-5.413,16.271) AP13(-6.099,16.271) AP14(-6.784,16.271) AP16(-7.394,16.157) AP17(-8.346,16.157) AP19(-9.337,16.157) AP21(-10.328,16.157) AP23(-11.318,16.157) AP24(-12.309,16.157) AP26(-13.299,16.157) AP28(-14.29,16.157) AP30(-15.281,16.157) AP32(-16.233,16.157) AP36(-16.843,16.271) AP37(-17.529,16.271) AP38(-18.214,16.271) AP39(-18.875,16.271) AP40(-19.51,16.271) AP42(-20.145,16.271) AP43(-20.78,16.271) AP45(-21.415,16.271) AP46(-22.05,16.271) AP47(-22.736,16.271) AP49(-23.627,16.271) AR2(-0.447,16.767) AR48(-23.18,16.767) AT1(0,17.262) AT3(-0.892,17.262) AT4(-1.577,17.262) AT5(-2.212,17.262) AT7(-2.847,17.262) AT8(-3.482,17.262) AT10(-4.117,17.262) AT11(-4.752,17.262) AT12(-5.413,17.262) AT13(-6.099,17.262) AT16(-7.356,16.843) AT18(-8.346,16.843) AT20(-9.337,16.843) AT22(-10.328,16.843) AT24(-11.318,16.843) AT26(-12.309,16.843) AT28(-13.299,16.843) AT30(-14.29,16.843) AT32(-15.281,16.843) AT34(-16.271,16.843) AT38(-18.214,17.262) AT39(-18.875,17.262) AT40(-19.51,17.262) AT42(-20.145,17.262) AT43(-20.78,17.262) AT45(-21.415,17.262) AT46(-22.05,17.262) AT47(-22.736,17.262) AT49(-23.627,17.262) AU2(-0.447,17.757) AU3(-1.234,17.757) AU16(-7.356,17.529) AU18(-8.346,17.529) AU20(-9.337,17.529) AU22(-10.328,17.529) AU24(-11.318,17.529) AU26(-12.309,17.529) AU28(-13.299,17.529) AU30(-14.29,17.529) AU32(-15.281,17.529) AU34(-16.271,17.529) AU36(-17.262,17.529) AU47(-22.393,17.757) AU48(-23.18,17.757) AV1(0,18.252) AV3(-0.892,18.252) AV4(-1.577,18.252) AV5(-2.212,18.252) AV7(-2.847,18.252) AV8(-3.482,18.252) AV10(-4.117,18.252) AV11(-4.752,18.252) AV12(-5.413,18.252) AV14(-6.365,18.214) AV16(-7.356,18.214) AV18(-8.346,18.214) AV20(-9.337,18.214) AV22(-10.328,18.214) AV24(-11.318,18.214) AV26(-12.309,18.214) AV28(-13.299,18.214) AV30(-14.29,18.214) AV32(-15.281,18.214) AV34(-16.271,18.214) AV36(-17.262,18.214) AV38(-18.252,18.214) AV40(-19.51,18.252) AV42(-20.145,18.252) AV43(-20.78,18.252) AV45(-21.415,18.252) AV46(-22.05,18.252) AV47(-22.736,18.252) AV49(-23.627,18.252) AW2(-0.447,18.748) AW14(-6.365,18.875) AW16(-7.356,18.875) AW18(-8.346,18.875) AW20(-9.337,18.875) AW22(-10.328,18.875) AW24(-11.318,18.875) AW26(-12.309,18.875) AW28(-13.299,18.875) AW30(-14.29,18.875) AW32(-15.281,18.875) AW34(-16.271,18.875) AW36(-17.262,18.875) AW38(-18.252,18.875) AW40(-19.243,18.875) AW48(-23.18,18.748) AY1(0,19.243) AY3(-0.892,19.243) AY4(-1.577,19.243) AY5(-2.212,19.243) AY7(-2.847,19.243) AY8(-3.482,19.243) AY10(-4.117,19.243) AY11(-4.752,19.243) AY12(-5.375,19.51) AY14(-6.365,19.51) AY16(-7.356,19.51) AY18(-8.346,19.51) AY20(-9.337,19.51) AY22(-10.328,19.51) AY24(-11.318,19.51) AY26(-12.309,19.51) AY28(-13.299,19.51) AY30(-14.29,19.51) AY32(-15.281,19.51) AY34(-16.271,19.51) AY36(-17.262,19.51) AY38(-18.252,19.51) AY40(-19.243,19.51) AY42(-20.145,19.243) AY43(-20.78,19.243) AY45(-21.415,19.243) AY46(-22.05,19.243) AY47(-22.736,19.243) AY49(-23.627,19.243) B7(-2.898,0.538) B9(-3.889,0.447) B11(-4.879,0.447) B13(-5.87,0.447) B15(-6.861,0.447) B17(-7.851,0.447) B19(-8.842,0.447) B21(-9.832,0.447) B23(-10.823,0.447) B25(-11.814,0.447) B27(-12.804,0.447) B29(-13.795,0.447) B31(-14.785,0.447) B33(-15.776,0.447) B35(-16.767,0.447) B37(-17.757,0.447) B39(-18.748,0.447) B41(-19.738,0.447) B43(-20.729,0.538) BA2(-0.447,19.738) BA3(-1.234,19.738) BA47(-22.393,19.738) BA48(-23.18,19.738) BB1(0,20.234) BB3(-0.892,20.234) BB4(-1.577,20.234) BB5(-2.212,20.234) BB7(-2.847,20.234) BB10(-4.384,20.145) BB12(-5.375,20.145) BB14(-6.365,20.145) BB16(-7.356,20.145) BB18(-8.346,20.145) BB20(-9.337,20.145) BB22(-10.328,20.145) BB24(-11.318,20.145) BB26(-12.309,20.145) BB28(-13.299,20.145) BB30(-14.29,20.145) BB32(-15.281,20.145) BB34(-16.271,20.145) BB36(-17.262,20.145) BB38(-18.252,20.145) BB40(-19.243,20.145) BB43(-20.78,20.234) BB45(-21.415,20.234) BB46(-22.05,20.234) BB47(-22.736,20.234) BB49(-23.627,20.234) BC2(-0.538,20.729) BC8(-3.393,20.78) BC10(-4.384,20.78) BC12(-5.375,20.78) BC14(-6.365,20.78) BC16(-7.356,20.78) BC18(-8.346,20.78) BC20(-9.337,20.78) BC22(-10.328,20.78) BC24(-11.318,20.78) BC26(-12.309,20.78) BC28(-13.299,20.78) BC30(-14.29,20.78) BC32(-15.281,20.78) BC34(-16.271,20.78) BC36(-17.262,20.78) BC38(-18.252,20.78) BC40(-19.243,20.78) BC42(-20.234,20.78) BC48(-23.089,20.729) BD3(-0.892,21.224) BD4(-1.577,21.224) BD5(-2.212,21.224) BD46(-22.05,21.224) BD47(-22.736,21.224) BE8(-3.393,21.415) BE10(-4.384,21.415) BE12(-5.375,21.415) BE14(-6.365,21.415) BE16(-7.356,21.415) BE18(-8.346,21.415) BE20(-9.337,21.415) BE22(-10.328,21.415) BE24(-11.318,21.415) BE26(-12.309,21.415) BE28(-13.299,21.415) BE30(-14.29,21.415) BE32(-15.281,21.415) BE34(-16.271,21.415) BE36(-17.262,21.415) BE38(-18.252,21.415) BE40(-19.243,21.415) BE42(-20.234,21.415) BE44(-21.224,21.415) BF3(-0.892,22.215) BF6(-2.403,22.05) BF8(-3.393,22.05) BF10(-4.384,22.05) BF12(-5.375,22.05) BF14(-6.365,22.05) BF16(-7.356,22.05) BF18(-8.346,22.05) BF20(-9.337,22.05) BF22(-10.328,22.05) BF24(-11.318,22.05) BF26(-12.309,22.05) BF28(-13.299,22.05) BF30(-14.29,22.05) BF32(-15.281,22.05) BF34(-16.271,22.05) BF36(-17.262,22.05) BF38(-18.252,22.05) BF40(-19.243,22.05) BF42(-20.234,22.05) BF44(-21.224,22.05) BF47(-22.736,22.215) BG4(-1.412,22.736) BG6(-2.403,22.736) BG8(-3.393,22.736) BG9(-3.889,22.393) BG10(-4.384,22.736) BG12(-5.375,22.736) BG13(-5.87,22.393) BG14(-6.365,22.736) BG16(-7.356,22.736) BG17(-7.851,22.393) BG18(-8.346,22.736) BG20(-9.337,22.736) BG21(-9.832,22.393) BG22(-10.328,22.736) BG24(-11.318,22.736) BG25(-11.814,22.393) BG26(-12.309,22.736) BG28(-13.299,22.736) BG29(-13.795,22.393) BG30(-14.29,22.736) BG32(-15.281,22.736) BG33(-15.776,22.393) BG34(-16.271,22.736) BG36(-17.262,22.736) BG37(-17.757,22.393) BG38(-18.252,22.736) BG40(-19.243,22.736) BG41(-19.738,22.393) BG42(-20.234,22.736) BG44(-21.224,22.736) BG46(-22.215,22.736) BH7(-2.898,23.089) BH9(-3.889,23.18) BH11(-4.879,23.18) BH13(-5.87,23.18) BH15(-6.861,23.18) BH17(-7.851,23.18) BH19(-8.842,23.18) BH21(-9.832,23.18) BH23(-10.823,23.18) BH25(-11.814,23.18) BH27(-12.804,23.18) BH29(-13.795,23.18) BH31(-14.785,23.18) BH33(-15.776,23.18) BH35(-16.767,23.18) BH37(-17.757,23.18) BH39(-18.748,23.18) BH41(-19.738,23.18) BH43(-20.729,23.089) BJ8(-3.393,23.627) BJ10(-4.384,23.627) BJ12(-5.375,23.627) BJ14(-6.365,23.627) BJ16(-7.356,23.627) BJ18(-8.346,23.627) BJ20(-9.337,23.627) BJ22(-10.328,23.627) BJ24(-11.318,23.627) BJ26(-12.309,23.627) BJ28(-13.299,23.627) BJ30(-14.29,23.627) BJ32(-15.281,23.627) BJ34(-16.271,23.627) BJ36(-17.262,23.627) BJ38(-18.252,23.627) BJ40(-19.243,23.627) BJ42(-20.234,23.627) C4(-1.412,0.892) C6(-2.403,0.892) C8(-3.393,0.892) C9(-3.889,1.234) C10(-4.384,0.892) C12(-5.375,0.892) C13(-5.87,1.234) C14(-6.365,0.892) C16(-7.356,0.892) C17(-7.851,1.234) C18(-8.346,0.892) C20(-9.337,0.892) C21(-9.832,1.234) C22(-10.328,0.892) C24(-11.318,0.892) C25(-11.814,1.234) C26(-12.309,0.892) C28(-13.299,0.892) C29(-13.795,1.234) C30(-14.29,0.892) C32(-15.281,0.892) C33(-15.776,1.234) C34(-16.271,0.892) C36(-17.262,0.892) C37(-17.757,1.234) C38(-18.252,0.892) C40(-19.243,0.892) C41(-19.738,1.234) C42(-20.234,0.892) C44(-21.224,0.892) C46(-22.215,0.892) D3(-0.892,1.412) D6(-2.403,1.577) D8(-3.393,1.577) D10(-4.384,1.577) D12(-5.375,1.577) D14(-6.365,1.577) D16(-7.356,1.577) D18(-8.346,1.577) D20(-9.337,1.577) D22(-10.328,1.577) D24(-11.318,1.577) D26(-12.309,1.577) D28(-13.299,1.577) D30(-14.29,1.577) D32(-15.281,1.577) D34(-16.271,1.577) D36(-17.262,1.577) D38(-18.252,1.577) D40(-19.243,1.577) D42(-20.234,1.577) D44(-21.224,1.577) D47(-22.736,1.412) E6(-2.403,2.212) E8(-3.393,2.212) E10(-4.384,2.212) E12(-5.375,2.212) E14(-6.365,2.212) E16(-7.356,2.212) E18(-8.346,2.212) E20(-9.337,2.212) E22(-10.328,2.212) E24(-11.318,2.212) E26(-12.309,2.212) E28(-13.299,2.212) E30(-14.29,2.212) E32(-15.281,2.212) E34(-16.271,2.212) E36(-17.262,2.212) E38(-18.252,2.212) E40(-19.243,2.212) E42(-20.234,2.212) F3(-0.892,2.403) F4(-1.577,2.403) F45(-21.415,2.403) F46(-22.05,2.403) F47(-22.736,2.403) G2(-0.538,2.898) G8(-3.393,2.847) G10(-4.384,2.847) G12(-5.375,2.847) G14(-6.365,2.847) G16(-7.356,2.847) G18(-8.346,2.847) G20(-9.337,2.847) G22(-10.328,2.847) G24(-11.318,2.847) G26(-12.309,2.847) G28(-13.299,2.847) G30(-14.29,2.847) G32(-15.281,2.847) G34(-16.271,2.847) G36(-17.262,2.847) G38(-18.252,2.847) G40(-19.243,2.847) G42(-20.234,2.847) G48(-23.089,2.898) H1(0,3.393) H3(-0.892,3.393) H4(-1.577,3.393) H5(-2.212,3.393) H7(-2.847,3.393) H10(-4.384,3.482) H12(-5.375,3.482) H14(-6.365,3.482) H16(-7.356,3.482) H18(-8.346,3.482) H20(-9.337,3.482) H22(-10.328,3.482) H24(-11.318,3.482) H26(-12.309,3.482) H28(-13.299,3.482) H30(-14.29,3.482) H32(-15.281,3.482) H34(-16.271,3.482) H36(-17.262,3.482) H38(-18.252,3.482) H40(-19.243,3.482) H43(-20.78,3.393) H45(-21.415,3.393) H46(-22.05,3.393) H47(-22.736,3.393) H49(-23.627,3.393) J2(-0.447,3.889) J3(-1.234,3.889) J47(-22.393,3.889) J48(-23.18,3.889) K1(0,4.384) K3(-0.892,4.384) K4(-1.577,4.384) K5(-2.212,4.384) K7(-2.847,4.384) K10(-4.384,4.117) K12(-5.375,4.117) K14(-6.365,4.117) K16(-7.356,4.117) K18(-8.346,4.117) K20(-9.337,4.117) K22(-10.328,4.117) K24(-11.318,4.117) K26(-12.309,4.117) K28(-13.299,4.117) K30(-14.29,4.117) K32(-15.281,4.117) K34(-16.271,4.117) K36(-17.262,4.117) K38(-18.252,4.117) K39(-18.875,4.384) K40(-19.51,4.384) K42(-20.145,4.384) K43(-20.78,4.384) K45(-21.415,4.384) K46(-22.05,4.384) K47(-22.736,4.384) K49(-23.627,4.384) L2(-0.447,4.879) L10(-4.384,4.752) L12(-5.375,4.752) L14(-6.365,4.752) L16(-7.356,4.752) L18(-8.346,4.752) L20(-9.337,4.752) L22(-10.328,4.752) L24(-11.318,4.752) L26(-12.309,4.752) L28(-13.299,4.752) L30(-14.29,4.752) L32(-15.281,4.752) L34(-16.271,4.752) L36(-17.262,4.752) L48(-23.18,4.879) M1(0,5.375) M3(-0.892,5.375) M4(-1.577,5.375) M5(-2.212,5.375) M7(-2.847,5.375) M8(-3.482,5.375) M10(-4.117,5.375) M12(-5.375,5.362) M14(-6.365,5.464) M16(-7.356,5.464) M18(-8.346,5.413) M20(-9.337,5.413) M22(-10.328,5.413) M24(-11.318,5.413) M26(-12.309,5.413) M28(-13.299,5.413) M30(-14.29,5.413) M32(-15.281,5.413) M34(-16.271,5.413) M36(-17.262,5.464) M38(-18.214,5.375) M39(-18.875,5.375) M40(-19.51,5.375) M42(-20.145,5.375) M43(-20.78,5.375) M45(-21.415,5.375) M46(-22.05,5.375) M47(-22.736,5.375) M49(-23.627,5.375) N2(-0.447,5.87) N3(-1.234,5.87) N14(-6.365,6.099) N16(-7.356,6.099) N18(-8.346,6.099) N20(-9.337,6.099) N22(-10.328,6.099) N24(-11.318,6.099) N26(-12.309,6.099) N28(-13.299,6.099) N30(-14.29,6.099) N32(-15.281,6.099) N34(-16.271,6.099) N47(-22.393,5.87) N48(-23.18,5.87) P1(0,6.365) P3(-0.892,6.365) P4(-1.577,6.365) P5(-2.212,6.365) P7(-2.847,6.365) P8(-3.482,6.365) P10(-4.117,6.365) P11(-4.752,6.365) P12(-5.438,6.365) P16(-7.356,6.784) P18(-8.346,6.784) P20(-9.337,6.784) P22(-10.328,6.784) P24(-11.318,6.784) P26(-12.309,6.784) P28(-13.299,6.784) P30(-14.29,6.784) P32(-15.281,6.784) P34(-16.271,6.784) P37(-17.529,6.365) P38(-18.214,6.365) P39(-18.875,6.365) P40(-19.51,6.365) P42(-20.145,6.365) P43(-20.78,6.365) P45(-21.415,6.365) P46(-22.05,6.365) P47(-22.736,6.365) P49(-23.627,6.365) R2(-0.447,6.861) R48(-23.18,6.861) T1(0,7.356) T3(-0.892,7.356) T4(-1.577,7.356) T5(-2.212,7.356) T7(-2.847,7.356) T8(-3.482,7.356) T10(-4.117,7.356) T11(-4.752,7.356) T12(-5.413,7.356) T13(-6.099,7.356) T14(-6.759,7.356) T16(-7.394,7.394) T17(-8.156,7.394) T19(-8.969,7.394) T21(-9.782,7.394) T23(-10.594,7.394) T24(-11.407,7.394) T26(-12.22,7.394) T27(-13.033,7.394) T29(-13.846,7.394) T31(-14.658,7.394) T33(-15.471,7.394) T34(-16.233,7.394) T36(-16.843,7.356) T37(-17.529,7.356) T38(-18.214,7.356) T39(-18.875,7.356) T40(-19.51,7.356) T42(-20.145,7.356) T43(-20.78,7.356) T45(-21.415,7.356) T46(-22.05,7.356) T47(-22.736,7.356) T49(-23.627,7.356) U2(-0.447,7.851) U3(-1.234,7.851) U47(-22.393,7.851) U48(-23.18,7.851) V1(0,8.346) V3(-0.892,8.346) V4(-1.577,8.346) V5(-2.212,8.346) V7(-2.847,8.346) V8(-3.482,8.346) V10(-4.117,8.346) V11(-4.752,8.346) V12(-5.413,8.346) V13(-6.099,8.346) V14(-6.784,8.346) V16(-7.394,8.207) V17(-8.156,8.207) V19(-8.969,8.207) V21(-9.782,8.207) V23(-10.594,8.207) V24(-11.407,8.207) V26(-12.22,8.207) V27(-13.033,8.207) V29(-13.846,8.207) V31(-14.658,8.207) V33(-15.471,8.207) V34(-16.233,8.207) V36(-16.843,8.346) V37(-17.529,8.346) V38(-18.214,8.346) V39(-18.875,8.346) V40(-19.51,8.346) V42(-20.145,8.346) V43(-20.78,8.346) V45(-21.415,8.346) V46(-22.05,8.346) V47(-22.736,8.346) V49(-23.627,8.346) W2(-0.447,8.842) W16(-7.394,9.02) W17(-8.156,9.02) W19(-8.969,9.02) W21(-9.782,9.02) W23(-10.594,9.02) W24(-11.407,9.02) W26(-12.22,9.02) W27(-13.033,9.02) W29(-13.846,9.02) W31(-14.658,9.02) W33(-15.471,9.02) W34(-16.233,9.02) W48(-23.18,8.842) Y1(0,9.337) Y3(-0.892,9.337) Y4(-1.577,9.337) Y5(-2.212,9.337) Y7(-2.847,9.337) Y8(-3.482,9.337) Y10(-4.117,9.337) Y11(-4.752,9.337) Y12(-5.413,9.337) Y13(-6.099,9.337) Y14(-6.784,9.337) Y36(-16.843,9.337) Y37(-17.529,9.337) Y38(-18.214,9.337) Y39(-18.875,9.337) Y40(-19.51,9.337) Y42(-20.145,9.337) Y43(-20.78,9.337) Y45(-21.415,9.337) Y46(-22.05,9.337) Y47(-22.736,9.337) Y49(-23.627,9.337)
BELLW_80003-1121_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
BQ24745RHDR_QFN28_5X5
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2.001,0) 6(2.501,0) 7(3.001,0) 15(3.001,4.8) 16(2.501,4.8) 17(2.001,4.8) 18(1.5,4.8) 19(1,4.8) 20(0.5,4.8) 21(0,4.8)
  oval 1.194x0.254 smd: 8(3.9,0.9) 9(3.9,1.4) 10(3.9,1.9) 11(3.9,2.4) 12(3.9,2.9) 13(3.9,3.4) 14(3.9,3.9) 22(-0.9,3.9) 23(-0.9,3.4) 24(-0.9,2.9) 25(-0.9,2.4) 26(-0.9,1.9) 27(-0.9,1.4) 28(-0.9,0.9)
  rect 2.692x2.692 smd: 29(1.5,2.4)
BSS138-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
C_25CE100AX
  oval 1.778x3.683 smd: 1(0,0) 2(0,6.317)
C_0402
  rect 0.559x0.508 smd: 1(0,0) 2(0.95,0)
C_0603
  oval 0.864x1.219 smd: 1(0,0) 2(1.422,0)
C_0805
  oval 1.016x1.524 smd: 1(0,0) 2(1.93,0)
C_1206
  oval 1.016x1.524 smd: 1(0,0) 2(3.048,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_EEEFK1E101YP
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
C_MP2VLPS330MC4R2
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
C_MP6VLPS220MC4R2
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
C_SX
  rect 2.388x2.794 smd: 1(0,0) 2(6,0)
C_V
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
CD3301RHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
CHENG_OCE2012120YZF_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.7,0) 3(1.7,1.2) 4(0,1.2)
CHT_C8BBPH853025_2P
  rect 2.54x1.397 smd: 1(-3.81,0) 2(3.81,0)
CSD86350Q5D_SON8
  oval 2.032x0.889 smd: 1(0,0)
  oval 0.711x0.889 smd: 2(1.98,0) 3(3.3,0) 4(3.3,5.39) 5(1.98,5.39) 6(0.66,5.39) 7(-0.66,5.39)
  custom 0.883x0.883 smd: 8(1.32,2.695)
CYNTE_PCMB053T-1R0MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMC104T-1R0MN_2P
  rect 2.489x3.505 smd: 1(0,0) 2(9,0)
DA204U_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
DELTA_0603CS-120EJTS_2P
  rect 0.635x1.016 smd: 1(0,0) 2(1.28,0)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN3030LSS-13_SOP8L-8
  oval 0.635x1.829 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.17) 6(2.54,5.17) 7(1.27,5.17) 8(0,5.17)
DTC115EUA_SC70-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
ECE5048-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
