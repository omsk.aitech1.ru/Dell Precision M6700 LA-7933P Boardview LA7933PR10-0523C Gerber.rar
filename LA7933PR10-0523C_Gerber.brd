# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D50: length 87
  TOP w0.089: v3(92.4,76.92) 92.87,76.45 JCPU1.AT8
  TOP w0.14: v1(154.33,75.88) 154.33,75.87 155.1,75.1 JDIMM3.175
  IN3 w0.089: v3(92.4,76.92) 91.82,77.5 91.82,77.87
  IN3 w0.127: v1(154.33,75.88) 154.6,76.14 154.6,76.43 154.33,76.69 150.78,76.69 145.78,81.7 144.56,81.7 143.45,82.8 142.65,83.6 126.65,83.6 124.3,85.95 114.82,85.95 114.73,86.04 114.73,86.2 114.6,86.32 114.31,86.32 114.18,86.2 114.18,85.89 114.06,85.76 113.79,85.76 113.66,85.89 113.66,86.2 113.54,86.32 113.27,86.32 113.14,86.2 113.14,85.89 113.02,85.76 112.75,85.76 112.62,85.89 112.62,86.2 112.49,86.32 110.58,86.32 105.75,91.16 102.46,91.16 91.82,80.52 91.82,77.87
  BOTTOM w0.14: v1(154.33,75.88) 154.33,75.74 154.78,75.3 155.64,75.3 156.13,74.8 JDIMM4.174
DDR_B_D51: length 83.5
  TOP w0.089: JCPU1.AT9 91.87,76.45 v1(91.4,76.92)
  TOP w0.14: JDIMM3.177 156.03,75.7 v1(155.85,75.88)
  IN3 w0.089: 91.45,77.87 91.45,76.97 v1(91.4,76.92)
  IN3 w0.127: v1(155.85,75.88) 155.89,75.91 155.89,76.75 155.57,77.06 150.88,77.06 145.2,82.74 143.98,82.74 142.21,84.51 126.21,84.51 124.07,86.65 110.72,86.65 105.88,91.49 102.32,91.49 91.45,80.62 91.45,77.87
  BOTTOM w0.14: v1(155.85,75.88) 156.33,75.4 JDIMM4.176
DDR_B_D52: length 96.7
  TOP w0.089: v3(89.4,68.81) 89.43,68.81 89.79,68.45 JCPU1.AH11
  TOP w0.14: v1(154.33,72.83) 154.33,72.64 155.47,71.5 JDIMM3.163
  IN3 w0.089: 94.74,78.55 93.98,77.79 93.98,76.45 93.82,76.3 93.82,75.78 93.56,75.51 92.18,75.51 91.81,75.15 91.81,74.76 91.57,74.52 91.19,74.52 90.82,74.16 90.82,69.78 90.4,69.35 90.06,69.35 89.52,68.81 v3(89.4,68.81)
  IN3 w0.127: v1(154.33,72.83) 154.44,72.93 154.44,73.52 154.31,73.65 150.36,73.65 146.64,77.37 145.38,77.37 142.6,80.15 133.24,80.15 132.5,80.89 125.56,80.89 123.57,82.88 113.65,82.88 113.53,82.76 113.53,82.49 113.4,82.36 113.15,82.36 113.02,82.49 113.02,82.86 112.89,82.99 112.64,82.99 112.51,82.86 112.51,82.49 112.38,82.36 112.13,82.36 112,82.49 112,82.86 111.88,82.99 111.62,82.99 111.49,82.86 111.49,82.49 111.37,82.36 111.11,82.36 110.99,82.49 110.99,82.86 110.86,82.99 110.61,82.99 110.48,82.86 110.48,82.49 110.35,82.36 110.1,82.36 109.97,82.49 109.97,82.86 109.84,82.99 109.59,82.99 109.46,82.86 109.46,82.49 109.34,82.36 109.08,82.36 108.95,82.49 108.95,82.86 108.83,82.99 108.57,82.99 108.45,82.86 108.45,82.49 108.32,82.36 108.07,82.36 107.94,82.49 107.94,82.86 107.81,82.99 107.56,82.99 107.43,82.86 107.43,82.49 107.3,82.36 107.05,82.36 106.92,82.49 106.92,82.86 106.8,82.99 106.54,82.99 106.41,82.86 106.41,82.49 106.29,82.36 102.01,82.36 99.41,79.76 98.74,79.76 98.61,79.89 98.61,80.47 98.49,80.59 98.23,80.59 98.11,80.47 98.11,79.89 97.98,79.76 97.72,79.76 97.6,79.89 97.6,80.47 97.47,80.6 97.22,80.6 97.09,80.47 97.09,79.89 96.96,79.76 95.95,79.76 94.74,78.55
  BOTTOM w0.14: v1(154.33,72.83) 154.33,72.54 155.07,71.8 JDIMM4.164
DDR_B_D53: length 86
  TOP w0.089: v3(93.4,75.92) 92.9,75.42 JCPU1.AR8
  TOP w0.14: v1(155.85,72.83) 155.85,72.2 155.95,72.1 JDIMM3.165
  IN3 w0.089: 94.22,78.55 93.8,78.13 93.8,76.54 93.4,76.14 v3(93.4,75.92)
  IN3 w0.127: 94.22,78.55 96.57,80.9 97.08,80.9 97.19,81.01 97.19,81.58 97.32,81.71 97.57,81.71 97.7,81.58 97.7,81.01 97.83,80.89 98.08,80.89 98.21,81.01 98.21,81.58 98.34,81.71 98.59,81.71 98.72,81.58 98.72,81.01 98.83,80.9 99.15,80.9 99.27,81.03 99.27,81.47 99.4,81.6 99.71,81.6 99.83,81.47 99.83,81.03 99.96,80.9 100.08,80.9 101.87,82.69 105.97,82.69 106.08,82.81 106.08,83 106.4,83.32 123.61,83.32 125.7,81.22 132.63,81.22 133.13,80.73 137.12,80.73 137.43,81.04 140.32,81.04 140.88,80.48 142.73,80.48 145.51,77.7 146.83,77.7 147.91,76.62 150.52,74.01 154.77,74.01 154.89,73.89 154.89,73.4 155.02,73.27 155.27,73.27 155.4,73.4 155.4,73.89 155.53,74.01 157.07,74.01 157.2,73.89 157.2,72.27 157.07,72.15 155.8,72.15 155.68,72.27 155.68,72.65 v1(155.85,72.83)
  BOTTOM w0.14: JDIMM4.166 156.27,72.4 156.19,72.31 155.89,72.31 155.74,72.47 155.74,72.71 v1(155.85,72.83)
DDR_B_D54: length 95.7
  TOP w0.089: v1(88.41,68.92) 88.34,68.92 88.87,69.45 JCPU1.AJ12
  TOP w0.14: JDIMM3.174 150.4,74.8 151.28,75.68 v1(151.28,75.88)
  IN3 w0.089: 92.56,77.87 92.99,77.45 92.99,76.68 92.58,76.28 91.61,76.28 90.65,75.32 90.23,75.32 89.83,74.91 89.83,74.8 89.38,74.35 89.25,74.35 88.92,74.03 88.92,71.24 88.01,70.32 88.01,69.32 v1(88.41,68.92)
  IN3 w0.127: v1(151.28,75.88) 150.66,75.88 146.12,80.42 144.65,80.42 142.2,82.86 125.67,82.86 124.11,84.42 123.68,84.42 123.56,84.54 123.56,84.97 123.43,85.1 123.18,85.1 123.05,84.97 123.05,84.54 122.92,84.42 122.67,84.42 122.54,84.54 122.54,84.98 122.41,85.1 122.16,85.1 122.03,84.98 122.03,84.54 121.91,84.42 121.65,84.42 121.52,84.54 121.52,84.98 121.4,85.1 121.14,85.1 121.02,84.98 121.02,84.54 120.89,84.42 120.64,84.42 120.51,84.54 120.51,84.98 120.38,85.1 120.13,85.1 120,84.98 120,84.54 119.87,84.42 119.62,84.42 119.49,84.54 119.49,84.98 119.37,85.1 119.11,85.1 118.98,84.98 118.98,84.54 118.86,84.42 118.6,84.42 118.48,84.54 118.48,84.98 118.35,85.1 118.1,85.1 117.97,84.98 117.97,84.54 117.84,84.42 117.59,84.42 117.46,84.54 117.46,84.98 117.33,85.1 117.08,85.1 116.95,84.98 116.95,84.54 116.83,84.42 116.57,84.42 116.44,84.54 116.44,84.98 116.32,85.1 116.06,85.1 115.94,84.98 115.94,84.54 115.81,84.42 115.56,84.42 115.43,84.54 115.43,84.98 115.3,85.1 115.05,85.1 114.92,84.98 114.92,84.54 114.79,84.42 114.54,84.42 114.41,84.54 114.41,84.98 114.29,85.1 114.03,85.1 113.9,84.98 113.9,84.54 113.78,84.42 113.52,84.42 113.4,84.54 113.4,84.96 113.27,85.09 113.02,85.09 112.89,84.96 112.89,84.54 112.76,84.42 105.95,84.42 105.32,83.79 97.84,83.79 92.56,78.51 92.56,77.87
  BOTTOM w0.14: v1(151.28,75.88) 151.28,75.59 150.79,75.1 JDIMM4.175
DDR_B_D55: length 98.8
  TOP w0.089: JCPU1.AH12 88.9,68.44 v3(88.36,67.9)
  TOP w0.14: JDIMM3.176 150.16,75.4 151.2,76.44 152.24,76.44 v1(152.81,75.88)
  IN3 w0.089: 92.19,77.87 92.8,77.25 92.8,76.75 92.52,76.47 91.54,76.47 90.96,75.89 90.58,75.51 89.4,75.51 87.83,73.93 87.83,68.44 v3(88.36,67.9)
  IN3 w0.127: v1(152.81,75.88) 152.36,76.33 150.68,76.33 145.68,81.33 144.46,81.33 142.55,83.23 125.76,83.23 123.56,85.43 112.48,85.43 112.36,85.31 112.36,85.08 112.02,84.75 109.47,84.75 108.94,85.28 108.94,87.5 105.61,90.83 102.6,90.83 92.19,80.42 92.19,77.87
  BOTTOM w0.14: JDIMM4.177 150.23,75.7 150.91,76.38 152.3,76.38 v1(152.81,75.88)
DDR_B_D56: length 93
  TOP w0.089: JCPU1.AT11 89.93,76.45 90.4,76.92 v3(90.42,76.92)
  TOP w0.14: JDIMM3.180 150.47,76.6 150.77,76.91 151.31,76.91 152.24,77.83 v1(152.24,77.86)
  IN3 w0.089: 90.57,77.87 90.57,77.09 90.4,76.92 v3(90.42,76.92)
  IN3 w0.127: 90.57,77.87 90.57,80.81 102.01,92.25 106.2,92.25 111.04,87.41 124.38,87.41 125.46,86.34 126.12,86.34 126.25,86.21 126.25,85.55 126.37,85.43 126.63,85.43 126.75,85.55 126.75,86.21 126.88,86.34 127.13,86.34 127.26,86.21 127.26,85.4 127.39,85.28 127.64,85.28 127.77,85.4 127.77,86.21 127.9,86.34 128.15,86.34 128.28,86.21 128.28,85.4 128.4,85.28 128.66,85.28 128.79,85.4 128.79,86.21 128.91,86.34 129.17,86.34 129.29,86.21 129.29,85.4 129.42,85.28 129.67,85.28 129.8,85.4 129.8,86.21 129.93,86.34 130.18,86.34 130.31,86.21 130.31,85.5 130.44,85.37 130.69,85.37 130.82,85.5 130.82,85.73 130.94,85.85 132.41,85.85 132.89,86.34 138.05,86.34 138.46,86.74 141.11,86.74 144.3,83.55 145.47,83.55 150.33,78.69 151.4,78.69 v1(152.24,77.86)
  BOTTOM w0.14: v1(152.24,77.86) 152.24,77.79 151.35,76.9 JDIMM4.181
DDR_B_D57: length 96.4
  TOP w0.089: JCPU1.AN14 86.87,73.45 v3(86.4,73.92)
  TOP w0.14: JDIMM3.182 150.17,77.2 150.71,77.74 v1(150.71,77.86)
  IN3 w0.089: 91,77.87 91,76.63 90.73,76.36 89.18,76.36 88.89,76.07 88.89,75.4 87.22,73.72 86.6,73.72 v3(86.4,73.92)
  IN3 w0.127: v1(150.71,77.86) 150.69,77.86 145.37,83.18 144.15,83.18 141.73,85.6 141.22,85.6 141.1,85.73 141.1,86.29 140.97,86.41 138.6,86.41 138.06,85.87 138.06,85.07 137.93,84.94 137.6,84.94 137.47,85.07 137.47,85.88 137.34,86 137.09,86 136.96,85.88 136.96,85.07 136.84,84.94 136.58,84.94 136.45,85.07 136.45,85.88 136.33,86 136.07,86 135.95,85.88 135.95,85.07 135.82,84.94 135.57,84.94 135.44,85.07 135.44,85.88 135.31,86 135.06,86 134.93,85.88 134.93,85.07 134.8,84.94 134.55,84.94 134.42,85.07 134.42,85.88 134.3,86 134.04,86 133.91,85.88 133.91,85.07 133.79,84.94 133.53,84.94 133.41,85.07 133.41,85.88 133.28,86 133.03,86 132.9,85.88 132.9,85.07 132.77,84.94 126.39,84.94 124.25,87.08 110.9,87.08 106.06,91.92 102.14,91.92 91,80.78 91,77.87
  BOTTOM w0.14: JDIMM4.183 150.1,77.5 150.2,77.39 150.48,77.39 150.71,77.62 v1(150.71,77.86)
DDR_B_D58: length 94.9
  TOP w0.089: v3(86.41,75.96) 86.9,75.46 JCPU1.AR14
  TOP w0.14: JDIMM3.192 151.1,80.2 v1(152.5,81.6)
  IN3 w0.089: 86.08,77.87 85.97,77.75 85.97,76.39 v3(86.41,75.96)
  IN3 w0.127: 86.08,77.87 87.6,79.38 87.6,80.8 101.14,94.34 107.07,94.34 110.5,90.91 122.68,90.91 122.81,90.78 122.81,89.73 122.94,89.61 123.19,89.61 123.32,89.73 123.32,90.78 123.45,90.91 123.7,90.91 123.83,90.78 123.83,89.73 123.95,89.61 124.21,89.61 124.34,89.73 124.34,90.78 124.46,90.91 125.24,90.91 126.2,89.94 131.99,89.94 132.85,89.09 142.27,89.09 144.5,86.87 146.24,86.87 150.97,82.13 151.97,82.13 v1(152.5,81.6)
  BOTTOM w0.14: JDIMM4.191 150.82,79.9 150.82,79.92 v1(152.5,81.6)
DDR_B_D59: length 86.7
  TOP w0.089: JCPU1.AT14 86.87,76.45 v1(86.41,76.92)
  TOP w0.14: JDIMM3.194 150.65,80.8 150.98,81.13 v1(150.98,81.6)
  IN3 w0.089: 86.61,77.87 86.41,77.67 v1(86.41,76.92)
  IN3 w0.127: v1(150.98,81.6) 150.97,81.6 150.82,81.6 150.31,82.11 150.31,82.11 145.92,86.5 144.34,86.5 142.08,88.76 132.71,88.76 132.19,89.28 130.68,89.28 130.23,88.82 128.43,88.82 128.31,88.95 128.31,89.48 128.18,89.61 127.92,89.61 127.8,89.48 127.8,88.95 127.67,88.82 127.42,88.82 127.29,88.95 127.29,89.48 127.16,89.61 126.91,89.61 126.78,89.48 126.78,89.03 126.65,88.9 125.78,88.9 125.66,89.03 125.66,89.15 125.53,89.28 111.67,89.28 106.93,94.01 101.28,94.01 87.97,80.7 87.97,79.23 86.61,77.87
  BOTTOM w0.14: JDIMM4.193 150.17,80.5 150.98,81.31 v1(150.98,81.6)
DDR_B_D60: length 91.5
  TOP w0.089: JCPU1.AT12 88.9,76.52 89.4,77.02 v1(89.4,77.02)
  TOP w0.14: JDIMM3.181 156.08,76.9 155.28,77.7 v1(155.28,77.86)
  IN3 w0.089: v1(89.4,77.02) 89.56,77.19 89.56,77.87
  IN3 w0.127: 89.56,77.87 89.56,80.74 101.73,92.91 106.48,92.91 111.31,88.08 124.66,88.08 125.74,87 131.62,87 131.74,87.12 131.74,87.5 131.87,87.63 132.12,87.63 132.25,87.5 132.25,87.12 132.38,87 132.63,87 132.76,87.12 132.76,87.39 132.89,87.52 133.14,87.52 133.27,87.39 133.27,87.12 133.39,87 133.65,87 133.78,87.12 133.78,87.29 133.9,87.41 134.16,87.41 134.28,87.29 134.28,87.12 134.41,87 134.66,87 134.79,87.12 134.79,87.33 134.92,87.45 135.17,87.45 135.3,87.33 135.3,87.12 135.43,87 135.68,87 135.81,87.12 135.81,87.3 135.93,87.43 136.19,87.43 136.32,87.3 136.32,87.12 136.44,87 136.7,87 136.82,87.12 136.82,87.3 136.95,87.43 137.2,87.43 137.33,87.3 137.33,87.12 137.46,87 137.78,87 137.91,87.12 137.91,87.41 138.03,87.54 141.38,87.54 143.78,85.14 145.18,85.14 150.89,79.42 151.84,79.42 152.05,79.21 152.33,78.93 154.21,78.93 v1(155.28,77.86)
  BOTTOM w0.14: JDIMM4.180 156.06,76.6 155.28,77.38 v1(155.28,77.86)
DDR_B_D61: length 96.4
  TOP w0.089: v1(85.41,73.94) 85.9,73.45 JCPU1.AN15
  TOP w0.14: v1(153.76,77.86) 154.48,78.58 155.46,78.58 156.53,77.5 JDIMM3.183
  IN3 w0.089: v1(85.41,73.94) 85.8,74.32 87.56,74.32 88.69,75.45 88.69,76.12 89.11,76.54 89.8,76.54 89.93,76.67 89.93,77.87
  IN3 w0.127: v1(153.76,77.86) 153.05,78.56 152.18,78.56 151.79,78.95 151.68,79.06 150.43,79.06 145.55,83.93 144.38,83.93 141.11,87.21 138.46,87.21 137.92,86.67 132.52,86.67 132.4,86.54 132.4,86.31 132.27,86.18 131.93,86.18 131.8,86.31 131.8,86.54 131.67,86.67 131.26,86.67 131.13,86.54 131.13,86.37 131,86.25 130.75,86.25 130.62,86.37 130.62,86.54 130.5,86.67 125.6,86.67 124.52,87.74 111.17,87.74 106.34,92.58 101.87,92.58 89.93,80.64 89.93,77.87
  BOTTOM w0.14: v1(153.76,77.86) 154.55,78.65 155.32,78.65 155.83,78.15 155.83,77.41 156.03,77.2 JDIMM4.182
DDR_B_D62: length 94.7
  TOP w0.089: JCPU1.AR15 85.89,75.45 85.41,75.92 v1(85.41,75.92)
  TOP w0.14: JDIMM3.191 156.51,79.9 155.49,80.92 155.49,81.54 v1(155.55,81.6)
  IN3 w0.089: v1(85.41,75.92) 85.41,75.92 84.95,76.38 84.95,77.82
  IN3 w0.127: v1(155.55,81.6) 155.55,82.87 155.42,83 154.76,83 154.63,82.87 154.63,82.18 154.5,82.06 154.25,82.06 154.12,82.18 154.12,82.87 153.99,83 151.04,83 146.51,87.53 144.77,87.53 142.55,89.75 133.12,89.75 132.24,90.63 126.45,90.63 125.44,91.64 110.7,91.64 107.34,95 100.87,95 86.9,81.03 86.9,79.99 84.95,78.04 84.95,77.82
  BOTTOM w0.14: v1(155.55,81.6) 155.57,81.58 155.57,80.95 156.32,80.2 JDIMM4.192
DDR_B_D63: length 92.3
  TOP w0.089: v3(85.41,76.97) 85.9,76.48 JCPU1.AT15
  TOP w0.14: v1(154.03,81.6) 154.54,82.12 155.69,82.12 156.08,81.73 156.08,80.85 156.43,80.5 JDIMM3.193
  IN3 w0.089: v3(85.41,76.97) 85.41,77.81
  IN3 w0.127: v1(154.03,81.6) 153.1,82.53 151.04,82.53 146.37,87.2 144.63,87.2 142.41,89.42 132.98,89.42 132.13,90.27 126.34,90.27 125.3,91.31 110.57,91.31 107.21,94.67 101,94.67 87.23,80.9 87.23,79.63 85.41,77.81
  BOTTOM w0.14: v1(154.03,81.6) 154.52,82.09 155.7,82.09 156.07,81.73 156.07,81.13 156.4,80.8 JDIMM4.194
DDR_B_DQS0: length 95.1
  TOP w0.089: JCPU1.C7 93.44,42.99 v3(93.4,42.99)
  TOP w0.127: JDIMM3.12 150.13,23.8 150.19,23.86 150.19,24 150.3,24.12 150.69,24.12 151.12,23.69 151.12,23.39 150.58,22.85 150.58,22.54 150.84,22.28 151.9,22.28 152.07,22.44 152.07,22.73 151.97,22.84 151.88,22.84 v1(151.79,22.74)
  IN3 w0.089: v3(93.4,42.99) 93.62,43.21 93.62,43.46 93.55,43.54 93.25,43.54 93.07,43.71 93.02,43.71 92.85,43.55 92.85,43.39 92.99,43.25 92.99,42.77 93.17,42.58 93.7,42.58 93.99,42.29 93.99,41.75 94.19,41.55 94.81,41.55 96.48,39.88 96.48,39.69
  IN3 w0.127: v1(151.79,22.74) 151.93,22.74 152.32,22.35 152.32,22.23 152.05,21.96 149.54,21.96 147,19.42 142.41,19.42 140.19,17.2 137.88,17.2 136.6,18.48 133.28,18.48 132.78,18.99 132.08,18.99 131.62,19.45 125.95,19.45 125.38,20.03 122.48,20.03 121.96,19.51 121.26,19.51 120.62,20.14 119.29,20.14 119.14,20.3 112.15,20.3 109.16,23.28 109.16,24.06 107.2,26.02 100.52,26.02 96.83,29.71 96.83,39.34 96.48,39.69
  BOTTOM w0.14: JDIMM4.12 152.36,23.8 151.95,23.39 151.95,22.9 v1(151.79,22.74)
DDR_B_DQS1: length 86.6
  TOP w0.102: JCPU1.G3 97.9,47.42 v1(97.4,46.92)
  TOP w0.127: JDIMM3.29 156.42,28.9 156.18,28.66 155.33,28.66 155.13,28.46 155.13,28.19 155.03,28.09 154.73,28.09 154.57,28.25 154.57,28.54 154.44,28.66 153.66,28.66 153.54,28.79 153.54,28.96 153.71,29.14 v1(153.87,29.14)
  IN3 w0.089: 104.33,40.6 104.32,40.61 104.32,40.64 104.28,40.68 104.28,40.71 101.55,43.43 99.56,43.43 97.77,45.22 97.77,46.55 v1(97.4,46.92)
  IN3 w0.127: v1(153.87,29.14) 153.66,28.92 153.66,28.39 153.07,27.8 151.89,27.8 151.62,28.06 151.62,28.16 151.5,28.28 151.12,28.28 150.99,28.16 150.99,28.06 150.72,27.8 149.8,27.8 148,26 147.08,26 145.48,24.4 136.45,24.4 136.24,24.19 134.13,24.19 134.04,24.11 134.04,23.8 133.64,23.39 133.1,23.39 132.9,23.59 132.4,23.59 132.2,23.39 127.91,23.39 127.56,23.04 127,23.04 126.6,23.44 120.74,23.44 120.6,23.58 115.49,23.58 115.48,23.57 114.49,23.57 112.64,25.42 112.64,26.07 109.03,29.68 109.03,35.9 104.33,40.6
  BOTTOM w0.14: v1(153.87,29.14) 153.69,29.32 153.69,29.61 153.35,29.95 152,29.95 150.95,28.9 JDIMM4.29
DDR_B_DQS2: length 86.8
  TOP w0.089: v3(94.4,48.92) 94.9,49.42 JCPU1.J6
  TOP w0.127: v1(152.61,34.09) 152.75,34.23 152.75,34.56 153.05,34.85 154.44,34.85 155.05,34.24 156.05,34.24 156.11,34.3 JDIMM3.47
  IN3 w0.089: 104.49,45.41 102.64,47.26 101.63,47.26 101.57,47.32 100.81,48.09 98.42,48.09 98.42,48.1 98.33,48.1 97.81,48.62 97.81,49.12 97.59,49.33 94.35,49.33 94.3,49.28 94.3,49.03 v3(94.4,48.92)
  IN3 w0.127: v1(152.61,34.09) 152.73,34.09 152.89,34.25 152.89,34.44 152.79,34.54 151.23,34.54 148.61,31.92 144.88,31.92 142.86,29.9 136.9,29.9 135.44,28.45 132.39,28.45 131.71,27.77 121.42,27.77 120.86,28.33 115.36,28.33 112.54,31.14 112.54,37.36 104.49,45.41
  BOTTOM w0.14: v1(152.61,34.09) 152.7,34.09 152.94,33.85 152.94,33.62 152.87,33.55 151.47,33.55 151.4,33.63 151.4,33.99 151.14,34.24 150.63,34.24 150.39,33.99 150.28,33.99 150.22,34.06 150.22,34.22 150.13,34.3 JDIMM4.47
DDR_B_DQS3: length 81.9
  TOP w0.089: v3(97.4,52.94) 97.89,52.45 JCPU1.M3
  TOP w0.14: v1(152.88,39.29) 152.98,39.29 153.12,39.14 153.12,38.95 152.97,38.8 151.2,38.8 150.91,39.09 150.57,39.09 150.51,39.15 150.51,39.41 150.37,39.55 150.25,39.55 150.1,39.4 JDIMM3.64
  IN3 w0.089: 104.49,50.71 104.19,51.02 102.11,51.02 100.83,52.29 99.49,52.29 99,52.78 99,53.16 98.63,53.53 98.15,53.53 97.81,53.18 97.81,52.86 97.72,52.78 97.53,52.78 97.4,52.91 v3(97.4,52.94)
  IN3 w0.127: 104.49,50.71 116.29,38.91 116.29,35.4 117.42,34.27 117.43,34.27 118.75,32.94 120.13,32.94 120.65,32.41 122.74,32.41 123.27,32.94 125.28,32.94 125.83,32.39 126.22,32.39 126.69,32.86 128.7,32.86 129.77,33.92 135.2,33.92 136.7,35.43 142.43,35.43 144.39,37.39 148.69,37.39 150.11,38.81 152.92,38.81 153.11,39 153.11,39.13 152.95,39.29 v1(152.88,39.29)
  BOTTOM w0.14: JDIMM4.64 156.24,39.4 156.23,39.41 155.71,39.41 155.07,40.06 153.39,40.06 153.01,39.68 153.01,39.41 v1(152.88,39.29)
DDR_B_DQS4: length 77.3
  TOP w0.089: v1(95.4,72.92) 94.9,73.42 JCPU1.AN6
  TOP w0.14: JDIMM3.137 156.17,63.7 155.97,63.91 155.97,64.61 155.23,65.34 153.91,65.34 153.34,64.77 153.34,64.42 v1(153.24,64.32)
  IN3 w0.089: 103.78,75.12 103.14,75.12 101.33,73.32 100.02,73.32 99.86,73.48 98.87,73.48 98.7,73.32 98.27,73.32 98.01,73.06 98.01,72.6 97.74,72.33 97.71,72.33 97.71,72.32 96.16,72.32 95.83,72.65 95.83,73.06 95.76,73.13 95.61,73.13 v1(95.4,72.92)
  IN3 w0.127: 103.78,75.12 119.2,75.12 124.84,69.48 142.32,69.48 143.16,68.64 144.21,67.59 147.15,67.59 147.53,67.21 148.59,67.21 151.03,64.77 153.31,64.77 153.41,64.67 153.41,64.49 v1(153.24,64.32)
  BOTTOM w0.14: v1(153.24,64.32) 153.36,64.32 153.69,63.98 153.69,63.86 153.41,63.58 150.49,63.58 150.31,63.39 150.24,63.39 150.18,63.45 150.18,63.65 150.13,63.7 JDIMM4.137
DDR_B_DQS5: length 87.1
  TOP w0.089: v1(92.4,73.92) 92.9,74.42 JCPU1.AP8
  TOP w0.14: v1(152.24,69.32) 152.35,69.32 152.8,68.86 152.92,68.86 153.12,68.66 153.12,68.47 153.03,68.38 152.51,68.38 152.06,68.83 151.29,68.83 150.84,68.38 150.44,68.38 150.26,68.56 150.26,68.69 150.15,68.8 JDIMM3.154
  IN3 w0.089: v1(92.4,73.92) 92.4,73.65 92.29,73.53 92.13,73.53 92.01,73.65 92.01,74.09 92.24,74.32 92.68,74.32 93,74 93.86,74 94.19,74.33 94.7,74.33 95.26,74.88 95.51,74.88 97.13,76.5 97.79,76.5 98.31,77.02 100.56,77.02 102.09,78.55
  IN3 w0.127: 102.09,78.55 103.12,79.58 119.85,79.58 124.35,75.08 132.5,75.08 132.76,75.34 132.76,76.17 132.89,76.29 133.27,76.29 133.4,76.17 133.4,75.34 133.66,75.08 134.24,75.08 134.5,75.34 134.5,76.17 134.63,76.29 135.01,76.29 135.14,76.17 135.14,75.34 135.4,75.08 136.22,75.08 136.49,75.34 136.49,76.06 136.66,76.23 141.18,76.23 143.64,73.77 146.02,73.77 149.07,70.72 150.08,70.72 150.95,69.86 152.36,69.86 152.49,69.73 152.49,69.47 152.33,69.32 v1(152.24,69.32)
  BOTTOM w0.14: JDIMM4.154 155.61,68.8 155.23,69.18 154.94,69.18 153.96,70.16 152.76,70.16 152.39,69.78 152.39,69.46 v1(152.24,69.32)
DDR_B_DQS6: length 97.2
  TOP w0.089: JCPU1.AK11 89.9,70.43 v1(89.4,69.94)
  TOP w0.127: JDIMM3.171 155.66,73.9 154.19,75.38 152.98,75.38 152.58,74.98 152.58,74.72 v1(152.43,74.56)
  IN3 w0.089: v1(89.4,69.94) 89.4,69.72 89.28,69.6 88.94,69.6 88.81,69.72 88.81,69.93 89.21,70.33 89.78,70.33 90,70.56 90,74.09 90.23,74.32 90.67,74.32 90.99,74.64 90.99,75.09 91.75,75.85 92.73,75.85 93.55,76.67 93.55,78.55
  IN3 w0.127: 93.55,78.55 97.14,82.14 98.34,82.14 98.6,82.41 98.6,83 98.73,83.12 99.29,83.12 99.42,83 99.42,82.32 99.68,82.06 100.26,82.06 100.53,82.32 100.53,83.02 100.63,83.12 105.6,83.12 106.22,83.75 123.78,83.75 125.88,81.65 126.99,81.65 127.25,81.92 127.25,82.07 127.38,82.2 127.76,82.2 127.89,82.07 127.89,81.92 128.15,81.65 129.28,81.65 129.53,81.91 129.53,82.06 129.66,82.18 130.04,82.18 130.16,82.06 130.16,81.92 130.43,81.65 131.06,81.65 131.33,81.92 131.33,82.07 131.46,82.2 131.9,82.2 132.03,82.07 132.03,81.88 132.25,81.65 133.57,81.65 133.68,81.54 133.68,81.41 133.94,81.16 134.61,81.16 134.88,81.43 134.88,82.07 135.01,82.2 135.49,82.2 135.62,82.07 135.62,81.43 135.89,81.16 136.77,81.16 136.96,81.35 136.96,81.47 137.03,81.54 140.43,81.54 140.99,80.98 141.35,80.98 141.55,81.18 141.55,81.46 141.68,81.59 142.01,81.59 142.14,81.46 142.14,81.21 142.39,80.96 142.86,80.96 145.69,78.13 147.01,78.13 150.13,75.01 152.23,75.01 152.43,74.81 v1(152.43,74.56)
  BOTTOM w0.14: v1(152.43,74.56) 152.64,74.56 152.75,74.45 152.75,74.36 152.9,74.21 152.9,73.9 152.82,73.83 152.73,73.83 152.54,74.01 151.57,74.01 151.15,74.44 150.79,74.44 150.52,74.17 150.52,73.74 150.37,73.59 150.28,73.59 150.2,73.67 150.2,73.8 150.1,73.9 JDIMM4.171
DDR_B_DQS7: length 97.6
  TOP w0.089: JCPU1.AP14 86.9,74.46 v1(86.41,74.95)
  TOP w0.127: JDIMM3.188 150.1,79 150.23,78.87 150.23,78.78 150.29,78.72 150.4,78.72 151.18,79.49 153.36,79.49 153.47,79.59 153.47,79.92 153.3,80.09 v1(153.12,80.09)
  IN3 w0.089: v1(86.41,74.95) 86.41,74.67 86.29,74.56 86.17,74.56 85.98,74.75 85.98,75.08 86.24,75.35 88.07,75.35 88.07,75.35 88.09,75.35 88.34,75.6 88.34,76.67 88.84,77.17 88.84,78.55
  IN3 w0.127: v1(153.12,80.09) 153.12,80.1 153.5,80.48 153.5,80.73 153.38,80.86 150.07,80.86 145.24,85.69 144.01,85.69 141.6,88.09 132.18,88.09 131.98,88.29 131.98,88.55 131.91,88.61 130.96,88.61 130.5,88.15 125.59,88.15 125.13,88.61 111.39,88.61 106.65,93.34 101.55,93.34 88.84,80.63 88.84,78.55
  BOTTOM w0.14: v1(153.12,80.09) 153.25,80.22 153.25,80.46 153.6,80.81 155.05,80.81 155.8,80.06 155.8,79.29 156.09,79 JDIMM4.188
DDR_B_DQS#0: length 95.2
  TOP w0.102: v1(93.4,43.95) 93.9,44.44 JCPU1.D7
  TOP w0.127: JDIMM3.10 149.96,23.2 150.52,23.77 150.68,23.77 150.8,23.65 150.8,23.42 150.33,22.95 150.33,22.39 150.68,22.04 152.06,22.04 152.39,22.37 152.39,22.57 v1(152.56,22.74)
  IN3 w0.089: v1(93.4,43.95) 93.37,43.91 92.93,43.91 92.65,43.63 92.65,43.31 92.8,43.17 92.8,42.68 93.09,42.39 93.62,42.39 93.79,42.21 93.79,42.18 93.8,42.18 93.8,41.66 94.12,41.34 94.74,41.34 95.22,40.85 95.22,40.61 96.15,39.69
  IN3 w0.127: v1(152.56,22.74) 152.56,22.13 152.15,21.72 149.64,21.72 147.09,19.18 142.51,19.18 140.29,16.96 137.79,16.96 136.5,18.24 133.19,18.24 132.68,18.75 131.99,18.75 131.52,19.22 125.85,19.22 125.28,19.79 122.58,19.79 122.06,19.27 121.16,19.27 120.53,19.91 119.19,19.91 119.04,20.06 112.05,20.06 108.93,23.19 108.93,23.96 107.1,25.79 100.42,25.79 96.59,29.62 96.59,39.24 96.15,39.69
  BOTTOM w0.14: v1(152.56,22.74) 152.33,22.74 152.26,22.82 152.26,23.25 152.55,23.55 155.88,23.55 155.99,23.43 155.99,23.22 156.07,23.14 156.19,23.14 156.25,23.2 JDIMM4.10
DDR_B_DQS#1: length 86.7
  TOP w0.102: JCPU1.F3 97.93,46.45 v3(98.4,46.92)
  TOP w0.127: v1(153.11,29.14) 153.28,28.97 153.28,28.69 153.57,28.4 154.24,28.4 154.32,28.32 154.32,28.15 154.63,27.84 155.15,27.84 155.38,28.07 155.38,28.33 155.43,28.39 156.22,28.39 156.31,28.3 JDIMM3.27
  IN3 w0.089: v3(98.4,46.92) 98.4,47.04 98.28,47.16 98.09,47.16 97.97,47.04 97.97,45.3 99.64,43.63 101.63,43.63 104.49,40.77
  IN3 w0.127: 104.49,40.77 109.26,36 109.26,29.78 112.88,26.17 112.88,25.52 114.58,23.81 115.39,23.81 115.39,23.81 120.7,23.81 120.84,23.67 126.7,23.67 127.09,23.28 127.47,23.28 127.82,23.63 132.1,23.63 132.23,23.76 132.23,23.76 132.29,23.83 133,23.83 133.2,23.63 133.54,23.63 133.81,23.89 133.81,24.21 134.03,24.43 136.15,24.43 136.35,24.64 145.34,24.64 146.97,26.27 147.93,26.27 149.7,28.04 150.63,28.04 150.75,28.16 150.75,28.25 151.02,28.52 151.59,28.52 151.86,28.25 151.86,28.16 151.99,28.04 152.97,28.04 153.42,28.49 153.42,29.02 153.3,29.14 v1(153.11,29.14)
  BOTTOM w0.14: v1(153.11,29.14) 153.26,29.14 153.43,29.31 153.43,29.51 153.25,29.69 152.11,29.69 151.03,28.62 150.42,28.62 150.33,28.53 150.33,28.37 150.26,28.3 JDIMM4.27
DDR_B_DQS#2: length 86.8
  TOP w0.089: v1(94.4,49.92) 94.9,50.42 JCPU1.K6
  TOP w0.127: v1(153.38,34.09) 153.18,34.09 153.03,34.24 153.03,34.44 153.16,34.57 154.33,34.57 154.93,33.96 156.04,33.96 156.11,33.9 156.11,33.76 156.16,33.7 JDIMM3.45
  IN3 w0.089: v1(94.4,49.92) 94.4,49.84 94.72,49.52 97.73,49.52 98,49.26 98,48.73 98.42,48.3 100.88,48.3 101.71,47.46 102.77,47.46 104.13,46.11 104.13,46.1 104.49,45.74
  IN3 w0.127: v1(153.38,34.09) 153.13,34.34 153.13,34.54 152.89,34.78 151.14,34.78 148.51,32.16 144.78,32.16 142.76,30.14 136.8,30.14 135.34,28.68 132.3,28.68 131.62,28 121.52,28 120.96,28.56 115.45,28.56 112.78,31.24 112.78,37.46 104.49,45.74
  BOTTOM w0.14: JDIMM4.45 150.51,33.7 150.75,33.95 151,33.95 151.1,33.85 151.1,33.51 151.35,33.26 153,33.26 153.22,33.49 153.22,33.94 v1(153.38,34.09)
DDR_B_DQS#3: length 81.8
  TOP w0.089: JCPU1.N3 97.9,53.43 v1(98.39,52.94)
  TOP w0.14: v1(153.65,39.29) 153.54,39.18 153.54,38.98 153.07,38.51 151.08,38.51 150.79,38.8 JDIMM3.62
  IN3 w0.089: 104.49,50.38 104.08,50.79 102.04,50.79 101.8,51.03 100.74,52.08 99.42,52.08 98.8,52.69 98.8,53.08 98.55,53.33 98.23,53.33 98,53.1 98,52.9 98.1,52.8 98.27,52.8 98.39,52.93 v1(98.39,52.94)
  IN3 w0.127: 104.49,50.38 116.05,38.82 116.05,35.3 117.32,34.03 117.33,34.03 118.66,32.7 120.03,32.7 120.56,32.17 122.84,32.17 123.37,32.7 125.18,32.7 125.73,32.15 126.32,32.15 126.79,32.62 128.8,32.62 129.86,33.69 135.3,33.69 136.8,35.19 142.53,35.19 144.49,37.15 148.79,37.15 150.21,38.57 153.02,38.57 153.35,38.9 153.35,38.99 v1(153.65,39.29)
  BOTTOM w0.14: JDIMM4.62 156.22,38.8 156.16,38.86 156.16,39.05 156.09,39.12 155.59,39.12 154.94,39.76 153.47,39.76 153.36,39.66 153.36,39.46 153.54,39.29 v1(153.65,39.29)
DDR_B_DQS#4: length 77.2
  TOP w0.089: v3(96.4,72.92) 95.9,73.42 JCPU1.AN5
  TOP w0.14: v1(154,64.32) 153.85,64.32 153.63,64.54 153.63,64.65 154.03,65.05 155.11,65.05 155.64,64.52 155.64,63.75 155.95,63.44 156.11,63.44 156.2,63.35 156.2,63.2 156.29,63.1 JDIMM3.135
  IN3 w0.089: 104.11,75.36 104.11,75.36 103.76,75.36 103.71,75.32 103.05,75.32 101.26,73.53 100.11,73.53 99.95,73.69 98.78,73.69 98.61,73.52 98.14,73.52 97.81,73.19 97.81,72.7 97.62,72.52 96.24,72.52 96.02,72.73 96.02,72.89 96.09,72.96 96.36,72.96 v3(96.4,72.92)
  IN3 w0.127: v1(154,64.32) 153.78,64.32 153.68,64.42 153.68,64.74 153.39,65.02 151.11,65.02 148.68,67.45 147.62,67.45 147.24,67.83 144.31,67.83 143.39,68.74 142.41,69.72 124.93,69.72 119.29,75.36 104.11,75.36
  BOTTOM w0.14: JDIMM4.135 150.4,63.1 150.58,63.28 153.54,63.28 153.99,63.73 153.99,64.3 v1(154,64.32)
DDR_B_DQS#5: length 87
  TOP w0.089: JCPU1.AP9 91.9,74.42 v3(91.4,73.92)
  TOP w0.14: v1(153.01,69.32) 153.01,69.23 153.41,68.82 153.41,68.35 153.15,68.09 152.39,68.09 151.93,68.54 151.41,68.54 150.96,68.09 150.25,68.09 150.14,68.2 JDIMM3.152
  IN3 w0.089: v3(91.4,73.92) 91.55,73.92 92.15,74.51 92.78,74.51 93.09,74.21 93.78,74.21 94.11,74.54 94.61,74.54 95.17,75.1 95.42,75.1 97.04,76.71 97.71,76.71 98.22,77.23 100.43,77.23 101.35,78.15 101.75,78.55
  IN3 w0.127: 101.75,78.55 103.02,79.82 119.94,79.82 124.45,75.32 132.4,75.32 132.53,75.44 132.53,76.27 132.79,76.53 133.37,76.53 133.63,76.27 133.63,75.44 133.76,75.32 134.14,75.32 134.27,75.44 134.27,76.27 134.53,76.53 135.11,76.53 135.38,76.27 135.38,75.44 135.5,75.31 136.13,75.31 136.25,75.44 136.25,76.16 136.56,76.47 141.27,76.47 143.73,74.01 146.12,74.01 149.17,70.96 150.18,70.96 151.04,70.09 152.46,70.09 152.72,69.83 152.72,69.51 152.92,69.32 v1(153.01,69.32)
  BOTTOM w0.14: JDIMM4.152 156.21,68.2 156.13,68.28 156.13,68.44 156.07,68.51 155.49,68.51 155.11,68.89 154.82,68.89 153.84,69.86 152.88,69.86 152.68,69.66 152.68,69.46 152.82,69.32 v1(153.01,69.32)
DDR_B_DQS#6: length 97.2
  TOP w0.089: JCPU1.AK12 88.9,70.44 88.4,69.94 v3(88.41,69.94)
  TOP w0.127: v1(153.19,74.56) 153.15,74.52 153,74.52 152.86,74.66 152.86,74.87 153.09,75.1 154.07,75.1 155.55,73.62 156.05,73.62 156.37,73.3 JDIMM3.169
  IN3 w0.089: v3(88.41,69.94) 88.51,69.94 89.1,70.52 89.69,70.52 89.81,70.65 89.81,74.18 90.14,74.51 90.58,74.51 90.8,74.73 90.8,75.18 91.68,76.06 92.66,76.06 93.21,76.61 93.21,78.55 93.21,78.55
  IN3 w0.127: v1(153.19,74.56) 152.47,75.28 150.2,75.28 147.11,78.37 145.79,78.37 142.96,81.2 142.49,81.2 142.38,81.31 142.38,81.56 142.11,81.82 141.58,81.82 141.32,81.56 141.32,81.28 141.26,81.22 141.09,81.22 140.53,81.78 136.93,81.78 136.73,81.57 136.73,81.45 136.67,81.4 135.98,81.4 135.86,81.52 135.86,82.17 135.59,82.43 134.91,82.43 134.64,82.17 134.64,81.52 134.52,81.4 134.03,81.4 133.92,81.51 133.92,81.64 133.67,81.89 132.35,81.89 132.27,81.97 132.27,82.17 132,82.43 131.36,82.43 131.09,82.17 131.09,82.02 130.97,81.89 130.53,81.89 130.4,82.02 130.4,82.15 130.13,82.42 129.56,82.42 129.29,82.15 129.29,82 129.18,81.89 128.25,81.89 128.13,82.02 128.13,82.17 127.86,82.43 127.28,82.43 127.02,82.17 127.02,82.02 126.89,81.89 125.98,81.89 123.88,83.98 106.13,83.98 105.5,83.36 100.53,83.36 100.29,83.12 100.29,82.42 100.16,82.29 99.78,82.29 99.65,82.42 99.65,83.09 99.39,83.36 98.63,83.36 98.37,83.09 98.37,82.51 98.24,82.38 97.04,82.38 93.21,78.55
  BOTTOM w0.14: v1(153.19,74.56) 153.19,73.78 152.94,73.53 152.61,73.53 152.42,73.72 151.45,73.72 151.03,74.14 150.91,74.14 150.81,74.05 150.81,73.62 150.49,73.3 JDIMM4.169
DDR_B_DQS#7: length 97.6
  TOP w0.089: v3(85.41,74.98) 85.41,74.98 85.9,74.49 JCPU1.AP15
  TOP w0.127: v1(153.89,80.09) 153.74,79.95 153.74,79.48 153.5,79.24 153.49,79.24 151.33,79.24 150.5,78.4 JDIMM3.186
  IN3 w0.089: 88.6,78.55 88.6,77.21 88.13,76.74 88.13,75.69 87.98,75.55 86.1,75.55 85.75,75.2 85.75,75.01 85.72,74.98 v3(85.41,74.98)
  IN3 w0.127: v1(153.89,80.09) 153.89,80.1 153.74,80.24 153.74,80.82 153.47,81.09 150.21,81.09 145.35,85.95 144.07,85.95 141.7,88.33 132.28,88.33 132.21,88.39 132.21,88.64 132.01,88.84 130.86,88.84 130.41,88.39 125.69,88.39 125.23,88.84 111.49,88.84 106.75,93.58 101.46,93.58 88.6,80.73 88.6,78.55
  BOTTOM w0.14: JDIMM4.186 156.21,78.4 156.08,78.53 156.08,78.65 155.55,79.19 155.55,79.95 154.95,80.54 153.73,80.54 153.6,80.42 153.6,80.23 153.77,80.06 153.86,80.06 v1(153.89,80.09)
DDR_B_MA0: length 92.1
  TOP w0.089: v3(92.4,60.96) 92.36,60.96 92.86,61.45 JCPU1.AA8
  TOP w0.102: JDIMM3.98 150.17,52 150.38,51.78 154.19,51.78 v1(155.14,50.83)
  IN3 w0.089: v3(92.4,60.96) 92.4,61.05 92.27,61.18 91.9,61.18 91.77,61.05 91.77,59.65 91.9,59.52 100.57,59.52 103.11,62.06 104.49,62.06
  IN3 w0.229: 104.49,62.06 109.2,62.06 116.1,55.16 118.02,55.16 119.23,53.95 119.8,53.95 119.92,53.82 119.92,53.21 120.05,53.09 121.34,53.09 122.2,52.22 131.57,52.22 132.23,51.57 136.32,51.57 136.6,51.85 141.69,51.85 142.21,51.33 153.01,51.33 153.13,51.46 153.13,51.9 153.26,52.02 153.92,52.02 154.05,51.9 154.05,51.45 154.17,51.32 154.84,51.32 154.96,51.45 154.96,51.9 155.09,52.02 155.75,52.02 155.88,51.9 155.88,51.69 156,51.56 156.87,51.56 157,51.44 157,50.78 156.87,50.65 155.27,50.65 155.14,50.78 v1(155.14,50.83)
  BOTTOM w0.102: JDIMM4.98 153.55,52 153.43,51.87 153.43,51.44 153.55,51.31 155.02,51.31 155.14,51.18 v1(155.14,50.83)
DDR_B_MA1: length 91.9
  TOP w0.089: JCPU1.T7 93.9,56.41 93.4,55.91 v3(93.39,55.91)
  TOP w0.102: v1(152.6,50.83) 153.04,50.4 155.32,50.4 155.58,50.65 155.58,51.03 156.25,51.7 JDIMM3.97
  IN3 w0.089: v3(93.39,55.91) 93.49,55.91 93.61,56.04 93.61,56.45 93.49,56.57 92.93,56.57 92.81,56.45 92.81,55.62 92.93,55.5 94.65,55.5 94.78,55.62 94.78,56.51 95.04,56.77 95.26,56.77 95.39,56.9 95.39,57.18 95.26,57.3 94.97,57.3 94.79,57.48 94.79,58.4 94.91,58.51 101.23,58.51 103.84,61.12 104.49,61.12
  IN3 w0.229: 104.49,61.12 108.85,61.12 116.29,53.67 116.61,53.67 116.74,53.8 116.74,54.11 116.86,54.24 117.5,54.24 117.63,54.11 117.63,53.8 117.75,53.67 118.17,53.67 119.67,52.17 119.67,52.17 119.99,51.85 120.19,51.85 120.5,52.16 120.85,52.16 121.73,51.28 121.73,51.1 121.51,50.88 121.51,50.64 121.64,50.51 128.09,50.51 128.93,49.66 129.37,49.66 129.5,49.79 129.5,51.14 129.63,51.27 130.07,51.27 130.2,51.14 130.2,50.24 130.33,50.11 130.69,50.11 130.82,49.99 130.82,49.44 130.95,49.31 131.51,49.31 131.64,49.44 131.64,49.94 131.76,50.06 132.42,50.06 132.55,49.94 132.55,49.44 132.68,49.31 133.34,49.31 133.47,49.44 133.47,49.89 133.59,50.01 134.26,50.01 134.39,49.89 134.39,49.45 134.52,49.32 135.11,49.32 135.24,49.45 135.24,50.09 135.37,50.21 139.02,50.21 139.09,50.28 141.55,50.28 141.62,50.21 142.3,50.21 142.42,50.34 150.36,50.34 150.49,50.21 152.25,50.21 152.6,50.57 v1(152.6,50.83)
  BOTTOM w0.102: JDIMM4.97 150.14,51.7 150.34,51.91 152.87,51.91 153,51.78 153,51.5 152.87,51.37 152.73,51.37 152.6,51.25 v1(152.6,50.83)
DDR_B_MA2: length 89.5
  TOP w0.089: v1(93.39,54.95) 93.39,54.95 93.89,55.45 JCPU1.R7
  TOP w0.102: JDIMM3.96 150.21,51.4 150.22,51.39 153.31,51.39 v1(153.87,50.83)
  IN3 w0.089: v1(93.39,54.95) 93.39,54.81 93.52,54.68 93.87,54.68 93.99,54.81 93.99,55.19 94.12,55.32 94.83,55.32 94.96,55.45 94.96,56.44 95.08,56.56 95.87,56.56 96,56.69 96,57.38 96.13,57.51 96.67,57.51 96.8,57.63 96.8,58.18 96.95,58.33 101.32,58.33 103.64,60.65 104.49,60.65
  IN3 w0.229: 104.49,60.65 108.67,60.65 116.11,53.21 117.98,53.21 121.14,50.05 127.9,50.05 128.41,49.54 128.41,48.97 128.53,48.84 129.47,48.84 129.6,48.97 129.6,49.2 129.73,49.33 130.3,49.33 130.43,49.2 130.43,48.97 130.55,48.84 135.29,48.84 135.97,49.53 138.99,49.53 139.28,49.83 141.36,49.83 141.43,49.76 152.82,49.76 152.94,49.63 152.94,49.62 152.95,49.62 157.26,49.62 157.39,49.75 157.39,50.07 157.26,50.19 154,50.19 153.87,50.32 v1(153.87,50.83)
  BOTTOM w0.102: JDIMM4.96 156.03,51.4 155.76,51.13 155.76,50.61 155.54,50.38 153.87,50.38 153.74,50.51 153.74,50.7 153.87,50.83 v1(153.87,50.83)
DDR_B_MA3: length 90.5
  TOP w0.089: v5(94.39,55.94) 94.9,56.44 JCPU1.T6
  TOP w0.102: JDIMM3.95 156.52,51.1 155.97,50.55 155.97,50.49 155.49,50 152.16,50 v1(151.33,50.83)
  IN3 w0.089: 104.49,61.59 102.89,61.59 102.22,60.92 102.22,60.74 102.53,60.44 102.53,60.19 101.67,59.33 93.9,59.33 93.79,59.22 93.79,57.85 94,57.64 94,57.21 93.79,57 93.79,55.8 93.92,55.67 94.26,55.67 94.39,55.8 v5(94.39,55.94)
  IN3 w0.229: 104.49,61.59 109.02,61.59 115.91,54.7 117.79,54.7 119.86,52.63 121.15,52.63 122.01,51.77 122.41,51.77 122.54,51.64 122.54,51.09 122.67,50.97 123.33,50.97 123.46,51.09 123.46,51.64 123.58,51.77 124.24,51.77 124.37,51.64 124.37,51.09 124.5,50.97 125.26,50.97 125.39,51.09 125.39,51.64 125.51,51.77 126.17,51.77 126.3,51.64 126.3,51.09 126.43,50.97 127.09,50.97 127.21,51.09 127.21,51.64 127.34,51.77 128,51.77 128.13,51.64 128.13,51.09 128.26,50.97 128.92,50.97 129.04,51.09 129.04,51.64 129.17,51.77 131.12,51.77 131.25,51.64 131.25,50.65 131.37,50.52 133.01,50.52 133.14,50.65 133.14,50.98 133.27,51.11 133.87,51.11 134,50.98 134,50.6 134.12,50.47 134.81,50.47 134.94,50.6 134.94,50.98 135.06,51.11 135.66,51.11 135.79,50.98 135.79,50.8 135.91,50.67 136.5,50.67 136.63,50.8 136.63,51.23 136.76,51.36 141.3,51.36 141.83,50.83 v1(151.33,50.83)
  BOTTOM w0.102: JDIMM4.95 150.64,51.1 150.81,50.93 150.81,49.75 150.93,49.63 151.1,49.63 151.49,50.03 152.32,50.03 152.42,50.13 152.42,50.29 152.32,50.4 151.77,50.4 151.39,50.78 151.39,50.78 v1(151.33,50.83)
DDR_B_MA4: length 85.5
  TOP w0.089: JCPU1.T2 98.93,56.45 v1(99.4,56.92)
  TOP w0.102: v1(155.15,49.08) 155.14,49.08 155.14,49.11 154.64,49.61 150.59,49.61 150,50.2 JDIMM3.92
  IN3 w0.089: v1(99.4,56.92) 99.39,56.92 99.26,57.05 99.26,57.5 99.39,57.62 102.65,57.62 103.8,58.77 104.49,58.77
  IN3 w0.229: v1(155.15,49.08) 155.15,49.07 155.23,48.99 155.23,48.91 155.36,48.79 158.23,48.79 158.36,48.66 158.36,47.82 158.29,47.76 154.97,47.76 154.91,47.7 150.66,47.7 150.45,47.9 147.01,47.9 145.8,46.69 141.53,46.69 141.17,46.34 136.84,46.34 136.47,45.97 131.44,45.97 131.08,45.61 129.46,45.61 129.15,45.29 128.33,45.29 127.42,44.39 126.23,44.39 125.6,45.02 123.51,45.02 117.15,51.38 115.35,51.38 107.96,58.77 104.49,58.77
  BOTTOM w0.102: JDIMM4.92 156.07,50.2 155.82,49.95 153.63,49.95 153.5,49.82 153.5,49.4 153.63,49.28 155.03,49.28 155.14,49.16 155.14,49.08 v1(155.15,49.08)
DDR_B_MA5: length 87.6
  TOP w0.089: JCPU1.T4 96.9,56.44 96.38,55.92 v3(96.39,55.92)
  TOP w0.102: v1(152.68,48.78) 152.72,48.75 152.72,48.75 153.12,48.35 155.04,48.35 155.69,49 155.69,49.24 156.02,49.57 156.16,49.57 156.49,49.9 JDIMM3.91
  IN3 w0.089: 104.49,60.18 103.45,60.18 101.42,58.16 97.91,58.16 97.84,58.09 97.84,57.67 97.68,57.5 96.91,57.5 96.79,57.37 96.79,56.52 96.66,56.4 95.93,56.4 95.8,56.27 95.8,55.74 95.93,55.61 96.28,55.61 96.39,55.73 v3(96.39,55.92)
  IN3 w0.229: v1(152.68,48.78) 152.55,48.91 152.55,49.17 152.42,49.3 141.24,49.3 141.17,49.37 139.47,49.37 139.18,49.07 136.16,49.07 135.47,48.39 128.87,48.39 128.74,48.26 128.74,47.89 128.61,47.77 127.96,47.77 127.84,47.89 127.84,49.47 127.71,49.59 127.06,49.59 126.93,49.47 126.93,47.89 126.81,47.77 126.15,47.77 126.02,47.89 126.02,49.47 125.89,49.59 125.23,49.59 125.11,49.47 125.11,48.95 124.98,48.82 124.31,48.82 124.19,48.95 124.19,49.47 124.06,49.59 123.4,49.59 123.27,49.47 123.27,48.12 123.15,47.99 122.48,47.99 122.36,48.12 122.36,49.37 122.13,49.59 120.88,49.59 117.72,52.76 115.92,52.76 108.49,60.18 104.49,60.18
  BOTTOM w0.102: v1(152.68,48.78) 152.6,48.86 152.6,49.11 152.73,49.24 153,49.24 153.11,49.35 153.11,49.51 153,49.62 151.66,49.62 151.53,49.49 151.53,49.34 151.43,49.24 150.76,49.24 150.42,49.58 150.42,49.81 150.33,49.9 JDIMM4.91
DDR_B_MA6: length 86.4
  TOP w0.089: JCPU1.T3 97.9,56.49 97.46,56.93 97.46,56.92 v3(97.4,56.92)
  TOP w0.102: v1(153.95,48.78) 153.52,49.22 150.43,49.22 150.04,49.6 JDIMM3.90
  IN3 w0.089: v3(97.4,56.92) 97.4,56.82 97.53,56.69 97.87,56.69 97.99,56.82 97.99,57.25 98.19,57.45 98.19,57.71 98.29,57.8 102.57,57.8 104.01,59.24 104.49,59.24
  IN3 w0.229: 104.49,59.24 108.14,59.24 115.54,51.84 117.34,51.84 123.36,45.82 123.61,45.82 123.72,45.94 123.72,46.32 123.84,46.43 124.49,46.43 124.62,46.3 124.62,45.61 124.75,45.48 125.41,45.48 125.53,45.61 125.53,46.62 125.76,46.85 126.22,46.85 126.45,46.62 126.45,44.97 126.57,44.84 127.23,44.84 127.36,44.97 127.36,46.72 127.49,46.85 128.15,46.85 128.28,46.72 128.28,45.98 128.4,45.85 129.06,45.85 129.19,45.98 129.19,46.62 129.42,46.85 129.88,46.85 130.1,46.62 130.1,46.19 130.23,46.06 130.89,46.06 131.02,46.19 131.02,46.72 131.15,46.85 131.7,46.85 131.83,46.72 131.83,46.55 131.96,46.42 135.13,46.42 135.25,46.55 135.25,46.84 135.38,46.97 136.31,46.97 136.8,47.46 139.58,47.46 139.97,47.84 141.43,47.84 142.12,47.15 143.6,47.15 143.72,47.28 143.72,48.24 143.85,48.36 144.51,48.36 144.64,48.24 144.64,48.11 144.77,47.99 145.43,47.99 145.55,48.11 145.55,48.24 145.68,48.36 150.64,48.36 150.84,48.17 153.71,48.17 153.95,48.4 v1(153.95,48.78)
  BOTTOM w0.102: JDIMM4.90 156.01,49.6 155.75,49.34 155.75,48.68 155.42,48.35 154.38,48.35 v1(153.95,48.78)
DDR_B_MA7: length 86.5
  TOP w0.089: JCPU1.R2 98.91,55.45 99.36,55.9 v1(99.4,55.9)
  TOP w0.102: v1(155.2,47.27) 155.07,47.27 154.79,47.55 152.8,47.55 152.41,47.94 150.71,47.94 150.25,48.4 JDIMM3.86
  IN3 w0.089: 104.49,56.89 103.97,56.89 102.11,55.04 101.91,55.04 101.35,55.59 99.72,55.59 v1(99.4,55.9)
  IN3 w0.229: 104.49,56.89 107.25,56.89 114.59,49.56 116.39,49.56 117.82,48.13 117.82,47.26 121.14,43.93 122.02,43.93 122.29,43.66 122.29,43.66 123.82,42.13 123.82,42.11 125.21,40.73 130.69,40.73 130.98,41.02 134.22,41.02 135.71,42.51 141.43,42.51 141.65,42.73 141.65,44.23 142.23,44.81 146.51,44.81 147.35,45.66 157.76,45.66 157.88,45.78 157.88,46.65 157.76,46.77 155.33,46.77 155.2,46.9 v1(155.2,47.27)
  BOTTOM w0.102: JDIMM4.86 156.04,48.4 155.92,48.27 155.92,47.99 155.79,47.87 155.48,47.87 155.4,47.96 154.05,47.96 153.93,47.84 153.93,47.67 154.05,47.55 154.92,47.55 v1(155.2,47.27)
DDR_B_MA8: length 88.6
  TOP w0.089: v1(95.4,55.92) 95.9,56.42 JCPU1.T5
  TOP w0.102: v1(151.41,48.78) 151.84,48.35 152.56,48.35 152.95,47.96 155.23,47.96 156.08,48.81 156.08,48.93 156.45,49.3 JDIMM3.89
  IN3 w0.089: v1(95.4,55.92) 95.26,55.92 95.13,55.79 95.13,55.62 95.26,55.5 95.75,55.5 95.81,55.44 96.87,55.44 97,55.56 97,57.25 97.07,57.32 97.81,57.32 98.02,57.53 98.02,57.86 98.13,57.98 102.49,57.98 104.22,59.71 104.49,59.71
  IN3 w0.229: v1(151.41,48.78) 150.9,48.78 150.84,48.84 143.39,48.84 143.27,48.72 143.27,47.74 143.14,47.61 142.45,47.61 142.33,47.74 142.33,48.5 142.11,48.72 141.62,48.72 141.25,48.35 139.7,48.35 139.28,47.93 136.85,47.93 136.73,48.05 136.73,48.15 136.56,48.32 136.08,48.32 135.89,48.13 135.89,47.59 135.76,47.46 134.92,47.46 134.79,47.33 134.79,47.01 134.66,46.88 134,46.88 133.88,47.01 133.88,47.78 133.75,47.9 133.09,47.9 132.96,47.78 132.96,47.16 132.83,47.03 132.17,47.03 132.05,47.16 132.05,47.8 131.92,47.93 131.14,47.93 131.02,47.8 131.02,47.44 130.89,47.31 130.23,47.31 130.1,47.44 130.1,47.8 129.97,47.93 129.31,47.93 129.19,47.8 129.19,47.44 129.06,47.31 125.72,47.31 125.6,47.44 125.6,47.7 125.47,47.83 124.81,47.83 124.68,47.7 124.68,47.02 124.55,46.89 123.89,46.89 123.76,47.02 123.76,47.33 123.56,47.54 122.3,47.54 121.88,47.95 121.88,48.44 121.54,48.77 121.06,48.77 117.53,52.3 115.73,52.3 108.32,59.71 104.49,59.71
  BOTTOM w0.102: JDIMM4.89 150.1,49.3 150.3,49.1 150.3,48.44 150.8,47.94 152.59,47.94 152.7,48.06 152.7,48.22 152.59,48.34 151.31,48.34 151.18,48.46 151.18,48.66 151.31,48.78 v1(151.41,48.78)
DDR_B_MA9: length 86.7
  TOP w0.089: JCPU1.R3 97.93,55.45 98.4,55.92 v3(98.39,55.92)
  TOP w0.102: v1(153.95,47.12) 153.9,47.12 153.77,46.99 153.77,46.81 153.9,46.69 155.23,46.69 155.68,47.13 155.68,47.57 156.2,48.1 JDIMM3.85
  IN3 w0.089: v3(98.39,55.92) 98.39,55.72 98.27,55.59 98.12,55.59 97.99,55.72 97.99,56.39 98.12,56.52 99.98,56.52 100.06,56.44 100.06,55.92 100.16,55.82 101.67,55.82 103.21,57.36 104.49,57.36
  IN3 w0.229: v1(153.95,47.12) 154.12,46.95 154.12,46.24 153.99,46.11 147.16,46.11 146.33,45.28 142.06,45.28 140.96,44.18 140.66,44.18 140.54,44.06 140.54,43.84 140.41,43.71 139.75,43.71 139.62,43.84 139.62,44.06 139.5,44.18 138.83,44.18 138.71,44.06 138.71,43.84 138.58,43.71 137.92,43.71 137.79,43.84 137.79,44.06 137.67,44.18 137.01,44.18 136.88,44.06 136.88,43.84 136.75,43.71 136.03,43.71 135.74,43.42 134.55,43.42 134.42,43.29 134.42,41.87 134.29,41.74 133.59,41.74 133.46,41.87 133.46,42.22 133.34,42.34 132.68,42.34 132.55,42.22 132.55,41.6 132.42,41.48 130.77,41.48 130.48,41.19 128.05,41.19 127.93,41.31 127.93,41.82 127.8,41.95 127.14,41.95 127.01,41.82 127.01,41.31 126.88,41.19 126.22,41.19 126.1,41.31 126.1,41.73 125.97,41.86 124.74,41.86 122.2,44.4 121.32,44.4 121.02,44.7 121.02,44.92 121.26,45.16 121.26,45.34 120.81,45.79 120.63,45.79 120.37,45.53 120.19,45.53 119.72,46 119.72,46.18 119.98,46.44 119.98,46.62 119.48,47.11 119.31,47.11 119.05,46.85 118.87,46.85 118.38,47.34 118.38,47.52 118.56,47.71 118.56,48.03 116.58,50.01 114.78,50.01 107.43,57.36 104.49,57.36
  BOTTOM w0.102: JDIMM4.85 150.08,48.1 150.63,47.55 153.49,47.55 153.93,47.12 v1(153.95,47.12)
DDR_B_MA10: length 89.4
  TOP w0.089: v3(93.4,62.01) 93.36,62.01 93.8,62.45 JCPU1.AB7
  TOP w0.102: JDIMM3.107 156.23,54.7 156.11,54.57 156.11,53.75 155.98,53.62 154.67,53.62 154.54,53.75 154.54,53.94 154.67,54.06 155.47,54.06 155.59,54.18 155.59,54.35 155.47,54.47 155.18,54.47 155.05,54.6 155.05,54.99 155.18,55.12 v1(155.4,55.12)
  IN3 w0.089: v3(93.4,62.01) 93.89,61.52 95.6,61.52 95.81,61.73 95.81,62.24 96.33,62.76 96.57,62.76 98.35,64.54 98.35,65.21 99.08,65.94 101.11,65.94 101.25,66.08 101.69,66.08 102.79,67.18 104.49,67.18
  IN3 w0.229: 104.49,67.18 112.44,67.18 114.95,64.67 118.17,64.67 123.34,59.5 129.04,59.5 130.33,58.21 135.34,58.21 136.05,58.92 142.19,58.92 143.76,57.35 145.95,57.35 146.73,56.58 152.12,56.58 152.35,56.35 157.29,56.35 157.41,56.22 157.41,55.56 157.29,55.43 155.52,55.43 155.4,55.31 v1(155.4,55.12)
  BOTTOM w0.102: JDIMM4.107 150.04,54.7 150.26,54.48 154.69,54.48 155.33,55.12 v1(155.4,55.12)
DDR_B_MA11: length 83.9
  TOP w0.089: v1(100.75,56.25) 99.95,55.45 JCPU1.R1
  TOP w0.102: v1(152.68,47.12) 152.25,47.55 150.81,47.55 150.68,47.42 150.68,46.86 150.56,46.74 150.4,46.74 150.28,46.86 150.28,47.71 150.19,47.8 JDIMM3.84
  IN3 w0.089: v1(100.75,56.25) 101.01,56.52 101.01,56.74 100.85,56.91 100.85,57.14 100.98,57.27 102.87,57.27 103.44,57.84 104.3,57.84 104.31,57.83 104.49,57.83
  IN3 w0.229: v1(152.68,47.12) 152.71,47.12 152.84,46.99 152.84,46.71 152.71,46.58 146.99,46.58 146.16,45.75 141.88,45.75 140.77,44.64 136.63,44.64 136.5,44.77 136.5,44.9 136.37,45.02 135.76,45.02 135.63,44.9 135.63,44.01 135.51,43.88 134.05,43.88 133.92,43.75 133.92,42.93 133.79,42.8 133.13,42.8 133.01,42.93 133.01,43.93 132.88,44.06 132.22,44.06 132.09,43.93 132.09,42.06 131.96,41.93 130.34,41.93 130.21,42.06 130.21,42.66 130.08,42.79 129.42,42.79 129.3,42.66 129.3,41.77 129.17,41.64 128.51,41.64 128.38,41.77 128.38,42.86 128.26,42.99 127.6,42.99 127.47,42.86 127.47,42.53 127.34,42.41 126.68,42.41 126.55,42.53 126.55,43.35 126.43,43.47 125.77,43.47 125.64,43.35 125.64,42.52 125.51,42.39 124.85,42.39 124.73,42.52 124.73,43.35 124.6,43.47 123.77,43.47 116.77,50.47 114.97,50.47 107.61,57.83 104.49,57.83
  BOTTOM w0.102: v1(152.68,47.12) 153.23,46.57 155.14,46.57 156.37,47.8 JDIMM4.84
DDR_B_MA12: length 84.7
  TOP w0.089: JCPU1.T1 99.98,56.45 v3(100.45,56.92)
  TOP w0.102: v1(151.41,47.12) 152.24,46.29 155.42,46.29 156.07,46.94 156.07,47.07 156.5,47.5 JDIMM3.83
  IN3 w0.089: v3(100.45,56.92) 100.35,57.02 100.35,57.32 100.48,57.44 102.73,57.44 103.58,58.3 104.49,58.3
  IN3 w0.229: v1(151.41,47.12) 151.14,47.12 151.02,47.24 150.3,47.24 150.1,47.04 149.54,47.04 149.41,47.17 149.41,47.32 149.29,47.45 148.66,47.45 148.54,47.32 148.54,47.19 148.41,47.07 147.89,47.07 147.76,47.19 147.76,47.31 147.66,47.41 147.17,47.41 145.98,46.22 141.7,46.22 141.36,45.88 137.03,45.88 136.66,45.51 135.28,45.51 135.15,45.38 135.15,44.5 135.03,44.37 134.37,44.37 134.24,44.5 134.24,45.38 134.11,45.51 133.46,45.51 133.34,45.38 133.34,45.18 133.21,45.05 132.56,45.05 132.43,45.18 132.43,45.38 132.31,45.51 131.67,45.51 131.55,45.38 131.55,42.52 131.42,42.39 130.8,42.39 130.67,42.52 130.67,45.02 130.54,45.15 129.88,45.15 129.75,45.02 129.75,44.49 129.64,44.37 128.05,44.37 127.93,44.24 127.93,43.57 127.8,43.45 127.14,43.45 127.01,43.57 127.01,43.8 126.88,43.93 125.56,43.93 125.44,44.06 125.44,44.44 125.31,44.56 124.49,44.56 124.37,44.44 124.37,44.06 124.24,43.93 123.96,43.93 116.96,50.93 115.16,50.93 107.79,58.3 104.49,58.3
  BOTTOM w0.102: JDIMM4.83 150.03,47.5 150.32,47.22 150.32,46.65 150.44,46.52 150.94,46.52 151.06,46.39 151.06,46.06 151.19,45.94 152.45,45.94 152.58,46.06 152.58,46.55 152.45,46.67 151.54,46.67 151.41,46.8 v1(151.41,47.12)
DDR_B_MA13: length 91.8
  TOP w0.089: v3(91.4,61.92) 91.4,61.95 JCPU1.AB10
  TOP w0.102: JDIMM3.119 156.34,58.3 155.87,58.78 155.32,58.78 154.92,58.37 154,58.37 153.5,57.87 153.04,57.87 v1(152.6,57.44)
  IN3 w0.089: 104.49,68.09 102.05,68.09 101.39,67.44 101.26,67.44 100.15,66.32 98.96,66.32 97.99,65.35 97.99,64.68 96.45,63.14 96.19,63.14 95.57,62.52 94.12,62.52 93.99,62.65 93.99,63.19 93.87,63.32 91.99,63.32 91.86,63.19 91.86,62.7 91.73,62.57 91.53,62.57 91.4,62.45 v3(91.4,61.92)
  IN3 w0.229: v1(152.6,57.44) 152.55,57.49 147.54,57.49 146.74,58.29 144.11,58.29 142.57,59.84 135.5,59.84 135.22,59.55 134.57,59.55 134.44,59.67 134.44,60.96 134.31,61.09 133.65,61.09 133.53,60.96 133.53,59.87 133.24,59.58 131.23,59.58 131.1,59.71 131.1,60.88 130.98,61.01 130.38,61.01 130.25,60.88 130.25,60.54 130.13,60.41 129.57,60.41 129.44,60.54 129.44,61.44 129.31,61.57 126.4,61.57 126.27,61.7 126.27,61.99 126.15,62.12 125.49,62.12 125.36,61.99 125.36,61.24 125.23,61.11 124.59,61.11 124.46,61.24 124.46,61.99 124.33,62.12 123.65,62.12 123.52,61.99 123.52,61.24 123.39,61.11 123.02,61.11 118.55,65.58 117.78,65.58 117.65,65.71 117.65,66.48 117.53,66.61 116.87,66.61 116.74,66.48 116.74,65.71 116.61,65.58 116,65.58 115.87,65.71 115.87,66.37 115.75,66.5 114.42,66.5 112.82,68.09 104.49,68.09
  BOTTOM w0.102: v1(152.6,57.44) 152.6,58.17 152.48,58.3 152.24,58.3 152.14,58.2 152.14,57.72 152.02,57.61 151.86,57.61 151.74,57.72 151.74,58.2 151.64,58.3 JDIMM4.119
DDR_B_MA14: length 90.7
  TOP w0.089: v3(95.4,54.92) 95.9,55.42 JCPU1.R5
  TOP w0.102: JDIMM3.80 149.97,46.6 150.23,46.34 151.36,46.34 151.93,45.77 153.47,45.77 153.82,45.42 153.82,45.09 v1(154.2,44.71)
  IN3 w0.089: 104.49,55.49 104.21,55.49 103.15,54.42 101.59,54.42 100.96,55.06 95.54,55.06 v3(95.4,54.92)
  IN3 w0.229: v1(154.2,44.71) 154.2,44.57 153.8,44.16 147.79,44.16 146.47,42.84 143.7,42.84 142,41.14 136.28,41.14 133.88,38.74 128.65,38.74 127.2,37.29 122.67,37.29 122.43,37.53 122.43,41.57 121.56,42.43 120.27,42.43 119.82,41.99 119.64,41.99 119.1,42.53 119.1,42.71 119.67,43.28 119.67,43.46 119.2,43.93 119.02,43.93 118.29,43.2 118.11,43.2 117.65,43.67 117.65,43.85 118.38,44.58 118.38,44.76 117.91,45.22 117.73,45.22 117.44,44.93 117.26,44.93 116.79,45.4 116.79,45.58 117.08,45.87 117.08,46.05 116.62,46.52 116.44,46.52 116.22,46.3 115.9,46.3 106.72,55.49 104.49,55.49
  BOTTOM w0.102: JDIMM4.80 156.29,46.6 155.41,45.72 154.77,45.72 154.68,45.63 154.68,45.32 154.57,45.2 154.4,45.2 154.28,45.32 154.28,45.78 154.15,45.91 153.95,45.91 153.82,45.78 153.82,45.09 v1(154.2,44.71)
DDR_B_MA15: length 87.8
  TOP w0.089: JCPU1.R4 96.93,55.45 v1(97.4,55.92)
  TOP w0.102: v1(152.93,44.71) 152.7,44.94 152.7,45.25 152.58,45.38 151.27,45.38 151.15,45.5 151.15,45.83 151.03,45.95 150.86,45.95 150.74,45.83 150.74,45.47 150.61,45.34 150.39,45.34 150.26,45.47 150.26,45.75 150.01,46 JDIMM3.78
  IN3 w0.089: 104.49,56.42 103.83,56.42 103.71,56.3 103.71,55.78 102.79,54.86 101.83,54.86 101.28,55.41 97.93,55.41 97.81,55.52 97.81,56.39 97.69,56.52 97.31,56.52 97.18,56.39 97.18,56.05 97.31,55.92 v1(97.4,55.92)
  IN3 w0.229: v1(152.93,44.71) 152.93,44.84 152.58,45.2 147.54,45.2 146.69,44.34 146.35,44.34 146.22,44.22 146.22,43.88 146.09,43.75 145.31,43.75 145.18,43.88 145.18,44.22 145.06,44.34 144.19,44.34 144.06,44.22 144.06,43.92 143.94,43.79 143.25,43.79 143.12,43.92 143.12,44.13 142.99,44.26 142.33,44.26 142.2,44.13 142.2,42.63 141.62,42.06 135.9,42.06 134.41,40.56 131.21,40.56 131.01,40.36 131.01,39.78 130.88,39.65 130.22,39.65 130.09,39.78 130.09,40.15 129.97,40.27 129.31,40.27 129.18,40.15 129.18,39.78 129.05,39.65 128.39,39.65 128.27,39.78 128.27,40.15 128.14,40.27 127.48,40.27 127.35,40.15 127.35,39.03 127.22,38.9 126.56,38.9 126.44,39.03 126.44,39.61 126.31,39.74 123.84,39.74 123.71,39.87 123.71,41.58 122.42,42.87 122.42,42.88 121.83,43.47 120.95,43.47 117.11,47.32 117.11,47.55 117.34,47.78 117.34,47.96 116.23,49.07 116.05,49.07 115.86,48.88 115.58,48.88 115.37,49.1 114.4,49.1 107.08,56.42 104.49,56.42
  BOTTOM w0.102: JDIMM4.78 156.51,46 154.79,44.27 153.11,44.27 152.93,44.45 v1(152.93,44.71)
