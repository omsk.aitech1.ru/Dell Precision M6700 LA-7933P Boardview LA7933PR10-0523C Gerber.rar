# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SNUB_1.5V:
  vias: v2(229.42,32.72)
SNUB_1.5VSP: length 1.3
  BOTTOM w0.102: PC312.1 v2(212.13,68.6)
SNUB_1.8VSP: length 3.5
  BOTTOM w0.102: PR302.2 v2(102.59,11.33)
  BOTTOM w0.508: PR302.2 103.38,12.64 104.06,13.32 PC306.1
SNUB_3V:
  vias: v2(276.1,42.18)
SNUB_5V: length 1.3
  BOTTOM w0.102: PC115.1 v2(269.39,43.04)
SNUB_+V1.05S_VCCPP: length 3
  BOTTOM w0.102: PC509.1 64.99,23.16 v2(64.6,23.55)
  BOTTOM w0.508: PR505.2 65.66,22.57 PC509.1
SNUB_+V1.05SP:
  vias: v2(9.19,138.86)
SOFT_START_GC: length 268
  TOP w0.254: PU1001.2 v1(175.37,68.27)
  TOP w0.381: v1(16.72,73.32) 17.04,73.64 PR20.2
  IN1 w0.381: v1(162.65,17.17) 162.46,17.36 162.46,40.89 165.97,44.41 165.97,45.98 168.14,48.15 169.93,48.15 173.53,51.75 173.53,62.82 172.4,63.95 172.4,65.37 175.3,68.27 v1(175.37,68.27)
  IN2 w0.381: v1(162.65,17.17) 162.24,17.58 159.68,17.58 159.59,17.49 157.45,17.49 155.67,15.71 153.2,15.71 151.15,13.66 132.55,13.66 132.09,14.12 129.92,14.12 129.34,14.71 127.19,14.71 127.19,14.71 125.48,14.71 125.48,14.71 122.07,14.71 121.69,15.09 119.71,15.09 118.34,16.45 117.88,16.45 117.66,16.68 113.7,16.68 111.1,14.07 110.17,14.07 110.03,14.07 109.11,13.16 108.17,13.16 108.17,13.16 105.39,13.16 104.91,12.68 104.9,12.68 104.53,12.3 104.53,12.3 102.17,9.93 36.32,9.93 35.2,11.05 32.08,11.05 31.62,11.51 31.62,34.78 32.99,36.15 32.99,45.18 32.62,45.56 32.61,45.56 31.88,46.29 31.88,47.31 29.3,49.89 28.7,50.48 28.7,57.91 17.32,69.29 17.32,72.72 v1(16.72,73.32)
  BOTTOM w0.127: v1(16.72,73.32) 16.72,73.94 v2(16.91,74.13)
SP_TPM_LPC_EN: length 122.7
  TOP w0.102: v1(239.79,73.58) 239.52,73.32 236.55,73.32 236.37,73.14 v2(235.82,73.14) 234.69,73.14 234.38,72.82 233.47,72.82 233.15,73.14 232.46,73.14 231.81,72.49 229.67,72.49 229.53,72.63 228.79,72.63 227.94,71.78 226.14,71.78 225.57,71.21 224.54,71.21 223.22,69.89 222.7,69.89 222.38,69.56 222.38,69.08 v1(221.72,68.42)
  IN2 w0.127: v1(221.72,68.42) 221.46,68.67 217.42,68.67 213.84,65.09 204.56,65.09 202.43,67.21 190.96,67.21 189.2,68.96 189.2,85.5 187.95,86.75 187.46,86.75 186.46,87.76 186.46,88.24 182.47,92.23 181.83,92.23 180.57,93.49 180.57,94.12 177.66,97.03 177.66,98.42 175.32,100.76 175.32,103.15 174.19,104.28 171.16,104.28 170.09,103.21 166.69,103.21 v1(166.51,103.39)
  IN4 w0.109: v1(239.79,73.58) 240.28,73.58 240.63,73.94 241.97,73.94 242.17,74.13 244.7,74.13 244.73,74.16 246.24,74.16 246.69,74.61 247.75,74.61 v1(248.19,75.06)
  BOTTOM w0.102: v1(248.19,75.06) 248.48,75.34 R772.2 ; U46.B56 240.94,74.2 240.92,74.18 240.38,74.18 v1(239.79,73.58) ; R2188.1 163.62,104.21 D103.1 164.31,103.98 164.96,103.33 166.44,103.33 v1(166.51,103.39)
SP_TPM_LPC_EN_R: length 8.5
  TOP w0.102: v1(166.93,106.83) 166.8,106.83 166.31,106.34 U37.28 U39.28
  BOTTOM w0.102: v1(166.93,106.83) 166.93,106.13 166.2,105.4 R2189.2 165.19,105.4 164.98,105.61 D103.2 164.3,105.59 R2188.2 v2(163.18,106.62)
SPI_CLK32: length 15.5
  TOP w0.102: R913.2 43.44,100.21 R897.1 45.06,101.16 45.19,101.28 45.19,102.43 45.31,102.55 45.69,102.55 45.82,102.43 v2(45.82,101.71) 45.82,101.28 45.95,101.16 46.2,101.16 46.33,101.28 46.33,102.55 46.46,102.68 46.7,102.68 46.82,102.55 46.82,100.7 46.95,100.57 47.24,100.57 47.37,100.7 47.37,101.05 47.5,101.18 47.97,101.18 48.1,101.31 48.1,101.49 47.97,101.61 47.5,101.61 47.37,101.74 47.37,102.68 47.5,102.81 47.76,102.81 47.89,102.68 47.89,102.17 48.02,102.05 U53.6
SPI_CLK64: length 11.8
  TOP w0.102: R899.1 46.1,108.2 45.95,108.36 45.95,108.65 46.11,108.81 46.37,108.81 46.43,108.88 R910.2 46.43,109.54 46.57,109.68 46.79,109.68 46.91,109.55 46.91,108.88 47,108.79 47.24,108.79 47.31,108.85 v2(47.43,108.85) 47.78,108.85 47.96,109.04 51.54,109.04 51.66,108.91 51.66,108.38 51.54,108.26 50.24,108.26 50.1,108.4 U52.6
SPI_DIN32: length 12.7
  TOP w0.127: U53.2 56.98,100.78 57.06,100.86 57.06,101.24 57.19,101.37 57.75,101.37 58.61,102.24 59.43,102.24 59.5,102.17 59.5,101.59 59.42,101.51 58.61,101.51 58.28,101.18 58.28,101.05 58.15,100.93 v2(57.68,100.93) 57.55,100.8 57.55,100.51 57.43,100.38 57.01,100.38 56.88,100.25 56.88,100.03 57.01,99.9 57.86,99.9 57.99,100.03 57.99,100.42 58.11,100.55 58.33,100.55 58.46,100.42 58.46,100.03 58.58,99.9 58.88,99.9 59,100.03 59,100.71 R895.2
SPI_DIN64: length 11.5
  TOP w0.102: v1(54.49,107.82) 54.49,107.86 54.36,107.99 53.76,107.99 53.63,108.12 53.63,108.36 53.76,108.48 54.88,108.48 55,108.36 55,107.66 54.77,107.43 54.77,107.25 54.9,107.13 U52.2
  BOTTOM w0.102: v1(54.49,107.82) 54.33,107.82 54.2,107.7 54.2,107.42 54,107.21 v2(54,107.09) 54,106.93 53.87,106.81 53.57,106.81 53.44,106.68 53.44,106.46 53.57,106.34 54.42,106.34 54.54,106.46 54.54,107.25 54.67,107.38 54.88,107.38 55,107.25 55,106.76 55.13,106.63 55.38,106.63 55.51,106.76 R894.2
SPI_DO32: length 12.7
  TOP w0.102: U53.5 47.97,103.32 47.83,103.45 47.83,103.62 48.16,103.95 49.03,103.95 49.16,104.08 49.16,104.67 49.29,104.8 49.46,104.8 49.59,104.67 49.59,103.95 49.72,103.82 49.95,103.82 50.07,103.95 50.07,105.07 49.95,105.2 48.77,105.2 48.68,105.11 48.68,104.55 48.57,104.43 48.4,104.43 48.28,104.55 48.28,105.11 48.19,105.2 47.99,105.2 47.5,104.71 v2(47.5,104.45) 47.5,103.87 47.27,103.65 46.75,103.65 R900.1
SPI_DO64: length 10.6
  TOP w0.102: U52.5 48.02,109.67 47.89,109.79 47.89,110.63 47.79,110.73 47.23,110.73 47.13,110.83 47.13,111.04 47.23,111.14 48.33,111.14 48.45,111.26 48.45,111.43 48.33,111.54 v2(48.06,111.54) 47.23,111.54 47.13,111.65 47.13,111.85 47.23,111.95 48.21,111.95 48.33,112.08 48.33,112.28 48.21,112.41 46.55,112.41 46.42,112.28 R901.1
SPI_HOLD#: length 12.1
  TOP w0.102: U53.7 50.14,100.78 50.54,101.18 50.54,106.74 50.16,107.13 U52.7 47.99,107.13 v2(47.46,106.6) 47.25,106.38 46.67,106.38 R891.2
SPI_PCH_CLK: length 22
  TOP w0.102: v1(43,103.52) 43,102.29 43.44,101.85 R897.2 ; v1(47.33,108.23) 46.76,107.66 45.77,107.66 45.48,107.94 R899.2
  BOTTOM w0.102: v1(43,103.52) 43.03,103.49 44.23,103.49 44.79,104.05 44.79,105.2 45.49,105.9 45.49,107.67 46.05,108.23 v1(47.33,108.23) 47.99,108.23 48.12,108.1 48.12,107.87 47.99,107.75 46.14,107.75 46.01,107.62 46.01,106.95 46.14,106.82 46.39,106.82 46.52,106.95 46.52,107.14 46.65,107.26 JSPI1.7 49.63,107.26 49.71,107.34 RH348.1
SPI_PCH_CS0#: length 10.2
  TOP w0.102: v1(53.19,107.82) 53.62,107.82 54.8,106.64 54.8,105.19 54.93,105.07 v1(54.93,104.97)
  BOTTOM w0.102: v1(53.19,107.82) v2(52.78,108.23) 52.23,108.78 RH349.1 51.12,108.26 JSPI1.9 ; R963.1 55.17,105.98 54.93,105.74 54.93,105.72 54.8,105.59 54.8,105.19 54.93,105.07 v1(54.93,104.97)
SPI_PCH_CS0#_R: length 4.5
  TOP w0.102: U52.1 56.92,105.86 57.13,105.65 57.13,105.47 56.7,105.04 55.65,105.04 v3(55.57,104.97)
  BOTTOM w0.102: v3(55.57,104.97) 55.57,105.12 55.95,105.5 55.97,105.5 R963.2
SPI_PCH_CS1#: length 20.4
  TOP w0.102: R936.1 59.1,98.72 56.7,98.72 56.23,98.25 v1(56.23,98.17)
  BOTTOM w0.102: v1(56.23,98.17) 56.23,98.37 57.86,100 57.86,102.51 56.3,104.06 52.21,104.06 51.98,104.29 RH345.1 51.62,103.29 51.22,102.9 v2(50.57,102.9) 49.2,104.26 JSPI1.1
SPI_PCH_CS1#_R: length 2.8
  TOP w0.102: U53.1 v2(57.68,99.51) 57.86,99.51 57.99,99.38 R936.2
SPI_PCH_DIN: length 17.8
  TOP w0.102: R895.1 59.76,102.33 60.16,102.73 60.16,104.45 v1(60.21,104.5)
  BOTTOM w0.102: v1(60.21,104.5) v2(59.11,105.59) 57.45,107.25 R894.1 55.63,106.43 55.15,106.43 54.04,105.32 53.62,105.32 52.91,106.03 51.91,106.03 RH347.1 51.47,106.32 50.99,105.84 49.87,105.84 49.45,106.26 JSPI1.5
SPI_PCH_DO: length 17.7
  TOP w0.102: v1(47.06,104.08) 46.72,104.08 46.33,103.68 45.58,103.68 45.35,103.45 R900.2 ; v3(44.19,111.51) 44.46,111.24 R901.2
  IN3 w0.127: v1(47.06,104.08) 46.86,104.28 46.86,105.78 45.34,107.3 45.34,110.36 v3(44.19,111.51)
  BOTTOM w0.102: RH346.1 51.38,105.31 51.14,105.06 51.14,104.98 51.01,104.85 49.97,104.85 49.56,105.26 JSPI1.3 48.24,105.26 47.12,104.14 47.12,104.13 v1(47.06,104.08)
SPI_WP#_SEL: length 226.4
  TOP w0.102: v1(157.73,94.82) 157.73,96.52 157.61,96.65 157.61,98.63 157.81,98.84 157.81,102.72 157.41,103.11 157.41,114.3 v1(157.92,114.81) ; v1(235.08,65.96) 234.18,66.87 229.86,66.87 229.03,67.69 225.58,67.69 v1(225.07,68.21)
  IN3 w0.127: v1(157.92,114.81) 157.61,115.13 141.17,115.13 140.59,115.71 140.26,115.71 139.41,116.56 133.17,116.56 132.61,116 126.77,116 125.82,115.05 119.54,115.05 116.88,112.38 96.99,112.38 87.66,103.05 80.69,103.05 78.05,105.69 72.28,105.69 70.57,103.98 63.5,103.98 62.15,105.32 61.52,105.32 58.38,108.46 58.38,109.02 v1(58.46,109.09)
  IN4 w0.109: v1(225.07,68.21) 225.07,68.98 224.14,69.9 218.07,69.9 214.47,73.5 214.47,78.58 214.06,78.99 198.36,78.99 192.25,85.1 175.76,85.1 170.53,90.32 162.65,90.32 158.15,94.82 v1(157.73,94.82)
  BOTTOM w0.102: R898.1 57.86,108.52 v2(57.94,108.6) 58.43,109.09 v1(58.46,109.09) ; v1(235.08,65.96) U46.A12
SPI_WP#_SEL_R: length 28.7
  TOP w0.102: U52.3 55.48,108.4 54.93,108.95 v1(54.75,108.95) ; v1(58.27,103.33) 57.95,103.01 57.95,101.89 57.77,101.71 57.12,101.71 56.79,102.05 U53.3 55.22,102.05 54.46,102.81 54.46,106.22 53.54,107.14 51.52,107.14 50.91,107.75 48.08,107.75 47.49,107.16 46.3,107.16 R890.2
  IN3 w0.127: v1(58.27,103.33) 57.25,104.34 57.25,105.56 55.29,107.51 55.29,108.59 54.93,108.95 v1(54.75,108.95)
  BOTTOM w0.102: v2(54.75,109.67) v1(54.75,108.95) 55.32,108.95 55.51,108.76 R898.2
SPKR: length 113
  TOP w0.102: v1(32.36,31.55) 32.16,31.75 JIO1.47 ; UH4.T10 24.93,108.37 24.72,108.37 v1(24.7,108.36)
  IN1 w0.109: v1(39.06,32.92) 38.42,32.27 37.01,32.27 36.93,32.2 33.25,32.2 32.6,31.55 v1(32.36,31.55)
  IN3 w0.102: 23.48,103.19 23.48,103.19 23.48,103.56 23.47,103.58 23.47,104.6 24.28,105.41 24.28,107.94 v1(24.7,108.36)
  IN3 w0.127: v1(39.06,32.92) 39.06,32.94 39.2,33.08 39.2,35.47 38.56,36.11 36.22,36.11 34.89,37.44 34.89,42.53 33.78,43.64 33.78,45.53 34.39,46.14 34.39,47.44 31.82,50.01 31.82,59.03 24.62,66.22 15.35,66.22 14.95,66.62 14.95,68.56 14.32,69.19 14.32,72.08 14.12,72.28 14.12,83.72 13.18,84.66 13.18,95.11 14.83,96.76 16.15,96.76 17.12,97.73 17.12,98.01 17.42,98.31 17.42,98.87 18.03,99.48 18.03,100.01 18.96,100.94 19.26,100.94 19.79,101.46 19.79,102.3 20.33,102.85 22.35,102.85 22.52,102.68 23.71,102.68 v1(23.81,102.78) 23.48,103.12 23.48,103.19
  BOTTOM w0.102: RH35.1 24.09,101.26 v2(24.09,102.22) 24.09,102.5 v1(23.81,102.78)
SRTCRST#: length 197.6
  TOP w0.102: v1(142.51,94.04) 142.86,94.4 146.84,94.4 147.6,95.16 147.6,102.31 147.06,102.85 147.06,113.89 145.44,115.52 140.65,115.52 136.64,119.53 136.64,132.96 v1(135.67,133.92) ; v1(21.06,114.39) 21.04,114.39 20.7,114.73 UH4.G22
  IN1 w0.102: v1(21.06,114.39) 21.06,114.59 21.36,114.9 24.71,114.9 25.33,114.28 26.34,114.28 26.66,113.96 26.66,113.79 26.92,113.53 27.66,113.53 28.47,112.72 28.47,111.88 28.57,111.79 29.78,111.79 30.02,111.54 30.9,111.54 30.92,111.52 33.11,111.52 33.18,111.6 38.1,111.6 38.71,110.99 39.12,110.99 39.21,111.07 39.91,111.07 40.98,110.01 40.98,107.99 41.22,107.75 41.22,106.6 41.94,105.87 42.14,105.87
  IN1 w0.109: v1(135.67,133.92) 126.85,133.92 121.96,129.03 116.43,129.03 114.08,126.68 110.39,126.68 109.41,125.7 109.41,122.79 107.75,121.13 102.37,121.13 101.59,120.35 99.07,120.35 98.96,120.23 93.37,120.23 92.21,119.06 90.73,119.06 88.62,116.95 88.62,116.7 84.96,113.04 84.86,113.04 82.49,110.67 81.07,110.67 79.58,109.18 72.53,109.18 71.31,107.96 70.85,107.96 69.96,107.07 69.96,106.6 69.18,105.82 67.55,105.82 65.71,103.97 63.19,103.97 62.84,103.63 61.31,103.63 60.78,103.1 60.5,103.1 59.64,102.24 58.35,102.24 57.81,102.78 50.27,102.78 49.75,103.29 46.63,103.29 46,103.92 46,104.38 45.06,105.32 43.45,105.32 42.89,105.87 42.14,105.87
  BOTTOM w0.102: v1(142.51,94.04) 142.59,93.96 ME1.2 ; RH23.2 17.41,116.9 CH5.2 18.01,115.76 18.91,114.86 v2(19.29,114.86) 20.59,114.86 v1(21.06,114.39)
STSTART_DCBLOCK_GC: length 69.8
  TOP w0.254: PU1001.16 v1(180.86,73.18)
  TOP w0.381: v1(147.08,96.05) 147.08,102.22 146.49,102.81 v1(146.49,103.76)
  IN4 w0.381: v1(180.86,73.18) 179.55,74.49 176.63,74.49 171.3,79.82 171.3,86.64 168.76,89.18 162.21,89.18 159.73,91.66 156.81,91.66 153.73,94.73 151.61,94.73 151.05,95.29 147.84,95.29 v1(147.08,96.05)
  BOTTOM w0.381: PR1002.1 v2(144.7,103.57) 146.3,103.57 v1(146.49,103.76)
SUS_ON: length 159.7
  TOP w0.102: v1(127.28,23.72) 126.37,24.63 R806.1
  IN2 w0.127: v1(244.03,71.51) 243.91,71.63 242.87,71.63 242.68,71.82 240.25,71.82 v1(240.11,71.95) 239.52,71.95 239.24,71.68 239.24,70.43 239.53,70.14 239.53,69.71 239.34,69.52 239.34,67.88 238.64,67.18 229.97,67.18 229.58,67.58 228.57,67.58 228.15,67.16 228.15,63.52 227.51,62.88 226.23,62.88 226.09,63.02 204.21,63.02 202.47,61.28 199.39,61.28 198.93,60.82 195.08,60.82 v1(194.73,61.18)
  IN4 w0.109: v1(194.73,61.18) 194.73,59.86 191.95,57.09 182.19,57.09 179.18,54.07 176.22,54.07 168.77,46.62 168.19,46.62 166.1,44.53 166.1,43.77 161.77,39.44 161.77,34.11 160.76,33.1 160.76,26.12 159.45,24.82 159.45,23.94 156.83,21.32 150.48,21.32 149.2,20.05 128.95,20.05 127.37,21.62 127.37,23.63 v1(127.28,23.72)
  BOTTOM w0.102: U46.B60 241.08,72.2 240.84,71.95 v1(240.11,71.95) ; v1(244.03,71.51) 244.11,71.44 R888.1 ; v1(194.73,61.18) v4(195.48,61.18)
SUS_ON_3.3V#: length 17.2
  TOP w0.102: 130.03,33.75 130.75,33.03 130.75,30.87 130.47,30.59 130.47,28.5 131.06,27.92 131.06,24.52 130.93,24.4 129.91,24.4 129.78,24.52 Q303.6 129.78,25.35 129.72,25.41 129.31,25.41 129.13,25.24 Q303.5 129.13,23.91 R915.2 ; 130.03,33.75 v2(130.03,33.74) ; 130.03,33.75 129.69,34.1 128.89,34.1 128.27,33.48 Q65.2
SUS_STAT#/LPCPD#: length 15.8
  TOP w0.102: v1(20.3,107.45) 20.32,107.47 20.33,107.47 20.7,107.84 UH4.G8
  IN4 w0.109: v1(11.75,101.35) 12.13,101.73 13.42,101.73 15.24,103.55 17.44,103.55 18.02,104.13 19.82,104.13 20.2,104.51 20.2,107.35 v1(20.3,107.45)
  BOTTOM w0.102: RH318.2 13.09,101.12 T56.1 11.94,101.16 v1(11.75,101.35)
SUSACK#: length 349.6
  TOP w0.102: v1(14.95,106.83) 14.92,106.81 13.8,106.81 13.36,107.25 RH114.1 ; v1(231.66,79.71) 232.04,79.32 232.64,79.32 233.73,80.42 237.26,80.42 238.68,78.99 239.4,78.99 239.91,79.5 241.21,79.5 242.37,78.35 242.37,77.69 243.01,77.04 243.01,76.53 244.63,74.92 244.63,73.03 244.5,72.9 v2(244.5,72.39) 244.5,71.91 244.63,71.78 244.63,71.43 244.17,70.97 243.67,70.97 v1(243.66,70.98)
  IN2 w0.127: v1(14.95,106.83) 13.96,107.82 13.96,108.78 13.18,109.55 9.7,109.55 9.36,109.89 8.62,109.89 8.58,109.86 8.13,109.86 7.85,110.13 7.85,111.29 7.16,111.98 6.34,111.98 6.03,112.28 6.03,112.88 5.28,113.63 5.28,119.95 5.55,120.21 5.55,125.13 6.96,126.54 6.96,132.56 8.34,133.95 9.24,133.95 13.69,138.39 13.69,139.14 14.13,139.58 14.57,139.58 16.72,141.73 16.72,144.09 17.72,145.1 19.33,145.1 20.57,143.87 33.13,143.87 35.18,141.81 35.84,141.81 36.05,141.59 38.07,141.59 38.43,141.24 40.89,141.24 41.48,141.84 42.74,141.84 43.85,142.95 45.47,142.95 46.14,143.62 48.53,143.62 49.43,142.72 49.74,142.72 50.53,141.94 50.9,141.94 51.88,142.91 61.49,142.91 62.11,143.54 63.16,143.54 63.65,144.03 65.63,144.03 65.91,144.32 68.22,144.32 68.86,143.68 71.05,143.68 71.56,143.17 73.28,143.17 73.83,142.61 73.83,141.74 74.03,141.54 74.03,140.94 74.45,140.51 74.85,140.51 75.32,140.04 78.36,140.04 78.95,140.63 78.95,142.31 79.46,142.82 81.78,142.82 82.71,143.74 85.64,143.74 86.87,142.51 91.25,142.51 92.1,143.36 107.62,143.36 108,143.74 116.34,143.74 117.29,144.69 118.78,144.69 118.99,144.49 135.77,144.49 136.06,144.2 145.06,144.2 149.03,140.23 154.6,140.23 155.4,139.43 160.53,139.43 161.34,138.62 169.26,138.62 171.56,140.92 173.51,140.92 173.68,141.1 176.52,141.1 177.56,140.06 181.76,140.06 183.46,138.35 185.32,138.35 187.69,135.99 187.69,134.59 189.16,133.11 189.16,110.37 190.34,109.2 190.65,109.2 191.92,107.92 191.92,106.48 194.66,103.74 194.66,103.21 195.59,102.28 195.59,100.18 195.85,99.93 195.85,98.13 197.12,96.86 197.12,96.12 198.63,94.61 198.63,94.27 199.9,92.99 200.93,92.99 201.12,92.8 201.12,91.66 201.62,91.15 202.37,91.15 203.41,90.11 208.34,90.11 209.17,89.27 213,89.27 213.21,89.05 216.75,89.05 218.95,86.86 219.88,86.86 220.87,85.87 223.21,85.87 225.25,83.83 225.25,83.25 226.76,81.74 228.84,81.74 230.87,79.71 v1(231.66,79.71)
  BOTTOM w0.102: v1(243.66,70.98) 243.64,70.98 243.09,71.53 242.84,71.53 242.76,71.45 U46.A58
SUSACK#_R: length 6.2
  TOP w0.102: UH4.C12 18.64,109.8 18.22,109.8 18,109.59 17.48,109.59 16.92,109.03 16.56,109.03 16.1,108.57 v2(15.37,108.57) 14.6,108.57 RH323.2 RH114.2
SUSCLK: length 2.4
  TOP w0.102: UH4.N14 23.95,110.68 23.7,110.43 v1(23.68,110.43)
  BOTTOM w0.102: v1(23.68,110.43) 23.24,110.87 T57.1
SW_1.5V: length 4.1
  TOP w0.102: v1(229.07,43.63) 228.73,43.28 v2(228.73,43.08)
  IN4 w1.016: 224.89,42.44 224.92,42.47 227.58,42.47 228.12,43
  vias: v1(223.4,42.47) v1(224.04,42.47) v1(228.43,43.63)
SW_+V1.05S_VCCPP: length 15.7
  TOP w0.762: 63.44,23.59 63.44,22.12 62.9,21.58 62.9,19.88 67.92,14.86 69.95,14.86
  BOTTOM w0.102: PL501.1 v2(74.39,12.38)
  vias: v1(61.73,23.81) v1(62.39,23.83) v1(70.78,14.86) v1(71.41,14.86)
SW_+V1.05SP: length 4.4
  BOTTOM w0.635: v1(4.04,149.92) 3.12,149.92 2.58,149.38 2.58,147.07 2.83,146.81
  vias: v1(2.67,145.05) v1(2.89,144.21) v1(3.08,143.51) v1(3.08,142.81) v1(3.47,146.62) v1(3.47,145.99) v1(3.47,145.1) v1(3.53,144.21) v2(2.51,140.92)
SW_LAN_TX0+: length 39.4
  TOP w0.089: v3(120.74,140.45) 120.86,140.45 120.95,140.54 120.95,140.87 120.8,141.02 U32.24
  IN3 w0.114: v1(94.32,140.69) 94.31,140.69 94.05,140.44 94.05,139.69 94.33,139.41 100.51,139.41 100.71,139.21 102.69,139.21 103.53,138.37 107.77,138.37 107.97,138.57 113.02,138.57 113.36,138.23 118.16,138.23 119.05,139.12 119.84,139.12 120.95,140.23 120.95,140.34 120.84,140.45 v3(120.74,140.45)
  BOTTOM w0.089: T156.1 94.21,146.46 93.97,146.22 93.55,146.22 93.28,145.95 93.28,145.86 C500.1 93.36,145.35 93.36,145.25 94.03,144.58 94.03,140.95 94.28,140.69 v1(94.32,140.69)
SW_LAN_TX0-: length 39.6
  TOP w0.089: v1(121.38,140.45) 121.38,140.64 121.3,140.72 121.3,141.59 U32.25
  IN3 w0.114: v3(93.69,140.69) 93.69,139.54 94.18,139.04 100.35,139.04 100.56,138.84 102.54,138.84 103.38,138 107.92,138 108.13,138.2 112.86,138.2 113.21,137.86 118.31,137.86 119.21,138.75 119.99,138.75 121.32,140.08 121.32,140.39 v1(121.38,140.45)
  BOTTOM w0.089: v3(93.69,140.69) 93.69,144.44 93.01,145.11 93.01,145.18 C500.2 92.94,145.88 T156.2
SW_LAN_TX1+: length 49.7
  TOP w0.089: U32.28 122.8,141.02 122.89,140.93 122.89,140.78 v3(122.74,140.64)
  IN3 w0.114: v1(95.12,140.98) 95.3,140.81 95.3,140.61 95.63,140.28 100.43,140.28 101.18,141.03 104.27,141.03 104.76,140.54 108.83,140.54 109.08,140.79 111.05,140.79 111.66,140.18 118.83,140.18 119.98,141.33 122.92,141.33 123.02,141.22 123.02,140.92 122.74,140.64 v3(122.74,140.64)
  BOTTOM w0.089: v1(95.12,140.98) 95.18,140.98 95.27,141.07 95.27,145.23 C501.1 95.27,145.78 95.27,148.91 94.64,149.54 88.47,149.54 88.2,149.27 88.2,148.87 88.28,148.79 89.02,148.79 89.13,148.68 T156.5
SW_LAN_TX1-: length 49.9
  TOP w0.089: v1(123.38,140.64) 123.23,140.78 123.23,140.96 123.3,141.02 U32.29
  IN3 w0.114: v1(123.38,140.64) 123.39,140.65 123.39,141.38 123.07,141.69 119.82,141.69 118.68,140.55 111.81,140.55 111.2,141.16 108.93,141.16 108.67,140.91 104.91,140.91 104.42,141.4 101.03,141.4 100.28,140.65 95.78,140.65 95.67,140.77 95.67,140.9 v3(95.76,140.98)
  BOTTOM w0.089: v3(95.76,140.98) 95.62,141.12 95.62,145.17 C501.2 95.62,145.84 95.62,149.05 94.78,149.89 88.33,149.89 87.86,149.42 T156.6
SW_LAN_TX2+: length 53.3
  TOP w0.089: v3(125.23,140.66) 125.36,140.66 125.45,140.75 125.45,140.93 125.3,141.08 U32.33
  IN3 w0.114: v1(87.74,140.08) 87.72,140.08 87.48,139.84 87.48,139.17 88.14,138.51 89.5,138.51 90.13,137.87 92.91,137.87 93.18,138.14 99.95,138.14 101.14,136.94 108.27,136.94 108.6,137.27 112.55,137.27 112.88,136.94 123.34,136.94 125.42,139.03 125.42,140.54 125.3,140.66 v3(125.23,140.66)
  BOTTOM w0.089: v1(87.74,140.08) 87.7,140.08 87.45,140.34 87.45,142.22 85.95,143.71 85.95,145 C502.1 85.89,145.69 85.89,146.09 85.98,146.18 86.49,146.18 86.59,146.28 86.59,147.53
SW_LAN_TX2-: length 53.4
  TOP w0.089: U32.34 125.79,141.59 125.79,140.74 v1(125.87,140.66)
  IN3 w0.114: v1(125.87,140.66) 125.79,140.59 125.79,138.88 123.49,136.58 112.72,136.58 112.39,136.91 108.75,136.91 108.42,136.58 100.99,136.58 99.79,137.77 93.33,137.77 93.06,137.5 89.98,137.5 89.34,138.14 87.98,138.14 87.11,139.01 v3(87.11,140.08)
  BOTTOM w0.089: v3(87.11,140.08) 87.11,142.07 85.61,143.57 85.61,145.02 C502.2 85.55,145.54 85.55,146.15 85.32,146.38 T156.8
SW_LAN_TX3+: length 60.8
  TOP w0.089: U32.37 127.3,141.05 127.36,140.98 127.36,140.8 v3(127.22,140.65)
  IN3 w0.114: v1(80.47,144.79) 80.33,144.65 80.33,144.13 87.31,137.15 88.8,137.15 89.33,136.61 93.51,136.61 93.71,136.82 98.04,136.82 99.17,135.69 103.53,135.69 103.8,135.42 109.13,135.42 109.7,135.99 112.05,135.99 112.62,135.42 125.4,135.42 127.35,137.38 127.35,140.53 127.23,140.65 v3(127.22,140.65)
  BOTTOM w0.089: T156.11 81.51,146.51 81.38,146.38 81.13,146.38 81.04,146.3 81.04,146.11 C503.1 81.09,145.53 81.09,145.33 80.67,144.91 80.58,144.91 v1(80.47,144.79)
SW_LAN_TX3-: length 62.2
  TOP w0.089: v1(127.85,140.65) 127.71,140.8 127.71,140.97 127.8,141.06 U32.38
  IN3 w0.114: v1(127.85,140.65) 127.72,140.52 127.72,137.22 125.55,135.05 112.47,135.05 111.9,135.62 109.85,135.62 109.28,135.05 103.64,135.05 103.38,135.32 99.02,135.32 97.89,136.45 93.86,136.45 93.66,136.25 89.18,136.25 88.64,136.78 87.16,136.78 79.96,143.98 79.96,144.67 v3(79.83,144.79)
  BOTTOM w0.089: T156.12 80.24,146.52 80.33,146.43 80.59,146.43 80.7,146.32 80.7,146.09 C503.2 80.69,145.51 80.69,145.42 80.53,145.25 80.29,145.25 v3(79.83,144.79)
SW_LVDS_A0+: length 13.6
  TOP w0.102: U11.9 69.22,136.28 69.11,136.17 68.97,136.17 68.91,136.23 68.9,136.23 68.55,136.58 68.55,136.59 v3(68.55,136.59) ; JLVDS1.21 72.24,142.75 72.16,142.67 72.16,142.39 v1(72.33,142.21)
  IN1 w0.117: v3(68.55,136.59) 68.55,136.59 68.55,136.6 68.58,136.63 68.58,137.02 68.9,137.35 71.55,137.35 71.62,137.28 72.97,137.28 73.4,137.72 73.4,139.71 71.96,141.15 71.96,141.84 72.33,142.21 v1(72.33,142.21)
SW_LVDS_A0-: length 13.7
  TOP w0.102: v1(68.09,137.05) 68.09,137.04 67.94,136.89 67.94,136.88 67.61,136.55 67.61,136.02 67.71,135.92 U11.10 ; v3(71.7,142.21) 71.88,142.39 71.88,142.61 71.74,142.75 JLVDS1.22
  IN1 w0.117: v3(71.7,142.21) 71.68,142.19 71.68,141.03 73.12,139.59 73.12,137.84 72.85,137.57 71.74,137.57 71.67,137.63 68.68,137.63 68.1,137.05 v1(68.09,137.05)
SW_LVDS_A1+: length 15.5
  TOP w0.102: U11.7 70.22,137.4 70.06,137.55 70.06,137.81 69.61,138.27 68.71,138.27 68.4,137.96 66.39,137.96 66.1,137.66 65.92,137.66 65.65,137.93 65.65,138.11 65.99,138.46 68.27,138.46 68.64,138.82 68.73,138.82 v1(68.95,139.04) 69.34,139.43 69.34,140.41 69.99,141.06 70.49,141.06 71.07,141.63 71.07,142.51 71.24,142.69 JLVDS1.23
SW_LVDS_A1-: length 15.4
  TOP w0.102: JLVDS1.24 70.74,142.71 70.85,142.6 70.85,141.8 70.38,141.33 69.88,141.33 69.07,140.52 69.07,139.54 68.88,139.35 68.76,139.23 68.62,139.09 68.53,139.09 68.16,138.72 65.88,138.72 65.38,138.22 65.38,137.82 v1(65.54,137.66) 65.81,137.4 66.21,137.4 66.5,137.69 68.51,137.69 68.82,138 69.5,138 69.8,137.7 69.8,137.53 69.72,137.45 U11.8
SW_LVDS_A2+: length 8.9
  TOP w0.102: v1(72.64,138.09) 72.66,138.07 72.66,137.54 72.72,137.48 U11.2 ; v3(70.31,142.06) 70.12,142.25 70.12,142.61 70.24,142.73 JLVDS1.25
  IN1 w0.117: v3(70.31,142.06) 70.18,141.94 70.18,141.61 69.96,141.38 69.96,141.03 70.07,140.92 70.41,140.92 70.65,140.69 70.65,140.09 70.75,139.98 72.02,139.98 72.47,139.54 72.47,138.26 v1(72.64,138.09)
SW_LVDS_A2-: length 9
  TOP w0.102: JLVDS1.26 69.74,142.69 69.85,142.58 69.85,142.24 v3(69.67,142.06) ; U11.3 72.22,137.88 v1(72.01,138.09)
  IN1 w0.117: v1(72.01,138.09) 72.18,138.26 72.18,139.42 71.9,139.7 70.64,139.7 70.36,139.97 70.36,140.57 70.3,140.64 69.95,140.64 69.67,140.92 69.67,141.5 69.9,141.73 69.9,141.83 v3(69.67,142.06)
SW_LVDS_ACLK+: length 20.5
  TOP w0.102: C1183.1 67.9,139.56 68.39,139.56 68.59,139.76 68.59,140.74 v3(68.9,141.05) 68.9,141.07 68.74,141.22 68.74,141.86 68.65,141.95 68.65,142.67 68.74,142.76 JLVDS1.28 ; U11.36 74.85,135.92 74.97,136.04 74.97,136.2 74.85,136.32 74.4,136.32 74.24,136.47 74.24,136.76 74.57,137.08 75.02,137.08 75.08,137.02 75.08,136.92 v1(75.03,136.87)
  IN1 w0.117: v3(68.9,141.05) 68.9,141.5 68.99,141.59 68.99,142.08 69.62,142.71 72.54,142.71 73.67,141.58 73.67,140.88 74.86,139.69 74.86,138.24 74.53,137.92 74.53,137.36 v1(75.03,136.87)
SW_LVDS_ACLK-: length 20
  TOP w0.102: U11.1 73.22,136.24 73.29,136.17 73.44,136.17 73.89,136.61 73.89,136.78 74.46,137.35 74.84,137.35 v1(75,137.52) ; JLVDS1.29 68.24,142.72 68.39,142.58 68.39,141.84 68.46,141.76 68.48,141.75 68.48,141.26 v3(68.27,141.05) 68.35,140.96 68.35,140.01 68.22,139.88 67.87,139.88 C1184.1
  IN1 w0.117: v3(68.27,141.05) 68.49,141.27 68.49,141.49 68.71,141.7 68.71,142.2 69.5,142.99 72.66,142.99 73.96,141.7 73.96,141 75.14,139.81 75.14,138.13 74.82,137.8 74.82,137.69 74.99,137.52 v1(75,137.52)
SW_LVDS_B0+: length 19.6
  TOP w0.102: v1(67.3,142.15) 67.09,142.35 67.09,142.57 67.24,142.72 JLVDS1.31 ; U13.9 56.77,138.65 56.67,138.76 56.5,138.76 56.42,138.84 56.42,139.34 55.98,139.79 55.46,139.79 55.19,139.52 55.19,139.3 v3(54.98,139.09)
  IN1 w0.117: v3(54.98,139.09) 55.18,139.28 55.18,139.59 55.64,140.04 58.63,140.04 60.28,141.7 62.88,141.7 64.15,142.97 66.84,142.97 67.12,142.69 67.12,142.33 v1(67.3,142.15)
SW_LVDS_B0-: length 19.6
  TOP w0.102: U13.10 55.29,137.19 55.17,137.31 55.17,137.8 55.46,138.09 55.79,138.09 56.16,138.46 56.16,139.23 55.87,139.52 55.57,139.52 55.46,139.41 55.46,139.25 v1(55.62,139.09) ; JLVDS1.32 66.74,142.74 66.82,142.65 66.82,142.31 v3(66.66,142.15)
  IN1 w0.117: v1(55.62,139.09) 55.46,139.24 55.46,139.47 55.76,139.76 58.74,139.76 60.4,141.42 63,141.42 64.27,142.68 66.73,142.68 66.83,142.58 66.83,142.32 v3(66.66,142.15)
SW_LVDS_B1+: length 18.4
  TOP w0.102: U13.7 57.77,138.67 57.66,138.79 57.66,138.98 57.83,139.15 v1(57.83,139.16) ; v3(66.67,141.51) 66.75,141.51 66.84,141.43 66.84,141.33 66.78,141.26 66.38,141.26 66.14,141.5 66.14,142.65 66.24,142.75 JLVDS1.33
  IN1 w0.117: v1(57.83,139.16) 57.79,139.19 57.74,139.19 57.63,139.07 57.63,138.89 57.81,138.71 58.08,138.71 58.2,138.83 58.2,138.91 58.49,139.2 58.96,139.2 59.59,138.57 63.88,138.57 64.28,138.97 65.2,138.97 65.32,139.09 65.32,139.27 65.62,139.56 66.52,139.56 66.65,139.69 66.65,139.96 66.52,140.09 65.91,140.09 65.61,140.38 65.61,140.97 65.91,141.27 66.63,141.27 66.76,141.39 66.76,141.49 66.73,141.51 v3(66.67,141.51)
SW_LVDS_B1-: length 18.6
  TOP w0.102: JLVDS1.34 65.74,142.74 65.87,142.6 65.87,141.39 66.27,141 66.51,141 v1(66.67,140.83) ; v3(57.19,139.16) 57.39,138.96 57.39,138.85 57.27,138.74 U13.8
  IN1 w0.117: v1(66.67,140.83) 66.52,140.98 66.03,140.98 65.9,140.86 65.9,140.5 66.03,140.37 66.64,140.37 66.93,140.08 66.93,139.57 66.64,139.28 65.73,139.28 65.61,139.15 65.61,138.98 65.31,138.68 64.4,138.68 64,138.29 59.47,138.29 58.84,138.92 58.61,138.92 58.48,138.79 58.48,138.71 58.2,138.43 57.69,138.43 57.34,138.78 57.34,139.01 v3(57.19,139.16)
SW_LVDS_B2+: length 16.4
  TOP w0.102: JLVDS1.35 65.24,142.7 65.12,142.58 65.12,142.38 v3(65.32,142.19) ; v1(60.34,139.15) 60.16,138.97 60.16,138.81 60.27,138.7 U13.2
  IN1 w0.117: v3(65.32,142.19) 65.11,141.97 65.11,141.73 64.77,141.39 64.35,141.39 64.22,141.26 64.22,140.69 64.35,140.56 64.8,140.56 65.1,140.27 65.1,139.76 64.8,139.47 64.08,139.47 63.88,139.27 63.3,139.27 63,139.56 63,140.51 62.88,140.63 62.53,140.63 62.4,140.51 62.4,139.39 62.11,139.1 61.49,139.1 61.2,139.39 61.2,140.51 61.07,140.63 60.72,140.63 60.56,140.47 60.56,139.87 60.32,139.62 60.25,139.62 60.18,139.55 60.18,139.31 60.34,139.14 v1(60.34,139.15)
SW_LVDS_B2-: length 16.3
  TOP w0.102: v3(59.71,139.15) 59.89,138.97 59.89,138.82 59.77,138.71 U13.3 ; v1(64.69,142.19) 64.86,142.36 64.86,142.66 64.74,142.77 JLVDS1.36
  IN1 w0.117: v3(59.71,139.15) 59.71,139.17 59.89,139.36 59.89,139.67 60.13,139.91 60.21,139.91 60.28,139.98 60.28,140.59 60.61,140.92 61.19,140.92 61.48,140.62 61.48,139.51 61.61,139.38 61.99,139.38 62.11,139.51 62.11,140.62 62.41,140.92 62.99,140.92 63.29,140.62 63.29,139.68 63.41,139.55 63.76,139.55 63.96,139.75 64.69,139.75 64.81,139.88 64.81,140.15 64.69,140.28 64.23,140.28 63.94,140.57 63.94,141.38 64.23,141.68 64.65,141.68 64.82,141.85 64.82,142.05 v1(64.69,142.19)
SW_LVDS_BCLK+: length 18
  TOP w0.102: U13.36 62.26,137.19 62.41,137.34 62.41,137.76 61.91,138.25 61.91,138.67 60.89,139.68 60.89,139.86 60.61,140.15 58.96,140.15 58.84,140.27 58.84,140.44 59.19,140.79 59.37,140.79 59.93,141.35 v1(60.53,141.35) 61.15,141.35 61.28,141.22 61.28,140.06 62.42,138.91 63.35,138.91 63.77,139.33 63.77,140.33 C1186.1 63.79,141.17 63.79,141.55 63.65,141.69 63.65,142.6 63.74,142.69 JLVDS1.38
SW_LVDS_BCLK-: length 18
  TOP w0.102: JLVDS1.39 63.24,142.79 63.39,142.65 63.39,141.58 63.52,141.44 63.52,141.22 63.05,140.75 C1185.1 63.5,140.32 63.5,139.44 63.24,139.18 62.53,139.18 61.54,140.17 61.54,141.33 61.26,141.62 59.82,141.62 59.26,141.06 59.08,141.06 58.61,140.59 v1(58.61,140.34) 58.61,140.12 58.85,139.88 60.5,139.88 60.63,139.75 60.63,139.57 61.17,139.03 61.64,138.56 61.64,138.35 61.52,138.23 61.34,138.23 61.14,138.43 61.14,138.63 60.95,138.82 60.82,138.82 60.77,138.78 U13.1
SYS_LED_MASK#: length 49.6
  TOP w0.102: v1(239.28,76.04) 238.83,75.59 238.83,75.08 239.18,74.73 239.6,74.73 240.2,74.12 241.28,74.12 242.48,75.32 243.9,75.32 244.4,74.82 244.4,73.09 244.05,72.75 244.05,72.17 243.32,71.44 242.79,71.44 241.79,70.44 241.79,65.17 239.23,62.6 237.68,62.6 237.32,62.24 237.32,61.86 236.66,61.2 236.66,60.19 v1(236.54,60.06)
  IN2 w0.127: v1(246.49,60.07) 246.39,60.17 240.12,60.17 239.53,59.59 237.02,59.59 236.55,60.06 v1(236.54,60.06) ; v1(242.87,78.28) 242.87,78.27 240.61,76.01 240.61,75.92 240.37,75.67 239.65,75.67 v1(239.28,76.04)
  BOTTOM w0.102: R775.2 241.15,79.78 241.86,79.07 242.7,79.07 242.87,78.89 v1(242.87,78.28) ; v1(236.54,60.06) 236.54,59.82 236.32,59.6 Q321.2 ; U58.1 247.38,61.46 247.25,61.33 247.25,60.82 v2(247.16,60.73) 246.49,60.06 v1(246.49,60.07) ; U46.B48 239.33,76.08 v1(239.28,76.04)
SYS_PWROK: length 452.9
  TOP w0.102: v1(75.25,95.89) 69.4,95.89 65.24,91.72 64.12,91.72 61.3,94.54 59.92,94.54 58.38,96.08 54.58,96.08 54.31,96.34 51.75,96.34 51.54,96.13 48.89,96.13 48.83,96.19 46.43,96.19 44.12,93.88 35.47,93.88 34.24,92.65 30.75,92.65 30.31,93.08 27.85,93.08 27.61,93.32 27.61,93.7 27.39,93.92 25.78,93.92 23.85,91.98 21.42,91.98 20.83,92.57 20.34,92.57 19.16,93.75 17.44,93.75 17.09,94.09 16.03,94.09 15.54,94.58 15.54,97.97 v1(15.07,98.44) ; v1(2.84,113.41) 2.87,113.41 2.93,113.35 6.5,113.35 7.1,112.75 v2(7.97,112.75) 8.61,112.75 v1(9.07,112.29) ; v1(72.86,87.67) 72.86,88.79 73.46,89.38 73.46,93.46 74.27,94.27 v1(74.27,94.34)
  IN1 w0.109: v1(240.74,73.42) 240.93,73.42 241.15,73.63 241.15,75.6 240.9,75.84 240.9,77.26 241.72,78.07 241.72,78.57 239.95,80.34 237.94,80.34 237.71,80.57 232.55,80.57 231.65,81.47 v1(231.06,81.47)
  IN2 w0.127: v1(231.06,81.47) 230.45,81.47 229.97,81.95 229.97,82.21 229.59,82.59 227.99,82.59 227.04,83.54 227.04,84.58 223.62,88 219.55,88 215.82,91.73 210.16,91.73 205.61,96.27 205.61,97.99 204.85,98.76 200.4,98.76 198.17,100.98 198.17,101.99 197.22,102.94 197.22,104.31 196.99,104.55 196.99,107.01 196.54,107.46 196.54,110.31 192.66,114.2 192.66,139.48 188.31,143.83 188.31,145.26 185.88,147.7 182.64,147.7 181.68,148.65 176.12,148.65 176.01,148.77 172.32,148.77 172.12,148.57 169.19,148.57 168.36,147.74 166.5,147.74 165.39,146.63 162.46,146.63 162.39,146.57 159.22,146.57 157.96,147.83 156.16,147.83 155.71,147.38 130.36,147.38 128.88,148.87 116.72,148.87 116.04,148.19 114.24,148.19 114.17,148.26 112.39,148.26 110.89,146.76 105.98,146.76 104.76,147.98 92.41,147.98 92.03,148.36 81.21,148.36 80.65,148.92 78.32,148.92 74.59,152.65 73.38,152.65 72.48,153.56 72.48,154.27 71.4,155.35 68.86,155.35 67.27,153.76 67.23,153.76 67.13,153.66 66.52,153.66 66.42,153.76 47.46,153.76 47.41,153.71 47.38,153.71 47.17,153.51 40.41,153.51 39.84,152.93 39.05,152.93 38.45,152.34 34.4,152.34 32.27,150.2 22.66,150.2 20.92,148.46 17.21,148.46 15.64,146.89 15.64,145.72 13.05,143.13 13.05,141.99 12.05,140.98 12.04,140.98 11.2,140.15 11.2,138.93 10.07,137.8 4.81,137.8 3.74,136.73 3.74,128.93 3.49,128.67 3.49,122.24 2.73,121.48 2.73,120.61 3.29,120.05 3.29,113.86 v1(2.84,113.41) 2.87,113.39 2.87,113.12 3.78,112.21 3.78,106.78 4.48,106.08 4.64,106.08 7.05,103.67 7.87,103.67 8.8,102.74 9.4,102.74 11.75,100.39 12.29,100.39 13.4,99.29 14.1,99.29 14.95,98.44 v1(15.07,98.44)
  BOTTOM w0.102: RH116.1 15.03,95.86 14.58,96.3 14.58,97.94 v1(15.07,98.44) ; v1(9.07,112.29) 9.1,112.33 RH321.2 ; RC11.1 74.66,88.34 73.99,87.67 v1(72.86,87.67) ; U46.B57 240.9,73.7 240.61,73.42 v1(240.74,73.42) ; v1(75.25,95.89) 75.22,95.89 74.29,94.96 74.29,94.36 v1(74.27,94.34)
SYS_PWROK_R: length 21.4
  TOP w0.102: UH4.P12 24.07,109.97 23.67,109.58 v1(23.65,109.58)
  IN4 w0.102: 22.97,104.88 23.21,105.13 23.21,109.07 23.64,109.5 23.64,109.57 v1(23.65,109.58)
  IN4 w0.109: 22.97,104.88 20.99,102.91 18.22,102.91 17.65,102.34 17.65,101.59 16.87,100.81 15.26,100.81 14.21,99.76 14.21,99.01 14.55,98.67 14.55,98.26 v1(15.09,97.73)
  BOTTOM w0.102: v2(24.19,108.79) 24.19,109.04 23.66,109.58 v1(23.65,109.58) ; RH116.2 v1(15.09,97.73)
SYS_PWROK_XDP: length 3.5
  BOTTOM w0.102: JXDP1.13 74.65,89.96 RC11.2 RC3.2 76.25,89.95 v2(76.58,90.27)
SYS_RESET#: length 9.2
  TOP w0.102: UC3.4 20.56,98.12 20.7,98.26 20.7,100.61 20.19,101.12 RH359.2 20.17,101.96 v2(20.85,102.64) 21.41,103.2 21.41,103.95 21.78,104.32 21.78,104.57 22.24,105.03 UH4.K3
SYSTEM_ID: length 4.1
  TOP w0.102: R871.2 C742.1 158.51,146.19 v2(159.51,146.19) 160.65,146.19 160.84,146.38 U54.A10
TCM_BA0: length 4.5
  TOP w0.102: U39.9 U37.9 v2(171.51,96.46) 171.51,96.36 172.06,95.81 R658.2 R660.1
TCM_BA1: length 5.5
  TOP w0.102: R659.1 R657.2 166.04,95.53 166.55,96.04 167.41,96.04 167.61,96.24 v2(167.61,96.46) 167.61,96.46 U37.3
  TOP w0.127: U37.3 U39.3
TEMP_ALERT#: length 255.6
  TOP w0.102: RH18.1 66.37,99.82 v1(66.37,100.13) ; v1(229.42,58.36) 229.42,58.41 229.49,58.47 229.49,59.31 226.62,62.18 223.92,62.18 222.18,63.92 206.69,63.92 202.26,68.35 199.18,68.35 197.56,69.97 197.56,77.71 195.74,79.53 193.93,79.53 192.62,80.84 188.53,80.84 188.34,80.65 186.49,80.65 186.17,80.96 v2(185.62,80.96) 185.44,80.79 182.57,80.79 179.09,84.27 177.53,84.27 175.22,86.57 v1(175.22,87.48) ; UH4.V3 26.2,105 25.9,104.69 25.9,104.39 26.06,104.23 26.06,102.6 26.12,102.54 v1(26.12,102.43) 26.24,102.43 26.72,101.94 26.72,101.58 RH266.1
  IN1 w0.109: v1(175.22,87.48) 175.22,88.99 176.12,89.89 176.12,92.65 175.77,93 v1(175.77,93.33)
  IN2 w0.127: v1(26.12,102.43) 26.45,102.43 27.11,101.77 27.89,101.77 28.68,100.98 29.84,100.98 30.59,101.73 31.3,101.73 31.97,102.4 32.29,102.4 32.62,102.07 36.06,102.07 37.45,103.46 41.86,103.46 43.43,101.89 45.61,101.89 46.39,102.67 51.26,102.67 52.88,104.29 55.85,104.29 57.03,105.47 61.19,105.47 65.51,101.16 65.51,100.99 v1(66.37,100.13) 66.67,100.13 69.71,97.09 73.54,97.09 74.13,97.68 74.13,98.57 74.77,99.21 78.47,99.21 78.98,98.7 82.25,98.7 82.88,99.34 108.53,99.34 109.75,98.12 128.88,98.12 131.7,100.94 149.06,100.94 150.67,99.33 172.65,99.33 174.43,97.54 174.43,95.89 175.69,94.63 175.69,93.41 v1(175.77,93.33)
  BOTTOM w0.102: v1(229.42,58.36) 229.88,58.81 230.31,58.81 230.73,58.4 231.72,58.4 231.88,58.55 231.88,60.17 R741.2
TEMP_ALERT#_R: length 11
  TOP w0.102: v2(232.13,65.42) 232.55,65 v1(232.78,65)
  IN1 w0.109: v1(235.83,68.53) 235.83,67.92 234.54,66.64 234.54,65.7 234,65.15 232.93,65.15 v1(232.78,65)
  BOTTOM w0.102: R741.1 232.4,61.5 232.78,61.87 v1(232.78,65) ; v1(235.83,68.53) U46.B11
TEST: length 3.9
  BOTTOM w0.102: R86.1 207.33,83.53 R41.2 208.09,84.9 U26.18
THERM_STP#: length 207.5
  TOP w0.102: v1(144.74,164.71) 144.74,164.83 R390.1 144.12,164.85 144.07,164.8 U18.25
  IN1 w0.109: v1(243.85,80.66) 244.6,79.91 244.6,75.67 247.81,72.45 247.81,68.64 250,66.46 250,65.27 v1(250.9,64.37)
  IN2 w0.127: v1(144.74,164.71) 152.11,164.71 152.7,164.11 156.83,164.11 157.51,164.79 174.39,164.79 174.85,164.33 190.09,164.33 191.15,163.27 196.55,163.27 201.96,157.86 207.15,157.86 208.65,156.37 208.65,156.19 211.03,153.81 211.4,153.81 212.32,152.89 212.32,129.87 211.44,128.99 211.44,105.32 212.06,104.7 213.34,104.7 218.16,99.88 218.16,98.3 227.48,88.98 228.39,88.98 232.38,84.99 234.33,84.99 235.94,83.38 236.19,83.38 238.56,81.01 243.5,81.01 v1(243.85,80.66)
  BOTTOM w0.102: PR118.1 266.8,62.55 267.31,62.04 v2(267.31,60.64) 266.8,60.14 255.24,60.14 251.01,64.37 v1(250.9,64.37)
THERMATRIP1#: length 9.3
  TOP w0.102: Q28.1 v2(150.47,163.64) 150.47,163.35 149.99,162.87 R396.2 149.5,161.86 149.01,162.36 147.69,162.36 C327.1 146.89,162.17 146.14,162.17 145.55,161.58 U18.22
THERMATRIP2#: length 3.7
  TOP w0.102: U18.23 145.34,162.08 146.14,162.88 v2(146.25,162.88) C350.1
  TOP w0.127: C350.1 R398.2
THERMATRIP3#: length 6.7
  TOP w0.102: Q115.1 147.15,165 146.7,165.45 R397.2 ; R397.2 v2(146.15,164.33) 146.15,163.51 145.22,162.58 U18.24 ; R397.2 C343.1
THERMB3: length 3.7
  TOP w0.102: v2(149.68,169.94) 148.97,169.23 148.97,168.69 148.44,168.16 R401.2 148.44,167.55 148.58,167.41 Q115.2
TMDS_DDCBUF: length 5
  TOP w0.102: U9.2 46.84,143.91 47.45,143.31 47.45,142.37 v2(47.64,142.17) 47.79,142.02 47.79,141.49 47.61,141.31 R66.2
  TOP w0.127: R68.2 48.6,140.95 R66.2
TMDS_PRE: length 4
  TOP w0.102: U9.20 v1(43.37,148.58)
  BOTTOM w0.102: R67.2 R65.2 v2(43.9,149.11) v1(43.37,148.58)
TMDS_RT: length 10.3
  TOP w0.102: U9.23 v1(42.17,148.68)
  BOTTOM w0.102: R71.2 46.23,148.13 R57.2 46.69,148.11 46.9,147.9 46.9,146.89 46.67,146.66 42.49,146.66 v2(42.39,146.76) 42.25,146.9 42.25,148.6 v1(42.17,148.68)
TMDSE_CON_CLK: length 21
  TOP w0.102: v1(33.2,167.34) 33.37,167.16 33.37,167.01 33.39,166.99 33.39,166.11 C1333.1 33.23,165.4 33.23,164.85 32.95,164.56 L19.3 32.87,164.03 R451.2
  IN1 w0.117: JHDMI1.10 32.72,169.56 32.72,170.07 33.09,170.44 36.61,170.44 37.9,169.15 37.9,167.84 37.53,167.47 37.53,165.89 36.56,164.92 33.89,164.92 33.36,165.45 33.36,167.18 v1(33.2,167.34)
TMDSE_CON_CLK#: length 21.1
  TOP w0.102: R452.2 33.88,164.03 L19.2 33.8,164.65 33.72,164.73 33.58,164.73 33.5,164.81 33.5,165.6 33.58,165.68 C1334.1 34.09,165.8 33.65,166.23 33.65,167.1 33.64,167.12 33.64,167.4 33.73,167.49 33.93,167.49 v1(34.08,167.34)
  IN1 w0.117: JHDMI1.12 33.15,169.29 33.01,169.43 33.01,169.96 33.2,170.16 36.49,170.16 37.62,169.03 37.62,167.95 37.25,167.59 37.25,166.01 36.44,165.2 34.01,165.2 33.64,165.57 33.64,167.41 33.77,167.54 33.95,167.54 34.08,167.41 v1(34.08,167.34)
TMDSE_CON_N0: length 5.2
  TOP w0.102: R454.2 31.85,164.03 L23.2 31.77,164.64 31.58,164.82 31.58,165.27 32,165.68 C1335.1 32.01,165.68 31.57,166.12 31.57,167.91 JHDMI1.9
TMDSE_CON_N1: length 16.7
  TOP w0.102: R456.2 29.82,164.03 L24.2 29.74,164.66 29.69,164.71 29.69,165.44 C1337.1 29.5,166.11 29.5,167.02 v1(29.95,167.46)
  IN1 w0.117: JHDMI1.6 30.18,169.56 30.18,169.98 29.71,170.45 27.59,170.45 27.06,169.92 27.06,166.28 27.63,165.71 29.17,165.71 29.79,166.32 29.79,167.31 v1(29.95,167.46)
TMDSE_CON_N2: length 6.1
  TOP w0.102: R458.2 27.79,164.03 L25.2 27.7,164.5 27.38,164.82 27.38,165.39 C1339.1 27.24,166.11 27.24,167.2 27.41,167.37 27.89,167.37 28.8,168.29 JHDMI1.3
TMDSE_CON_P0: length 5.3
  TOP w0.102: R453.2 30.83,164.03 L23.3 30.92,164.47 31.32,164.87 31.32,165.24 C1336.1 31.3,166.07 31.3,167.94 JHDMI1.7
TMDSE_CON_P1: length 16.6
  TOP w0.102: v1(29.07,167.49) 29.23,167.32 29.23,166.14 28.8,165.71 C1338.1 29.28,165.68 29.42,165.53 29.42,164.87 29.32,164.77 28.99,164.77 28.89,164.66 L24.3 28.8,164.03 R455.2
  IN1 w0.117: JHDMI1.4 29.79,169.29 29.89,169.39 29.89,169.86 29.59,170.16 27.7,170.16 27.34,169.8 27.34,166.4 27.75,165.99 29.06,165.99 29.51,166.44 29.51,167.64 29.38,167.77 29.2,167.77 29.07,167.64 v1(29.07,167.49)
TMDSE_CON_P2: length 6.1
  TOP w0.102: JHDMI1.1 27.95,167.82 27.77,167.64 27.3,167.64 26.97,167.31 26.97,166.24 26.54,165.81 C1340.1 26.99,165.68 27.11,165.56 27.11,164.87 26.85,164.61 L25.3 26.77,164.03 R459.2
TMDSE_RP_CLK: length 25.3
  TOP w0.102: U9.16 44.97,150.18 45.06,150.27 45.06,150.78 45.27,151 45.27,152.53 v3(45.04,152.76) ; R451.1 32.87,162.49 L19.4 32.95,161.93 33.24,161.64 33.24,161.26 v1(33.07,161.09)
  IN1 w0.117: v1(33.07,161.09) 33.23,160.93 33.23,160.54 33.48,160.29 36.02,160.29 36.7,160.97 42.73,160.97 44.88,158.81 44.88,155.44 45.46,154.86 45.46,153.53 45.22,153.3 45.22,152.94 v3(45.04,152.76)
TMDSE_RP_CLK#: length 25.3
  TOP w0.102: R452.1 33.88,162.49 L19.1 33.8,161.91 33.51,161.62 33.51,161.28 v3(33.7,161.09) ; v1(45.68,152.76) 45.54,152.62 45.54,150.89 45.32,150.67 45.32,150.27 45.37,150.22 U9.15
  IN1 w0.117: v1(45.68,152.76) 45.51,152.93 45.51,153.18 45.74,153.42 45.74,154.97 45.16,155.55 45.16,158.93 42.84,161.25 36.58,161.25 35.91,160.58 33.59,160.58 33.51,160.66 33.51,160.9 v3(33.7,161.09)
TMDSE_RP_N0: length 25.8
  TOP w0.102: v3(44.19,150.99) 44.05,150.86 44.05,150.33 44.17,150.21 U9.18 ; R454.1 31.85,162.49 L23.1 31.77,161.93 31.48,161.64 31.48,161.28 v1(31.67,161.09)
  IN1 w0.117: v3(44.19,150.99) 44.04,151.14 44.04,151.66 43.83,151.88 43.83,152.94 44.03,153.14 44.03,158.74 42.51,160.25 37.08,160.25 36.61,159.78 32.06,159.78 31.51,160.34 31.51,160.92 v1(31.67,161.09)
TMDSE_RP_N1: length 22.9
  TOP w0.102: U9.21 42.97,150.12 42.86,150.23 42.86,152.47 v3(43.08,152.68) ; R456.1 29.82,162.49 L24.1 29.74,161.97 29.44,161.68 29.44,161.31 v1(29.63,161.12)
  IN1 w0.117: v3(43.08,152.68) 42.9,152.86 42.9,153.4 37.75,158.55 31.61,158.55 29.48,160.68 29.48,160.97 v1(29.63,161.12)
TMDSE_RP_N2: length 23
  TOP w0.102: v1(27.57,161.19) 27.41,161.35 27.41,161.67 27.7,161.96 L25.1 27.79,162.49 R458.1 ; U9.24 41.77,150.15 41.71,150.22 41.71,150.77 v3(41.92,150.98)
  IN1 w0.117: v3(41.92,150.98) 41.64,151.26 41.64,151.92 35.86,157.7 30.12,157.7 27.43,160.39 27.43,161.05 v1(27.57,161.19)
TMDSE_RP_P0: length 25.8
  TOP w0.102: v1(43.55,150.99) 43.79,150.76 43.79,150.33 43.77,150.31 U9.19 ; R453.1 30.83,162.49 L23.4 30.92,161.91 31.21,161.61 31.21,161.26 v3(31.04,161.09)
  IN1 w0.117: v1(43.55,150.99) 43.75,151.19 43.75,151.55 43.54,151.76 43.54,153.06 43.74,153.25 43.74,158.62 42.4,159.96 37.2,159.96 36.73,159.5 31.94,159.5 31.22,160.22 31.22,160.9 v3(31.04,161.09)
TMDSE_RP_P1: length 22.8
  TOP w0.102: R455.1 28.8,162.49 L24.4 28.89,161.96 29.18,161.67 29.18,161.31 v3(28.99,161.12) ; v1(42.44,152.68) 42.59,152.53 42.59,150.23 42.57,150.21 U9.22
  IN1 w0.117: v1(42.44,152.68) 42.62,152.86 42.62,153.28 37.63,158.26 31.49,158.26 29.19,160.56 29.19,160.92 v3(28.99,161.12)
TMDSE_RP_P2: length 22.9
  TOP w0.102: U9.25 41.37,150.14 41.43,150.19 41.43,150.84 v1(41.28,150.98) ; R459.1 26.77,162.49 L25.4 26.85,161.93 27.14,161.64 27.14,161.4 v3(26.94,161.19)
  IN1 w0.117: v1(41.28,150.98) 41.35,151.06 41.35,151.8 35.74,157.42 30,157.42 27.15,160.27 27.15,160.98 v3(26.94,161.19)
TOUCH_SCREEN_PD#: length 292.6
  TOP w0.102: v1(240.66,74.74) 240.79,74.74 241.15,75.1 241.15,76.01 239.42,77.74 233.03,77.74 232.92,77.85 231.79,77.85 230.98,77.04 229.88,77.04 229.4,77.52 229.4,77.93 229.06,78.27 227.27,78.27 226.36,79.18 226.36,79.41 221.82,83.95 v3(219.89,83.95) ; v1(9.05,131.09) 9.27,130.87 R419.2 9.79,130.06 7.93,128.2 JCAM1.7
  IN2 w0.127: v1(9.05,131.09) 9.89,131.09 11.26,132.46 12.44,132.46 13.96,133.98 13.96,136.51 17.38,139.93 18.38,139.93 20.76,142.32 25.99,142.32 26.02,142.29 26.07,142.29 26.88,141.48 31.09,141.48 32.53,140.04 32.93,140.04 33.06,139.9 35.82,139.9 36.88,138.84 42.43,138.84 43.47,139.88 45.02,139.88 45.83,140.69 51.27,140.69 52.27,141.69 62.98,141.69 64.17,142.89 66.1,142.89 66.38,143.17 67.74,143.17 68.39,142.53 70.46,142.53 70.76,142.23 70.76,140.77 71.95,139.58 73.03,139.58 73.33,139.28 74.46,139.28 74.84,138.9 80.49,138.9 82.84,141.25 91.74,141.25 92.68,142.19 108.19,142.19 109.15,141.22 110.37,141.22 111.72,142.57 117.69,142.57 119.66,140.6 119.66,140.42 120.96,139.12 123.69,139.12 125.1,137.71 149.86,137.71 150.9,138.75 153.67,138.75 155.46,136.96 158.2,136.96 158.71,136.45 159.43,136.45 162.74,133.15 169.26,133.15 179.22,123.18 179.22,120.98 181.73,118.48 183.04,118.48 185.39,116.13 185.39,110.92 185.96,110.35 186.93,110.35 189.23,108.05 189.23,107.4 190,106.63 190,105.4 191.27,104.13 191.27,99.96 192.42,98.81 192.42,97.74 197.15,93 197.15,91.8 199.17,89.78 201.42,89.78 202.46,88.74 207.03,88.74 208.77,86.99 216.57,86.99 219.61,83.95 v3(219.89,83.95)
  BOTTOM w0.102: U46.B55 241.39,74.74 v1(240.66,74.74)
TP_LAN_JTAG_TCK: length 3.5
  TOP w0.102: U31.35 127.59,162.65 128.08,163.13 R546.2 v2(129.42,164.07)
TP_LAN_JTAG_TDI: length 1.4
  TOP w0.102: T142.1 128.33,161.45 U31.32
TP_LAN_JTAG_TDO: length 1.6
  TOP w0.102: T143.1 128.03,162.25 U31.34
TP_LAN_JTAG_TMS: length 2.4
  TOP w0.102: U31.33 129.4,161.85 R545.2
TPM_ID0: length 7.8
  TOP w0.102: v1(20.85,101.99) 20.85,101.5 21.18,101.17 RH267.1 ; v1(23.07,103.38) 23.11,103.42 23.11,103.43 23.47,103.78 23.47,104.34 23.67,104.55 23.67,104.93 UH4.N2
  IN1 w0.102: 22.88,103.19 v1(23.07,103.38)
  IN1 w0.109: 22.88,103.19 22.64,102.95 21.87,102.95 20.92,101.99 v1(20.85,101.99)
  BOTTOM w0.102: v2(19.95,102.07) 20.01,102.01 20.84,102.01 v1(20.85,101.99) 20.17,101.31 RH270.2
TPM_ID1: length 10.8
  TOP w0.102: UH4.M3 23.23,104.99 22.61,104.37 22.61,103.79 22.64,103.76 22.64,103.25 21.69,102.3 21.69,99.25 21.14,98.7 v2(21.14,98.48) 21.14,97.35 RH271.1
  TOP w0.127: RH271.1 RH268.2
TRIP_+V1.05S_VCCPP: length 3.8
  BOTTOM w0.254: PU501.2 57.68,23.35 57.34,23.02 57.34,22.76 57.15,22.56 57.15,21.08 PR503.2
TRIP_+V1.05SP: length 4.1
  TOP w0.102: PR403.2 v2(8.38,156.18)
  TOP w0.254: PU401.2 5.21,155.29 5.56,155.64 6.93,155.64 PR403.2
UG_3V: length 10.2
  TOP w1.016: 280.81,49.95 280.82,49.96 280.82,50.47 282.17,51.82 282.17,54.88 280.16,56.88 v2(280.16,58.75)
  vias: v1(279.08,60.01) v1(279.72,60.01) v1(280.57,49.51) v1(281.25,49.49)
UG_5V: length 10.8
  TOP w0.102: v1(264.26,52.39) v2(264.26,53.05)
  IN1 w0.762: 271.88,60.01 264.71,52.84
  vias: v1(263.63,52.4) v1(272.36,60.01) v1(273.02,60.01)
UG_+V1.05S_VCCPP: length 14.7
  TOP w0.762: 70.31,13.78 67.78,13.78 61.82,19.73 61.82,22.57
  BOTTOM w0.102: v1(70.7,13.78) v2(70.7,12.89)
  vias: v1(61.83,22.87) v1(62.48,22.89) v1(71.33,13.78)
UG_+V1.05SP: length 5.2
  BOTTOM w0.102: v2(3.52,147.43) 3.53,147.43 4.1,146.86 4.1,146.85 PQ401.4
  BOTTOM w0.635: 4.48,147.45 5.82,148.78 v1(5.82,150.81)
UGATE1: length 14.4
  TOP w0.102: v2(34.74,63.99) v1(35.66,63.99)
  IN2 w1.016: 34.64,64.2 33.51,65.33 33.51,72.82 30.83,75.5 30.2,75.5
  vias: v1(29.37,76.45) v1(30.01,76.45) v1(35.13,58.37) v1(35.1,57.72) v1(35.66,63.36)
UGATE1G: length 5
  IN4 w1.016: 30.58,83.5 32.36,83.5 34.14,81.73
  BOTTOM w0.102: v1(29.69,83.88) 29.68,83.88 v2(29.22,84.34)
  vias: v1(29.69,83.25) v1(34.77,81.01) v1(35.53,81.01)
UGATE2: length 7.1
  IN2 w1.016: 34.4,76.09 34.01,76.09 33.53,76.57 33.53,80.81 32.87,81.47 32.04,81.47
  vias: v1(30.52,80.84) v1(30.83,81.41) v1(35.03,69.28) v1(35.14,75.12) v1(35.53,69.66) v1(35.81,75.13) v2(34.8,69.84)
UGATE2G: length 5.4
  IN4 w0.635: 29.32,89.29 29.5,89.29 30.08,88.71 33.88,88.71 34.34,88.25
  vias: v1(28.46,89.31) v1(29.13,89.29) v1(35.14,87.86) v1(35.69,87.49) v2(34.87,87.39)
UGATE3:
  vias: v1(43.29,47.88) v1(43.29,47.19) v1(45.81,45.62) v1(46.51,45.66) v1(49.63,47.86) v1(49.63,47.1) v2(44.18,47.45)
UIM_CLK: length 345.8
  IN1 w0.109: v1(271.03,36.68) 267.03,36.68 v1(266.32,35.97) 265.72,35.37 263.53,35.37 256.71,28.55 218.81,28.55 208.38,38.98 208.38,55.39 215.45,62.46 215.45,66.09 219.58,70.22 219.58,71.5 220.29,72.21 v1(220.29,72.31) ; v1(105.1,144.34) 105.1,144.71 107.15,146.75 107.15,147.65 108.29,148.79 108.29,151.03 109.5,152.24 109.91,152.24 110.73,153.06 110.73,153.66 112.19,155.12 114.41,155.12 115.35,154.18 118.15,154.18 118.71,153.62 119.54,153.62 120.84,152.33 136.13,152.33 136.5,151.96 142.06,151.96 142.48,152.38 146.1,152.38 146.53,152.81 151.34,152.81 152.46,153.92 152.46,154.66 156.48,158.68 157.9,158.68 160.28,161.06 165.73,161.06 168.53,158.27 181.28,158.27 181.84,158.83 181.84,159.96 184.3,162.42 188.7,162.42 189.2,161.92 189.2,158.24 194.78,152.66 194.78,148.99 195.71,148.07 195.71,129.48 197.39,127.79 197.39,125.97 198.23,125.13 198.23,119.74 197.07,118.58 194.42,118.58 191.9,116.06 191.9,108.91 191.08,108.09 191.08,97.09 197.5,90.68 201.34,90.68 204.77,87.25 204.77,86.93 v1(204.81,86.89)
  IN3 w0.127: v1(204.81,86.89) 204.81,86.74 205.59,85.97 206.22,85.97 208.66,83.53 213.63,83.53 215.8,81.35 222.3,81.35 223.72,79.92 223.72,76.29 220.29,72.86 v1(220.29,72.31)
  BOTTOM w0.102: JMINI1.12 107.11,144.65 106.89,144.86 105.62,144.86 v1(105.1,144.34) ; C628.1 266.37,36.44 266.37,36.02 v1(266.32,35.97) 266.38,35.9 266.38,35.19 266.16,34.97 U40.3 ; JSIM1.3 268.64,29.84 271.12,32.32 v2(271.12,34.05) 271.12,36.59 v1(271.03,36.68)
UIM_DATA: length 335.8
  IN1 w0.109: v1(106.69,144.35) 106.73,144.31 107.9,144.31 109.7,146.11 109.7,150.13 110.31,150.74 110.31,151.52 111.21,152.43 111.64,152.43 112.81,153.6 117.75,153.6 119.53,151.82 129,151.82 130.26,150.55 145.06,150.55 146.76,152.25 151.7,152.25 153.19,153.73 153.19,154.62 154.79,156.22 158.15,156.22 159.93,158 159.93,158.43 161.34,159.84 165.99,159.84 168.12,157.71 181.57,157.71 182.35,158.48 182.35,159.77 184.44,161.86 186.03,161.86 187.43,160.47 187.43,159.28 194.28,152.43 194.28,148.77 195.2,147.85 195.2,129.22 196.89,127.53 196.89,125.76 197.69,124.96 197.69,119.89 196.86,119.07 194.21,119.07 191.41,116.26 191.41,109.13 190.52,108.25 190.52,96.86 197.28,90.11 200.96,90.11 v1(204.18,86.89) ; v1(271.87,36.65) 271.16,35.94 v1(267.03,35.94) 265.95,34.86 263.78,34.86 256.95,28.03 218.63,28.03 207.85,38.81 207.85,55.94 214.93,63.02 214.93,66.32 219.06,70.45 219.06,71.78 v1(219.63,72.35)
  IN3 w0.127: v1(204.18,86.89) 204.18,86.45 204.06,86.34 204.06,85.56 204.3,85.32 205.95,85.32 208.28,83 213.28,83 217.33,78.94 217.33,75.17 219.63,72.87 v1(219.63,72.35)
  BOTTOM w0.102: v1(106.69,144.35) 106.69,144.13 106.98,143.85 JMINI1.10 ; U40.4 267.08,34.97 266.91,35.14 266.91,35.83 v1(267.03,35.94) 266.86,36.11 266.86,36.52 C631.1 ; v1(271.87,36.65) 271.87,32.16 v2(271.44,31.73) 269.91,30.2 JSIM1.7
UIM_RESET: length 337.3
  IN1 w0.109: v1(205.47,86.91) 205.33,87.05 205.33,87.44 201.52,91.25 197.81,91.25 191.6,97.46 191.6,107.85 192.42,108.67 192.42,115.83 194.68,118.09 197.27,118.09 198.75,119.57 198.75,125.33 197.9,126.18 197.9,128.25 196.98,129.17 196.98,147.57 195.29,149.26 195.29,152.95 190.54,157.7 190.54,161.79 189.42,162.91 184.03,162.91 180.25,159.13 172.65,159.13 171.95,159.84 168.03,159.84 166.15,161.71 158.77,161.71 151.09,154.03 148.56,154.03 148.27,154.32 145.01,154.32 143.57,152.88 142.14,152.88 141.55,153.46 137.92,153.46 137.39,152.93 121.17,152.93 119.96,154.14 118.92,154.14 117.94,155.12 117.05,155.12 116.55,155.63 112,155.63 110.21,153.84 110.21,153.31 109.64,152.75 109.29,152.75 107.78,151.24 107.78,149.09 106.16,147.47 106.16,146.48 104.48,144.8 104.48,144.42 104.44,144.39 v1(104.44,144.32) ; v1(262.72,35.89) 262.72,35.48 256.29,29.04 219.1,29.04 208.89,39.26 208.89,54.98 215.96,62.05 215.96,65.85 220.09,69.98 220.09,71.07 220.93,71.91 v1(220.93,72.47)
  IN3 w0.127: v1(220.93,72.47) 220.93,72.62 224.37,76.06 224.37,80 222.46,81.9 215.97,81.9 213.8,84.07 208.83,84.07 206.43,86.47 205.83,86.47 205.47,86.83 v1(205.47,86.91)
  BOTTOM w0.102: JMINI1.14 105.46,145.44 104.44,144.42 v1(104.44,144.32) ; v1(262.72,35.89) v2(262.72,34.72) 262.72,33.53 263.18,33.07 U40.1 266.38,33.07 266.55,32.91 266.55,32.06 C629.1 266.1,31.62 JSIM1.2
