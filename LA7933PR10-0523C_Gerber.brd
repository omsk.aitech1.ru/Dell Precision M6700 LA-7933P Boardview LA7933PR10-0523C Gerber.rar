# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UIM_VPP: length 325.5
  IN1 w0.109: v1(203.54,86.82) 203.45,86.91 202.94,86.91 200.4,89.45 196.28,89.45 190.02,95.71 190.02,106.93 189.6,107.35 189.6,108.23 190.87,109.5 190.87,116.54 194.5,120.17 196.68,120.17 197.08,120.56 197.08,124.66 196.68,125.06 196.18,125.06 194.69,126.54 194.69,147.61 193.77,148.53 193.77,152.11 186.93,158.95 186.93,160.19 185.76,161.37 184.71,161.37 183.76,160.43 183.76,159.05 181.81,157.1 167.92,157.1 165.71,159.31 162.03,159.31 161.69,158.98 161.69,158.18 161.17,157.66 160.41,157.66 158.41,155.65 155.19,155.65 154.47,154.93 154.47,154.29 151.9,151.73 146.98,151.73 145.29,150.04 130.05,150.04 128.81,151.28 118.24,151.28 116.48,153.04 113.35,153.04 110.21,149.9 110.21,145.38 v1(109.51,144.68) ; v1(218.95,72.42) 218.57,72.03 218.57,70.65 214.44,66.52 214.44,63.22 207.36,56.15 207.36,38.49 218.36,27.5 264.3,27.5 v3(269.12,32.32)
  IN3 w0.127: v1(203.54,86.82) 203.54,85.32 204.34,84.53 206,84.53 208.04,82.49 213.05,82.49 216.69,78.85 216.69,74.89 218.95,72.63 v1(218.95,72.42)
  BOTTOM w0.102: v3(269.12,32.32) 268.37,33.07 U40.6 266.97,33.07 266.83,32.93 266.83,31.96 C630.1 267.37,31.42 JSIM1.6 ; v1(109.51,144.68) 109.51,145.69 108.96,146.25 JMINI1.16
USB1_A_DE0: length 5.7
  BOTTOM w0.102: R104.2 268.58,70.65 U625.16 ; R104.2 R23.2 ; R104.2 268.58,69.63 v2(268.58,68.28)
USB1_A_DE1: length 4.7
  BOTTOM w0.102: R809.2 R25.2 v2(266.07,71.18) 266.55,71.18 267.58,72.22 U625.18
USB1_A_EQ0: length 3.8
  BOTTOM w0.102: R24.2 R106.2 v2(268.08,71.16) U625.17
USB1_A_EQ1: length 5.9
  BOTTOM w0.102: U625.15 269.08,71.15 R22.2 R108.2 270.64,69.65 v2(270.64,68.22)
USB1_B_DE0: length 5.7
  BOTTOM w0.102: R16.2 R103.2 ; R103.2 268.58,78.45 U625.3 ; R103.2 267.82,79.22 267.82,80.75 v2(267.88,80.81)
USB1_B_DE1: length 3.8
  BOTTOM w0.102: U625.6 270.08,77.42 v2(270.41,77.75) R21.2 R773.2
USB1_B_EQ0: length 4
  BOTTOM w0.102: R105.2 R18.2 v2(267.22,77.78) 268.08,76.92 U625.2
USB1_B_EQ1: length 3.4
  BOTTOM w0.102: U625.4 v2(269.08,77.71) 269.08,78.45 R107.2 R15.2
USB1_TEST: length 4.1
  BOTTOM w0.102: U625.14 269.58,71.45 v2(269.93,71.1) 270.36,70.68 271.59,70.68 R12.2
USB2_A_DE0: length 5.5
  BOTTOM w0.102: U626.16 256.14,70.14 R113.2 R32.2 256.59,69.58 v2(256.59,68.28)
USB2_A_DE1: length 4.2
  BOTTOM w0.102: U626.18 255.14,72.19 254.07,71.13 ; 254.07,71.13 R34.2 R826.2 ; 254.07,71.13 v2(254.07,71.12)
USB2_A_EQ0: length 3.6
  BOTTOM w0.102: R33.2 R114.2 255.64,70.66 v2(255.64,71.3) U626.17
USB2_A_EQ1: length 6.4
  BOTTOM w0.102: v2(259.71,68.22) 259.71,69.61 259.19,70.13 R111.2 R31.2 257.62,70.68 257.15,70.68 256.64,71.19 U626.15
USB2_B_DE0: length 5.6
  BOTTOM w0.102: R112.2 255.64,79.21 v2(255.64,80.84) ; R112.2 R28.2 ; R112.2 256.14,78.71 U626.3
USB2_B_DE1: length 3.9
  BOTTOM w0.102: U626.6 257.64,77.17 v2(258.18,77.71) R30.2 R813.2
USB2_B_EQ0: length 4
  BOTTOM w0.102: R110.2 R29.2 254.1,78.7 254.7,78.1 254.97,78.1 v2(255.45,77.62) 255.64,77.43 U626.2
USB2_B_EQ1: length 3.5
  BOTTOM w0.102: R27.2 R109.2 256.78,78.34 v2(256.78,77.71) 256.64,77.57 U626.4
USB2_TEST: length 4.8
  BOTTOM w0.102: R26.2 259.4,70.93 257.45,70.93 v2(257.26,71.13) 257.14,71.25 U626.14
USB3_RX1_N_D-: length 15.9
  BOTTOM w0.102: R746.2 287.69,110.07 L40.4 287.69,110.68 288,110.99 288,111.28 288.3,111.58 288.3,111.67 288.15,111.82 D14.5 D14.6 288.15,114.02 288.31,114.18 v1(288.31,115.15) 288.33,115.16 288.33,115.33 288.31,115.34 288.31,117.38 288.3,117.39 288.3,117.99 288.31,118 288.31,120.83 290.36,122.87 290.79,122.87 JUSB1.5
USB3_RX1_P_D+: length 16.1
  BOTTOM w0.102: R745.2 288.54,110.12 L40.1 288.54,110.71 288.2,111.04 288.2,111.19 288.52,111.51 288.52,111.7 288.65,111.83 D14.4 D14.7 288.65,114.06 288.53,114.18 288.53,114.87 288.54,114.88 288.54,115.42 288.53,115.43 v1(288.53,117.69) 288.53,120.74 290.45,122.66 290.9,122.66 290.99,122.75 291.67,122.75 291.76,122.65 JUSB1.6
USB3_RX2_N_D-: length 8.3
  TOP w0.102: R752.2 284.92,100.19 L43.1 285.42,100.08 285.74,99.77 285.86,99.77 286.28,100.19 286.75,100.19 286.85,100.3 D16.6 D16.5 288.88,100.3 289.06,100.11 290.46,100.11 290.64,99.94 291.54,99.94 291.76,100.16 JUSB2.5
USB3_RX2_P_D+: length 8.4
  TOP w0.102: JUSB2.6 291.76,99.48 291.51,99.72 290.55,99.72 290.37,99.9 288.96,99.9 288.86,99.8 D16.4 D16.7 286.97,99.8 286.8,99.96 286.4,99.96 v1(286.24,99.8) 285.98,99.55 285.68,99.55 285.36,99.23 L43.4 284.97,99.17 R753.2
USB3_TX1_N_D-: length 9.4
  BOTTOM w0.102: R743.2 289.72,110.07 L42.4 289.72,110.74 290.06,111.08 290.06,111.19 289.81,111.44 289.81,111.73 289.65,111.89 D14.2 D14.9 289.65,114.14 289.8,114.28 289.8,114.85 289.81,114.86 v1(289.81,116.21) 289.81,116.56 290.31,117.06 290.98,117.06 JUSB1.8
USB3_TX1_P_D+: length 9.5
  BOTTOM w0.102: JUSB1.9 291.76,116.4 291.32,116.84 290.4,116.84 290.04,116.48 290.04,115.93 290.03,115.91 v1(290.03,114.55) 290.03,114.3 290.15,114.17 D14.10 D14.1 290.15,111.87 290.02,111.74 290.02,111.54 290.28,111.28 290.28,111.08 290.57,110.79 L42.1 290.57,110.12 R744.2
USB3_TX2_N_D-: length 12.9
  TOP w0.102: JUSB2.8 291.76,94.06 291.57,93.87 290.93,93.87 290.68,94.12 290.68,94.92 289.72,95.87 289.72,98.22 289.42,98.53 289.24,98.53 288.97,98.8 D16.2 D16.9 286.92,98.8 286.75,98.63 286.46,98.63 286.19,98.36 v1(286.19,97.99) 286.19,97.68 285.94,97.43 285.83,97.43 285.52,97.75 L44.1 284.77,97.75 R750.2
USB3_TX2_P_D+: length 12.7
  TOP w0.102: JUSB2.9 291.76,93.42 291.53,93.65 290.84,93.65 290.46,94.03 290.46,94.83 289.51,95.78 289.51,98.13 289.33,98.31 289.24,98.31 289.23,98.3 D16.1 D16.10 286.89,98.3 286.78,98.41 286.61,98.41 286.42,98.22 286.42,97.55 286.09,97.21 285.83,97.21 285.52,96.9 L44.4 284.72,96.9 R751.2
USB3RN1: length 268.7
  TOP w0.102: v1(39,117.31) 39,117.65 39.18,117.84 UH4.BE28
  IN4 w0.102: v1(39,117.31) 39,117.46 39.24,117.7 42.14,117.7 42.5,118.06 42.67,118.06 42.67,118.05 42.77,118.05
  IN4 w0.117: v1(262.76,74.74) 262.9,74.59 263.02,74.59 263.02,74.6 263.6,74.6 264.12,74.08 264.12,72.93 264.12,72.93 264.12,70.35 264.12,70.15 262.95,68.98 262.75,68.98 252.41,68.98 250.2,71.2 248.83,71.2 248.24,70.62 248.24,67.41 246.14,65.31 245.09,65.31 243.5,63.72 236.31,63.72 235.55,64.47 234.94,64.47 234.34,65.07 233.35,65.07 232.96,65.46 227.66,65.46 226.98,66.14 226.98,73.27 224.48,75.77 224.48,78.37 221.46,81.39 216.24,81.39 213.77,83.87 209.2,83.87 207.79,85.28 203.93,85.28 201.66,87.55 197.94,87.55 194.58,90.91 184.25,90.91 183.36,91.79 180.82,91.79 179.73,92.88 177.97,92.88 175.91,94.95 174.97,94.95 174.39,95.52 174.39,97.37 173.42,98.35 159.43,98.35 156.96,100.83 131.38,100.83 130.26,101.95 103.38,101.95 102.42,102.91 83.19,102.91 80.3,105.8 77.93,105.8 77.45,106.27 71.94,106.27 70.69,107.52 70.27,107.52 69.31,108.49 68.44,108.49 66.33,110.6 65.56,110.6 64.1,112.06 63.88,112.06 61.13,114.81 52.19,114.81 49.85,117.15 48.31,117.15 47.4,118.05 42.77,118.05
  BOTTOM w0.102: v1(262.76,74.74) 262.92,74.57 263.46,74.57 263.53,74.65 C487.1
USB3RN1_C: length 2.8
  BOTTOM w0.102: U625.23 266.19,75.24 266.05,75.09 v1(265.62,75.09) 265.41,75.09 264.93,74.61 264.76,74.61 264.48,74.89 C487.2
USB3RN1_RP: length 43.2
  IN3 w0.127: v1(274.91,75.6) 275.3,75.22 275.42,75.22 275.52,75.31 275.52,75.67 274.5,76.68 274.5,79.71 275.19,80.4 275.19,80.59 279.12,84.52 279.12,86.81 279.91,87.6 279.91,89.14 281.59,90.82 281.59,94.69 283.82,96.92 283.82,103.25 284.88,104.31 284.88,104.6 v3(284.57,104.9)
  BOTTOM w0.102: R746.1 287.69,109 L40.3 287.69,108.55 288.07,108.17 288.07,108.1 288,108.03 286.17,108.03 285,106.86 285,106.41 284.9,106.31 284.9,105.23 v3(284.57,104.9) ; R830.1 274.13,75.76 274.52,75.36 274.67,75.36 v1(274.91,75.6)
USB3RN1_RP_R: length 2.7
  BOTTOM w0.102: U625.8 271.31,75.24 271.47,75.07 271.78,75.07 271.79,75.08 272.26,75.08 272.55,75.38 272.8,75.38 R830.2
USB3RN2: length 248.7
  TOP w0.102: UH4.BC30 38.58,118.77 38.58,118.53 38.78,118.33 v1(38.87,118.33)
  IN4 w0.102: v1(38.87,118.33) 39.08,118.53 39.08,118.74 39.3,118.96 39.99,118.96 40.05,118.9 41.68,118.9 41.98,119.19 42.73,119.19 42.77,119.15
  IN4 w0.117: 42.77,119.15 46.46,119.15 46.81,119.51 49.05,119.51 52.64,115.91 61.6,115.91 64.35,113.17 64.9,113.17 66.31,111.76 67.21,111.76 67.41,111.76 69.59,109.58 69.76,109.58 69.77,109.58 70.63,108.72 71.06,108.72 72.09,107.7 77.59,107.7 78.37,106.92 80.78,106.92 83.49,104.2 103.05,104.2 103.71,103.54 130.33,103.54 131.95,101.93 157.61,101.93 160.03,99.51 174.76,99.51 181.37,92.9 194.64,92.9 197.81,89.73 198.99,89.73 200,88.72 202.07,88.72 203.11,87.68 207.31,87.68 208.58,86.4 212.82,86.4 215.99,83.22 217.58,83.22 218.25,82.56 221.98,82.56 224.82,79.72 225.8,79.72 227.28,78.24 227.28,74.78 228.09,73.97 228.09,66.71 228.2,66.59 232.72,66.59 232.77,66.64 239.47,66.64 240.34,65.77 243.96,65.77 247.12,68.92 247.12,71.39 248.17,72.45 248.32,72.45 v3(248.65,72.78)
  BOTTOM w0.102: v3(248.65,72.78) 248.85,72.58 249.06,72.58 249.17,72.7 249.17,73.37 249.57,73.76 249.57,74.91 250.01,75.36 250.43,75.36 C491.1
USB3RN2_C: length 3
  BOTTOM w0.102: U626.23 253.74,75.24 253.6,75.09 v1(253.12,75.09) 252.88,75.09 252.64,75.34 252.2,75.34 C491.2
USB3RN2_RP: length 40.7
  TOP w0.102: R752.1 283.59,100.08 L43.2 282.84,100.08 282.53,99.77 282,99.77 281.38,99.15 281.38,96.99 281.3,96.91 281.12,96.91 v3(280.93,97.1)
  IN3 w0.127: v3(280.93,97.1) 280.7,96.87 280.38,96.87 280.02,96.51 280.02,94.15 280.63,93.54 280.63,91.11 276.38,86.86 276.38,84.29 273.16,81.07 273.16,79.42 270.25,76.51 265.55,76.51 264.72,75.68 262.55,75.68 v1(262.35,75.88)
  BOTTOM w0.102: v1(262.35,75.88) 262.08,75.62 261.83,75.62 R832.1
USB3RN2_RP_R: length 2.5
  BOTTOM w0.102: R832.2 260.08,75.61 259.8,75.61 259.31,75.12 258.99,75.12 258.87,75.24 U626.8
USB3RN4: length 113.6
  TOP w0.102: UH4.BJ32 41.4,119.82 41.22,119.99 41.22,120.07 41.4,120.24 41.53,120.24 41.74,120.03 41.91,120.03 42.07,120.19 v1(42.07,120.32) ; v1(100.54,106.3) 100.67,106.3 100.83,106.46 100.83,107.14 99.58,108.39 99.58,112.36 97.39,114.54 97.39,116.52 104.27,123.39 104.27,123.56 103.85,123.97 v3(103.85,123.98)
  IN4 w0.102: 42.77,120.13 42.73,120.17 42.23,120.17 v1(42.07,120.32)
  IN4 w0.117: v1(100.54,106.3) 101.02,105.82 101.02,105.56 100.54,105.08 84.34,105.08 81.18,108.24 78.31,108.24 77.97,108.58 72.44,108.58 71.36,109.66 70.9,109.66 70.09,110.48 69.95,110.48 66.83,113.6 66.83,114.23 64.32,116.74 64.32,130.18 64.12,130.38 48.74,130.38 46.05,127.69 46.05,121.76 44.93,120.64 44.01,120.64 43.5,120.13 42.77,120.13
  BOTTOM w0.102: v3(103.85,123.98) 104.01,124.14 104.01,124.63 103.38,125.26 103.38,125.51 103.24,125.65 JDOCK1.84
USB3RP1: length 268.6
  TOP w0.102: UH4.BC28 38.64,117.85 38.23,118.26 v1(38.23,118.33)
  IN4 w0.102: v1(38.23,118.33) 38.64,117.91 42.04,117.91 42.42,118.29 42.77,118.29
  IN4 w0.117: 42.77,118.29 47.5,118.29 48.41,117.38 49.95,117.38 52.28,115.05 61.23,115.05 63.98,112.29 64.2,112.29 65.65,110.84 66.42,110.84 68.54,108.72 69.41,108.72 70.37,107.76 70.79,107.76 72.04,106.51 77.55,106.51 78.03,106.03 80.4,106.03 83.29,103.14 102.51,103.14 103.47,102.18 130.36,102.18 131.48,101.06 157.05,101.06 159.53,98.59 173.52,98.59 174.63,97.47 174.63,95.62 175.06,95.18 176,95.18 178.07,93.12 179.83,93.12 180.92,92.02 183.46,92.02 184.34,91.14 194.68,91.14 198.03,87.79 201.76,87.79 204.03,85.52 207.89,85.52 209.3,84.1 213.87,84.1 216.34,81.63 221.56,81.63 224.72,78.47 224.72,75.87 227.21,73.37 227.21,66.24 227.76,65.69 233.06,65.69 233.45,65.3 234.44,65.3 235.04,64.71 235.65,64.71 236.41,63.95 243.4,63.95 244.99,65.55 246.04,65.55 248,67.51 248,70.71 248.73,71.44 250.29,71.44 252.51,69.22 253.02,69.22 262.85,69.22 263.88,70.25 263.88,72.83 263.88,72.84 263.88,73.98 263.5,74.36 263,74.36 v1(262.75,74.11)
  BOTTOM w0.102: v1(262.75,74.11) 263,74.36 263.46,74.36 263.53,74.28 C465.1
USB3RP1_C: length 2.9
  BOTTOM w0.102: C465.2 264.48,74.11 264.77,74.4 265.02,74.4 265.49,74.87 266.06,74.87 266.19,74.74 U625.22
USB3RP1_RP: length 43.2
  IN3 w0.127: v1(274.91,74.97) 275.52,74.97 275.77,75.21 275.77,75.77 274.75,76.78 274.75,79.61 275.44,80.3 275.44,80.49 279.37,84.42 279.37,86.71 280.16,87.5 280.16,89.03 281.84,90.71 281.84,94.58 284.07,96.81 284.07,103.14 285.13,104.2 285.13,104.82 v3(285.21,104.9)
  BOTTOM w0.102: R831.1 274.54,75.15 274.73,75.15 v1(274.91,74.97) ; v3(285.21,104.9) 285.11,105 285.11,106.22 285.22,106.32 285.22,106.77 286.26,107.81 288.09,107.81 288.29,108.01 288.29,108.26 288.54,108.5 L40.2 288.54,108.96 R745.1
USB3RP1_RP_R: length 2.7
  BOTTOM w0.102: R831.2 272.76,75.16 272.64,75.16 272.34,74.85 v1(272.06,74.85) 271.49,74.85 271.37,74.74 U625.9
USB3RP2: length 248.6
  TOP w0.102: v3(39.65,118.33) 39.27,118.7 UH4.BE30
  IN4 w0.102: v3(39.65,118.33) 39.52,118.2 39.41,118.2 39.28,118.33 39.28,118.63 39.39,118.74 39.9,118.74 39.96,118.68 41.78,118.68 42.07,118.97 42.6,118.97 42.61,118.98 42.63,118.96
  IN4 w0.117: v1(248.65,72.15) 248.59,72.21 248.27,72.21 247.35,71.29 247.35,68.83 244.06,65.53 240.24,65.53 239.37,66.4 232.87,66.4 232.82,66.36 228.1,66.36 227.85,66.61 227.85,73.88 227.04,74.68 227.04,78.14 225.7,79.48 224.72,79.48 221.88,82.32 218.15,82.32 217.48,82.99 215.89,82.99 212.72,86.16 208.49,86.16 207.21,87.44 203.02,87.44 201.97,88.49 199.9,88.49 198.9,89.49 197.72,89.49 194.55,92.66 181.28,92.66 174.66,99.28 159.93,99.28 157.51,101.69 131.85,101.69 130.23,103.31 103.61,103.31 102.95,103.96 83.39,103.96 80.68,106.68 78.27,106.68 77.49,107.46 71.99,107.46 70.97,108.48 70.53,108.48 69.67,109.35 69.67,109.35 69.49,109.35 67.31,111.52 66.21,111.52 64.81,112.93 64.26,112.93 61.51,115.68 52.54,115.68 48.95,119.27 46.91,119.27 46.55,118.92 42.67,118.92 42.63,118.96
  BOTTOM w0.102: C490.1 250.43,75.14 250.1,75.14 249.78,74.82 249.78,73.67 249.39,73.28 249.39,72.61 249.15,72.37 248.87,72.37 v1(248.65,72.15)
USB3RP2_C: length 2.9
  BOTTOM w0.102: U626.22 253.74,74.74 253.6,74.88 253.4,74.88 253.39,74.87 252.81,74.87 252.55,75.12 252.16,75.12 C490.2
USB3RP2_RP: length 40.6
  TOP w0.102: R753.1 283.64,99.23 L43.3 282.84,99.23 282.53,99.55 282.09,99.55 281.6,99.06 281.6,96.9 281.39,96.7 281.17,96.7 v3(280.93,96.46)
  IN3 w0.127: v3(280.93,96.46) 280.87,96.51 280.87,96.51 280.87,96.56 280.81,96.62 280.49,96.62 280.27,96.4 280.27,94.25 280.88,93.64 280.88,91.01 276.63,86.76 276.63,84.19 273.4,80.96 273.4,79.31 270.36,76.26 265.66,76.26 264.82,75.43 262.53,75.43 v1(262.35,75.25)
  BOTTOM w0.102: R833.1 261.84,75.4 262.2,75.4 v1(262.35,75.25)
USB3RP2_RP_R: length 2.5
  BOTTOM w0.102: R833.2 260.08,75.39 259.89,75.39 259.4,74.91 258.97,74.91 258.8,74.74 U626.9
USB3RP4: length 113.7
  TOP w0.102: v3(101.26,106.3) 101.05,106.51 101.05,107.23 99.8,108.48 99.8,112.45 97.61,114.63 97.61,116.43 104.48,123.3 104.48,123.97 v1(104.49,123.98) ; UH4.BG32 40.99,119.82 41,119.81 41.06,119.81 41.36,119.51 41.63,119.51 41.79,119.67 v1(42.11,119.67)
  IN4 w0.102: 42.33,119.89 v1(42.11,119.67)
  IN4 w0.117: v3(101.26,106.3) 101.26,106.3 101.26,105.46 100.63,104.84 84.25,104.84 81.08,108.01 78.21,108.01 77.87,108.34 72.35,108.34 71.26,109.43 70.81,109.43 69.99,110.24 69.85,110.24 66.59,113.5 66.59,114.13 64.09,116.64 64.09,130.08 64.02,130.14 48.84,130.14 46.28,127.59 46.28,121.66 45.03,120.4 44.11,120.4 43.6,119.89 42.33,119.89
  BOTTOM w0.102: v1(104.49,123.98) 104.23,124.24 104.23,124.72 103.6,125.35 103.6,125.51 103.74,125.65 JDOCK1.86
USB3TN1: length 295.2
  TOP w0.102: UH4.AV26 36.07,116.79 36.43,116.43 v3(36.43,116.38)
  IN4 w0.102: v3(36.43,116.38) 35.93,116.88 35.43,116.88 35.08,117.23 35.08,117.55 34.5,118.12 34.5,118.62 34.91,119.03 36.7,119.03 37.53,119.87 40.68,119.87 41.92,121.12 42.67,121.12 42.68,121.11 42.75,121.11 42.75,121.1 42.77,121.1
  IN4 w0.117: v1(261.05,72.19) 260.77,71.92 260.77,71.51 260.32,71.06 255.36,71.06 255.36,71.06 255.07,71.06 255.06,71.06 253.88,71.06 251.61,73.33 247.77,73.33 246.76,72.32 245.59,72.32 244.96,71.69 244.96,67.96 244.3,67.31 232.34,67.31 232.25,67.22 230.13,67.22 229.57,67.78 229.57,68.84 231.19,70.47 231.19,74.64 230.91,74.93 228.92,74.93 227.91,75.95 227.91,80.16 224.51,83.55 224.51,84.22 223.51,85.22 220.86,85.22 219.98,86.1 217.66,86.1 216.74,87.03 209.16,87.03 207.65,88.54 203.25,88.54 202.41,89.38 200.43,89.38 199.4,90.4 198.06,90.4 194.94,93.52 183.64,93.52 182.77,94.39 180.78,94.39 174.39,100.78 160.26,100.78 158.49,102.55 132.47,102.55 130.82,104.2 104.68,104.2 101.94,106.93 100.32,106.93 100.21,106.81 83.55,106.81 81.49,108.87 78.67,108.87 78.33,109.21 72.71,109.21 70.76,111.16 70.16,111.16 67.48,113.84 67.48,115.17 65,117.64 65,124.53 65.23,124.76 65.23,128.79 64.95,129.07 64.95,130.45 64.37,131.03 62.1,131.03 61.52,131.6 47.15,131.6 45.25,129.7 45.25,122.03 44.5,121.29 43.62,121.29 43.44,121.1 42.77,121.1
  BOTTOM w0.102: C452.2 263.13,72.56 262.52,72.56 262.27,72.31 262.27,71.91 261.92,71.57 261.06,71.57 260.83,71.79 260.83,71.98 v1(261.05,72.19)
USB3TN1_C: length 3.3
  BOTTOM w0.102: U625.20 266.36,73.74 266.22,73.59 265.85,73.59 265.64,73.38 265.64,72.96 265.23,72.54 264.9,72.54 C452.1
USB3TN1_RP: length 45.8
  IN3 w0.127: v1(284.71,102.81) 284.7,102.8 284.7,96.55 282.7,94.55 282.7,87.91 280.01,85.22 280.01,82.34 278.74,81.07 278.74,80.05 276.97,78.27 276.97,74.34 275.78,73.15 275.49,73.15 v3(275.18,73.46)
  BOTTOM w0.102: v3(275.18,73.46) 274.97,73.24 274.2,73.24 274.13,73.31 C488.1 ; v1(284.71,102.81) 285.22,103.32 285.29,103.32 285.89,103.91 285.89,106.55 286.54,107.2 288.71,107.2 289.23,107.72 289.79,107.72 289.94,107.88 289.94,107.99 289.72,108.21 L42.3 289.72,109 R743.1
USB3TN1_RP_C: length 2.7
  BOTTOM w0.102: C488.2 272.76,73.3 272.67,73.3 272.37,73.61 271.79,73.61 271.78,73.59 271.45,73.59 271.31,73.74 U625.11
USB3TN2: length 255.9
  TOP w0.102: v3(38.25,116.37) 38,116.62 UH4.BB26
  IN4 w0.102: v3(38.25,116.37) 38.12,116.5 37.78,116.5 37.7,116.42 37.7,116.21 37.95,115.96 38.45,115.96 38.72,116.24 38.72,116.24 39.28,116.8 42.12,116.8 42.63,117.32 42.77,117.32
  IN4 w0.117: v1(249.02,70.55) 249.42,70.15 249.42,64.53 249.01,64.12 244.9,64.12 243.82,63.04 234.46,63.04 233.6,63.9 227.97,63.9 225.95,65.92 225.95,71.29 226.02,71.36 226.02,72.62 225.31,73.32 219.55,73.32 217.32,75.56 217.32,79.32 213.39,83.24 207.79,83.24 206.46,84.57 201.01,84.57 200.31,83.87 198.8,83.87 195.29,87.39 195.29,87.91 192.96,90.23 183.96,90.23 183.22,90.97 177.23,90.97 173.75,94.45 173.75,97.03 173.18,97.6 157.88,97.6 156.07,99.41 131.91,99.41 130.01,101.31 101.88,101.31 101.74,101.16 84.05,101.16 80.17,105.05 77.77,105.05 77.18,105.64 71.27,105.64 69.05,107.86 68.11,107.86 65.99,109.98 64.84,109.98 64.12,110.69 64.12,110.92 60.86,114.19 51.22,114.19 48.91,116.5 47.59,116.5 46.77,117.32 42.77,117.32
  BOTTOM w0.102: v1(249.02,70.55) 249.31,70.84 249.31,71.06 250.02,71.77 250.02,73.05 250.38,73.41 250.52,73.41 250.83,73.72 C456.2
USB3TN2_C: length 3
  BOTTOM w0.102: U626.20 253.74,73.74 253.6,73.59 v1(253.16,73.59) 252.8,73.59 252.53,73.32 252.18,73.32 C456.1
USB3TN2_RP: length 43
  TOP w0.102: v3(278.36,94.64) 278.56,94.44 280.69,94.44 282.21,95.95 282.21,97.22 282.42,97.43 282.61,97.43 282.92,97.75 L44.2 283.6,97.75 R750.1
  IN3 w0.127: v1(262.1,73.8) 262.02,73.72 261.19,73.72 260.95,73.95 260.95,76.54 261.82,77.41 268.08,77.41 269.28,78.62 270.9,78.62 271.75,79.46 271.75,80.58 275.68,84.51 275.68,87.21 279.14,90.66 279.14,92.18 279.05,92.27 279.05,94 278.79,94.25 278.74,94.25 v3(278.36,94.64)
  BOTTOM w0.102: v1(262.1,73.8) 261.92,73.62 261.64,73.62 261.43,73.83 C492.1
USB3TN2_RP_C: length 2.3
  BOTTOM w0.102: U626.11 259.03,73.74 259.17,73.59 v1(259.55,73.59) 260.1,73.59 C492.2
USB3TN4: length 99.6
  TOP w0.102: v3(37.12,118.35) 37.37,118.6 UH4.AY30
  IN1 w0.102: 42.77,110.83 42.59,110.83 41.02,112.41 41.02,115.52 40.57,115.96 35.5,115.96 35.1,116.37 35.1,117.35 35.47,117.72 36.45,117.72 37.08,118.35 v3(37.12,118.35)
  IN1 w0.117: v1(104.35,125.34) 104.44,125.43 104.71,125.43 104.85,125.29 104.85,124.99 104.65,124.79 104.13,124.79 103.87,125.05 103.87,127.02 101.16,129.73 92.05,129.73 88.82,126.5 88.82,120.92 85.82,117.92 85.82,117.9 82.01,114.1 78.43,114.1 76.16,111.83 70.98,111.83 67.65,108.5 66.2,108.5 65.17,107.47 64,107.47 63.3,106.77 62.36,106.77 61.75,106.16 56.98,106.16 56.48,105.65 54.42,105.65 54.17,105.41 53.66,105.41 53.41,105.65 52.35,105.65 52.02,105.98 49.17,105.98 48.29,106.86 47.49,106.86 45.44,108.92 45.44,109.33 44.65,110.12 43.64,110.12 42.92,110.83 42.77,110.83
  BOTTOM w0.102: v1(104.35,125.34) 104.58,125.34 104.81,125.57 104.81,125.72 104.74,125.79 JDOCK1.90
USB3TP1: length 295.2
  TOP w0.102: v1(35.75,116.37) 35.75,116.46 35.38,116.82 UH4.AU26
  IN4 w0.102: v1(35.75,116.37) 35.75,116.6 35.69,116.66 35.33,116.66 34.85,117.14 34.85,117.46 34.28,118.03 34.28,118.72 34.82,119.25 36.6,119.25 37.44,120.09 40.59,120.09 41.83,121.34 42.77,121.34
  IN4 w0.117: v3(260.41,72.19) 260.54,72.07 260.54,71.61 260.23,71.29 255.26,71.29 255.26,71.29 255.16,71.29 255.16,71.29 253.98,71.29 251.7,73.57 247.67,73.57 246.66,72.56 245.49,72.56 244.72,71.79 244.72,68.05 244.21,67.54 232.24,67.54 232.16,67.46 230.23,67.46 229.8,67.88 229.8,68.75 231.43,70.37 231.43,74.74 231,75.17 229.02,75.17 228.14,76.05 228.14,80.26 224.75,83.65 224.75,84.32 223.61,85.46 220.95,85.46 220.07,86.34 217.76,86.34 216.84,87.26 209.26,87.26 207.75,88.77 203.35,88.77 202.51,89.61 200.53,89.61 199.5,90.64 198.16,90.64 195.04,93.76 183.73,93.76 182.86,94.63 180.87,94.63 174.49,101.02 160.36,101.02 158.59,102.79 132.57,102.79 130.92,104.43 104.77,104.43 102.04,107.16 100.23,107.16 100.11,107.05 83.64,107.05 81.59,109.11 78.76,109.11 78.43,109.44 72.8,109.44 70.86,111.39 70.26,111.39 67.71,113.94 67.71,115.27 65.24,117.74 65.24,124.44 65.47,124.66 65.47,128.88 65.19,129.17 65.19,130.55 64.47,131.26 62.2,131.26 61.62,131.84 47.05,131.84 45.01,129.8 45.01,122.13 44.4,121.52 43.52,121.52 43.34,121.34 42.77,121.34
  BOTTOM w0.102: v3(260.41,72.19) 260.62,71.99 260.62,71.7 260.97,71.35 261.12,71.35 261.12,71.35 261.3,71.35 261.3,71.35 262.01,71.35 262.48,71.82 262.48,72.22 262.61,72.35 263.13,72.35 C454.2
USB3TP1_C: length 3.3
  BOTTOM w0.102: C454.1 264.49,71.95 264.87,72.33 265.34,72.33 v1(265.61,72.6) 265.86,72.85 265.86,73.29 265.94,73.38 266.17,73.38 266.31,73.24 U625.19
USB3TP1_RP: length 45.9
  IN3 w0.127: v1(285.34,102.77) 284.95,102.37 284.95,96.45 282.95,94.45 282.95,87.81 280.26,85.12 280.26,82.23 278.99,80.96 278.99,79.95 277.21,78.17 277.21,74.23 275.88,72.9 275.26,72.9 v3(275.18,72.82)
  BOTTOM w0.102: v3(275.18,72.82) 274.98,73.03 274.47,73.03 274.15,72.71 C489.1 ; v1(285.34,102.77) 285.34,103.06 286.1,103.82 286.1,106.46 286.63,106.99 288.8,106.99 289.32,107.51 289.88,107.51 290.16,107.79 290.16,107.86 290.57,108.27 L42.2 290.57,108.96 R744.1
USB3TP1_RP_C: length 2.7
  BOTTOM w0.102: U625.12 271.28,73.24 271.42,73.38 v1(272.06,73.38) 272.29,73.38 272.58,73.09 272.8,73.09 C489.2
USB3TP2: length 256
  TOP w0.102: v1(37.1,116.38) 37.37,116.65 UH4.AY26
  IN4 w0.102: 42.77,117.08 42.71,117.08 42.21,116.58 39.37,116.58 38.94,116.15 38.94,116.14 38.77,115.98 38.56,115.76 37.84,115.76 37.48,116.13 37.48,116.27 37.39,116.36 37.12,116.36 v1(37.1,116.38)
  IN4 w0.117: v3(249.66,70.55) 249.66,64.44 249.11,63.89 245,63.89 243.91,62.8 234.36,62.8 233.5,63.67 227.87,63.67 225.72,65.82 225.72,71.39 225.78,71.45 225.78,72.52 225.21,73.09 219.45,73.09 217.08,75.46 217.08,79.22 213.29,83.01 207.69,83.01 206.36,84.33 201.1,84.33 200.41,83.64 198.71,83.64 195.05,87.29 195.05,87.81 192.86,89.99 183.87,89.99 183.12,90.73 177.13,90.73 173.51,94.35 173.51,96.93 173.08,97.36 157.78,97.36 155.97,99.17 131.81,99.17 129.91,101.07 101.98,101.07 101.84,100.93 83.95,100.93 80.07,104.81 77.67,104.81 77.08,105.4 71.17,105.4 68.95,107.63 68.01,107.63 65.89,109.74 64.74,109.74 63.88,110.6 63.88,110.82 60.76,113.95 51.12,113.95 48.81,116.26 47.49,116.26 46.67,117.08 42.77,117.08
  BOTTOM w0.102: v3(249.66,70.55) 249.53,70.68 249.53,70.97 250.24,71.68 250.24,72.96 250.45,73.17 250.65,73.17 250.83,72.99 C457.2
USB3TP2_C: length 2.9
  BOTTOM w0.102: U626.19 253.74,73.24 253.61,73.37 252.88,73.37 252.62,73.11 252.18,73.11 C457.1
USB3TP2_RP: length 43.1
  TOP w0.102: v1(278.36,94.01) 278.57,94.22 280.78,94.22 282.42,95.86 282.42,97.13 282.5,97.21 282.69,97.21 283.01,96.9 L44.3 283.65,96.9 R751.1
  IN3 w0.127: v3(262.1,73.17) 261.8,73.47 261.09,73.47 260.7,73.85 260.7,76.65 261.72,77.66 267.97,77.66 269.18,78.87 270.8,78.87 271.5,79.57 271.5,80.68 275.44,84.62 275.44,87.31 278.89,90.77 278.89,92.08 278.8,92.17 278.8,93.9 278.69,94.01 v1(278.36,94.01)
  BOTTOM w0.102: v3(262.1,73.17) 261.86,73.41 261.59,73.41 261.43,73.25 C493.1
USB3TP2_RP_C: length 2.4
  BOTTOM w0.102: C493.2 260.07,73.38 259.83,73.38 259.81,73.37 259.28,73.37 259.27,73.38 259.17,73.38 259.03,73.24 U626.12
USB3TP4: length 99.6
  TOP w0.102: v1(36.46,118.34) 36.73,118.6 UH4.AW30
  IN1 w0.102: v1(36.46,118.34) 36.46,118.34 36.46,118.12 36.26,117.92 35.37,117.92 34.88,117.43 34.88,116.27 35.39,115.76 40.49,115.76 40.8,115.45 40.8,112.32 42.5,110.61 42.77,110.61
  IN1 w0.117: v3(105.29,125.31) 105.09,125.11 105.09,124.89 104.75,124.55 104.04,124.55 103.64,124.95 103.64,126.92 101.06,129.49 92.15,129.49 89.05,126.4 89.05,120.82 86.05,117.82 86.05,117.8 82.11,113.86 78.53,113.86 76.26,111.6 71.08,111.6 67.74,108.26 66.3,108.26 65.27,107.23 64.1,107.23 63.4,106.53 62.45,106.53 61.84,105.92 57.08,105.92 56.57,105.42 54.52,105.42 54.27,105.17 53.56,105.17 53.32,105.42 52.25,105.42 51.92,105.75 49.07,105.75 48.19,106.63 47.39,106.63 45.2,108.82 45.2,109.24 44.55,109.89 43.54,109.89 42.81,110.61 42.77,110.61
  BOTTOM w0.102: JDOCK1.92 105.24,125.85 105.03,125.63 105.03,125.39 105.1,125.31 v3(105.29,125.31)
USB_OC0#: length 361.2
  TOP w0.102: v1(15.02,119.61) 15.02,119.2 RH339.2 ; v1(249.11,74.71) 249.24,74.59 250.96,74.59 258.16,67.39 262.81,67.39 v2(263.05,67.63) 264.62,67.63 265.22,67.02 273.36,67.02 274.41,65.98 294.66,65.98 295.04,65.6 295.04,61.26 v1(294.23,60.45) v1(294.23,57.23)
  IN2 w0.127: v1(15.52,122.45) 15.44,122.38 14.65,122.38 14.32,122.71 14.32,123.11 14.55,123.34 14.55,125.17 14.59,125.21 14.59,126.63 14.83,126.87 14.83,130.3 16.14,131.6 16.14,132.26 16.55,132.66 16.55,133.57 16.71,133.73 16.71,135.91 16.94,136.14 17.18,136.14 17.58,136.55 19.32,136.55 20.55,137.78 20.55,138 22.87,140.32 25.04,140.32 26.05,139.32 26.88,139.32 27.72,138.48 28.41,138.48 28.83,138.06 32.1,138.06 33.76,136.41 36,136.41 36.69,135.73 42.75,135.73 43.88,136.86 45.79,136.86 47.42,138.48 54.7,138.48 54.85,138.63 60.73,138.63 61.27,139.17 64.82,139.17 65.27,138.72 68.27,138.72 70.3,136.69 70.44,136.69 70.86,136.27 72.76,136.27 74.86,134.17 78.86,134.17 79.83,135.14 79.83,136.2 80.02,136.39 83.16,136.39 84.07,135.47 84.07,134.53 84.62,133.99 87.27,133.99 87.81,134.52 99.74,134.52 100.51,135.3 102.8,135.3 103.36,134.73 108.06,134.73 110.3,132.5 113.34,132.5 113.8,132.96 131.42,132.96 133.07,134.61 151.83,134.61 155.65,130.79 159.42,130.79 161.18,129.02 169.37,129.02 175.89,122.5 175.89,118.24 175.97,118.16 182.15,111.98 182.15,111.69 182.76,111.08 182.76,108.36 187.76,103.37 188.7,103.37 189.44,102.62 189.44,99.24 190.66,98.02 190.66,97.01 195.63,92.05 195.63,90.34 195.89,90.08 195.89,89.54 197.72,87.71 200.75,87.71 201.78,86.68 202.73,86.68 204.18,85.23 209.03,85.23 210.43,83.83 214.79,83.83 216.77,81.85 222.26,81.85 225.31,78.8 225.31,78.4 226.67,77.04 227.94,77.04 v1(228.66,77.76)
  IN4 w0.109: v1(249.11,74.71) 248.79,74.4 246.77,74.4 246.31,73.93 244.82,73.93 244.79,73.9 242.26,73.9 241.33,72.97 238.93,72.97 237.21,74.69 236.47,74.69 235.9,75.25 235.9,75.95 235.56,76.29 235.31,76.29 234.2,76.29 233.94,76.55 231.45,76.55 231.18,76.82 229.6,76.82 v1(228.66,77.76) ; v1(15.52,122.45) 15.53,122.44 15.53,121.87 14.63,120.97 14.63,120 v1(15.02,119.61)
  BOTTOM w0.102: U45.6 v1(294.23,60.45) ; U45.10 v1(294.23,57.23)
USB_OC0#_R: length 97.6
  TOP w0.102: v2(74.04,114.87) 75.16,113.75 RH51.1 75.96,112.55 v1(77.62,110.88) ; RPH1.4 11.23,121.15 11.78,120.6 11.78,120.33 12.01,120.1 v1(12.04,120.1) 12.09,120.05 12.09,119.64 12.22,119.51 12.22,119.15 12.09,119.02 12.09,118.19 12.5,117.78 12.86,117.78 13.4,118.32 RH339.1 ; v1(16.62,110.74) 17.05,110.74 17.21,110.9 UH4.A14
  IN2 w0.102: 16.36,110.86 16.47,110.74 v1(16.62,110.74) 18.77,110.74 19.62,109.89 23.37,109.89 23.47,109.99 23.81,109.99 24.09,109.71 24.09,105.44 24.47,105.05 28.21,105.05 28.38,104.88 40.98,104.88 43.19,107.09 43.28,107.09
  IN2 w0.127: 16.36,110.86 16.28,110.94 15.07,110.94 14.59,111.42 14.59,113.68 13.88,114.4 13.88,120.16 13.38,120.65 12.32,120.65 12.04,120.37 v1(12.04,120.1) ; 43.28,107.09 45.16,107.09 46.94,108.86 50.25,108.86 51.71,110.33 61.09,110.33 63.7,107.72 72.07,107.72 75.23,110.88 v1(77.62,110.88)
USB_OC1#: length 112.8
  TOP w0.102: v1(32.35,30.78) 32.12,30.55 JIO1.51 ; RH341.2 14.35,117.58 14.73,117.96 14.86,117.96 v1(14.92,118.02)
  IN3 w0.127: v1(14.92,118.02) 14.76,118.02 13.77,117.03 13.77,112.09 13.27,111.6 12.39,111.6 12.27,111.47 11.19,111.47 10.83,111.11 10.83,110.29 9.89,109.36 9.89,107.07 8.48,105.66 8.48,103.75 7.87,103.14 7.87,102.65 6.2,100.98 6.2,95.25 6.61,94.84 6.61,86.77 6.77,86.61 6.77,67.93 12.6,62.1 13.98,62.1 14.37,61.71 24.81,61.71 29.06,57.47 29.06,46.86 30.58,45.34 30.58,44.07 30.5,44 30.5,33.32 30.96,32.86 30.96,32.16 32.34,30.78 v1(32.35,30.78)
  BOTTOM w0.102: v2(14.51,118.5) 14.92,118.1 v1(14.92,118.02)
USB_OC1#_R: length 88.2
  TOP w0.102: RPH1.3 11.24,120.35 11.56,120.04 11.56,119.55 v1(11.77,119.33) 11.56,119.11 11.56,118.79 11.7,118.65 11.7,118.2 12.38,117.51 RH341.1 ; v1(22.38,113.38) 22.38,113.43 21.97,113.84 UH4.K20 ; RH7.1 74.14,112.62 v1(73.13,113.64)
  IN2 w0.102: v1(22.38,113.38) 21.93,112.93 18.87,112.93 18.25,113.55 18.25,115.6 18.79,116.14 24.66,116.14 25.53,117.01 25.53,117.98 25.93,118.38 26.66,118.38 26.87,118.59 28.93,118.59 28.99,118.64 32.3,118.64 32.53,118.42 33.06,118.42 33.54,117.93 33.54,117.59 34.2,116.93 34.61,116.93 35.58,115.96 42.53,115.96 42.77,116.21
  IN2 w0.127: v1(73.13,113.64) 73.13,113.63 72.57,113.07 68.73,113.07 67.94,113.86 65.38,113.86 64.72,113.2 63.73,113.2 62.74,114.19 52.43,114.19 52.04,113.79 51.29,113.79 50.89,114.19 49.62,114.19 48.45,115.35 45.09,115.35 44.23,116.21 42.77,116.21
  BOTTOM w0.102: v1(22.38,113.38) 21.78,113.98 19.51,113.98 17.8,115.68 17.8,115.71 17.25,116.27 15.34,116.27 15.11,116.5 14.77,116.5 14.49,116.78 v2(13.47,116.78) 13.16,116.78 12.04,117.89 12.04,119.06 v1(11.77,119.33)
USB_OC2#: length 96.9
  TOP w0.102: RPH2.1 6.01,110.37 6.3,110.66 6.67,110.66 v2(6.84,110.83) 7.18,111.16 v1(7.34,111.16) ; v1(15.11,112.61) 15.14,112.61 15.56,113.03 17.16,113.03 17.64,112.55 18.14,112.55 UH4.B17 ; RH16.1 72.83,112.55 72.54,112.84 72.54,113.27 71.18,114.63 v1(71.09,114.63)
  IN1 w0.109: v1(7.34,111.16) 7.83,111.16 8.42,111.75 9.31,111.75 9.46,111.6 13.54,111.6 14.49,112.55 14.96,112.55 15.02,112.61 v1(15.11,112.61)
  IN2 w0.102: 16.36,116.99 17.66,116.99 19.47,118.8 24.32,118.8 24.61,119.09 24.61,119.93 25.92,121.23 25.92,122.51 27.01,123.6 27.01,126 27.14,126.12 27.14,126.73 28.12,127.71 33.07,127.71 33.27,127.51 35.88,127.51 37.07,128.7 40.78,128.7 41.53,127.95 42.77,127.95
  IN2 w0.127: 42.77,127.95 45.1,127.95 48.02,125.03 48.02,119.88 52.47,115.43 61.18,115.43 62.02,116.27 68.68,116.27 70.31,114.64 71.08,114.64 v1(71.09,114.63) ; v1(15.11,112.61) 15.11,112.65 15.7,113.23 15.7,114.7 15.47,114.92 14.96,114.92 14.58,115.3 14.58,116.3 15.27,116.99 16.36,116.99
USB_OC3#: length 195.5
  TOP w0.102: v1(15.91,111.38) 16.09,111.56 18.01,111.56 18.2,111.75 18.6,111.75 UH4.C16 ; v1(29.6,30.46) 30.11,29.95 JIO1.53 ; RPH1.2 10.24,119.55 9.87,119.18 9.87,118.76 9.29,118.19 9.2,118.19 v1(9.18,118.17) ; v1(71.19,113.7) 71.61,113.7 v2(71.8,113.52) 72.11,113.21 RH5.1
  IN1 w0.109: v1(15.91,111.38) 15.91,111.32 15.39,110.8 14.51,110.8 13.36,109.65 13.36,109.17 12.5,108.31 11.11,108.31 10.15,109.27 9.73,109.27 9.28,109.73 8.29,109.73 7.81,109.25 6.98,109.25 6.48,109.75 6.48,109.96 v1(6.44,110.01) 6.22,110.01 6.06,110.17 6.06,112.7 6.88,113.53 6.88,114.03 6.72,114.19 6.72,115.7 7.06,116.04 7.06,117.13 8.23,118.3 9,118.3 9.14,118.17 v1(9.18,118.17)
  IN2 w0.102: 42.77,117.44 41.72,117.44 41.26,117.91 34.66,117.91 34.62,117.95 34.24,117.95 33.37,118.82 32.71,118.82 32.48,119.05 28.82,119.05 28.76,118.99 26.7,118.99 26.5,118.79 25.73,118.79 25.12,118.18 25.12,117.2 24.47,116.55 18.62,116.55 17.82,115.74 17.82,112.21 17.27,111.66 16.36,111.66
  IN2 w0.127: 42.77,117.44 44.5,117.44 45.78,116.17 48.28,116.17 49.81,114.64 51.08,114.64 51.48,114.25 51.85,114.25 52.24,114.64 61.72,114.64 62.58,115.51 65.73,115.51 66.38,114.86 68.48,114.86 68.86,114.48 68.86,113.89 69.16,113.59 70.9,113.59 71.02,113.7 v1(71.19,113.7) ; v1(15.91,111.38) 16.19,111.66 16.36,111.66
  IN3 w0.127: v1(29.6,30.46) 30.59,31.45 30.59,32.91 30.24,33.27 30.24,41.34 29.03,42.55 29.03,45.45 28.04,46.44 28.04,56.96 24.31,60.69 13.55,60.69 13.22,61.02 12.22,61.02 5.75,67.49 5.75,76.33 5.56,76.52 5.56,85.26 4.42,86.4 4.42,91.89 5.5,92.97 5.5,94.22 5.18,94.54 5.18,103.95 5.69,104.46 5.69,104.84 5.56,104.97 5.56,109.32 6.13,109.89 6.32,109.89 v1(6.44,110.01)
USB_OC4#: length 67.8
  TOP w0.102: v1(19.28,162.13) 19.61,162.13 19.91,161.82 19.91,161.16 19.83,161.08 U48.10 ; U48.6 20.31,159.08 v1(20.37,159.14) ; RH356.2 9.79,112.31 9.3,111.82 8.27,111.82 v1(8.02,112.07)
  IN2 w0.127: v1(18.29,141.9) 18.05,141.9 12.92,136.77 12.86,136.77 9.46,133.38 8.42,133.38 7.43,132.39 7.43,123.15 6.88,122.61 6.88,120.65 5.74,119.51 5.74,113.88 6.3,113.31 6.78,113.31 v1(8.02,112.07)
  IN4 w0.109: v1(18.29,141.9) 18.53,141.9 19.39,142.76 19.39,148.22 17.3,150.32 17.3,152.78 15.96,154.12 15.96,156.24 16.85,157.12 18.76,157.12 20.37,158.74 v1(20.37,159.14)
  BOTTOM w0.102: v1(20.37,159.14) 20.37,161.04 v2(19.99,161.41) v1(19.28,162.13)
USB_OC4#_R: length 83.6
  TOP w0.102: v1(70.74,110.48) 70.72,110.48 71.26,111.01 71.26,111.88 RH6.1 ; v1(22.38,112.37) 22.38,112.12 UH4.L16 ; RH356.1 10.74,112.53 11.39,113.18 v1(11.42,113.18) ; v1(10.73,118.08) 10.9,117.92 11.14,117.92 11.47,118.25 11.47,118.56 11.27,118.75 RPH1.1
  IN2 w0.102: 42.77,111.04 41.29,111.04 40.32,112 33.38,112 33.31,111.93 30.21,111.93 29.14,113.01 27.74,113.01 27.35,112.62 26.48,112.62 25.84,111.98 24.97,111.98 24.58,112.37 v1(22.38,112.37)
  IN2 w0.127: v1(70.74,110.48) 70.72,110.48 70.23,109.98 64.72,109.98 61.59,113.12 52.87,113.12 52.48,112.73 49.44,112.73 49.01,112.29 44.12,112.29 42.86,111.04 42.77,111.04
  IN3 w0.127: v1(11.42,113.18) 10.79,113.18 10.36,112.75 7.25,112.75 6.95,113.06 6.95,116.43 7.72,117.2 10.13,117.2 10.73,117.8 v1(10.73,118.08)
  IN4 w0.102: 16.43,113.06 16.61,113.06 17.65,112.02 22.02,112.02 v1(22.38,112.37)
  IN4 w0.109: v1(11.42,113.18) 11.46,113.14 12.87,113.14 12.96,113.06 16.43,113.06
  BOTTOM w0.102: v1(22.38,112.37) 22.38,112.53 v2(22.06,112.85)
USB_OC5#: length 93.6
  TOP w0.102: UH4.A16 16.55,111.89 16.36,112.09 16.25,112.09 15.76,112.59 v1(15.75,112.59) ; v1(6.55,112.46) 6.23,112.78 5.13,112.78 RPH2.4 ; RH14.1 v2(69.57,113.77) 69.57,114.02 69.71,114.16 v1(69.71,114.35)
  IN2 w0.102: 42.77,127.72 41.04,127.72 40.64,128.12 39.42,128.12 38.99,127.69 36.41,127.69 35.36,126.63 33.65,126.63 32.81,127.48 28.37,127.48 27.34,126.45 27.34,125.97 27.23,125.86 27.23,123.47 26.17,122.42 26.17,121.01 25,119.84 25,118.91 24.7,118.61 24.7,118.17 24.41,117.88 18.96,117.88 17.71,116.64 16.36,116.64
  IN2 w0.127: v1(15.75,112.59) 15.75,112.95 15.92,113.13 15.92,114.8 15.57,115.15 15.05,115.15 14.81,115.39 14.81,116.21 15.24,116.64 16.36,116.64 ; v1(69.71,114.35) 69.71,114.73 68.4,116.04 62.11,116.04 61.21,115.14 52.44,115.14 47.79,119.79 47.79,124.86 44.93,127.72 42.77,127.72
  IN4 w0.109: v1(6.55,112.46) 6.62,112.52 8.21,112.52 8.88,111.85 13.5,111.85 13.73,112.08 15.24,112.08 v1(15.75,112.59)
USB_OC6#: length 82
  TOP w0.102: v1(9.04,108.59) 9.02,108.59 8.23,109.37 8.22,109.37 7.92,109.67 v2(7.92,110.03) 7.92,111.35 7.31,111.97 RPH2.3 ; v1(68.36,114.12) 68.55,113.93 RH8.1 ; UH4.D14 19.43,110.63 19.71,110.35 v1(19.74,110.35)
  IN2 w0.102: 42.77,116.8 35.1,116.8 34.78,117.13 34.78,117.51 34.54,117.75 34.16,117.75 33.29,118.62 32.63,118.62 32.4,118.85 28.91,118.85 28.85,118.79 26.78,118.79 26.58,118.59 25.82,118.59 25.32,118.09 25.32,117.09 24.57,116.35 18.7,116.35 18.02,115.66 18.02,111.8 19.47,110.35 v1(19.74,110.35)
  IN2 w0.127: 42.77,116.8 44.35,116.8 45.39,115.75 48.37,115.75 49.71,114.41 50.99,114.41 51.38,114.02 51.94,114.02 52.33,114.41 61.82,114.41 62.68,115.28 65.61,115.28 66.28,114.61 67.88,114.61 v1(68.36,114.12)
  IN4 w0.109: v1(19.74,110.35) 17.97,110.35 16.51,108.89 15.51,108.89 15.24,108.62 13.94,108.62 13.63,108.31 9.61,108.31 9.33,108.59 v1(9.04,108.59)
USB_PWR_SHR_EN#: length 70.8
  IN1 w0.109: v1(240.75,60.66) 240.68,60.73 240.68,65.15 240.26,65.56 240.26,68.57 v1(239.83,69.01) ; v1(280.39,70.68) 280.39,75.69 279.36,76.72 277.82,76.72 275.46,79.08 275.46,80.42 274.86,81.01 274.45,81.01 v1(273.95,80.52)
  IN2 w0.127: v1(239.83,69.01) 240.27,68.57 240.27,68.3 240.59,67.98 240.97,67.98 243.43,70.43 245.1,70.43 245.56,69.98 260.2,69.98 260.32,70.1 279.82,70.1 v1(280.39,70.68)
  BOTTOM w0.102: R1626.1 274.29,80.16 273.95,80.51 v1(273.95,80.52) 273.95,81.08 v2(273.84,81.19) ; v1(239.83,69.01) 239.83,68.96 240.33,68.46 U46.B2 ; R776.2 240.27,59.97 240.75,60.45 v1(240.75,60.66)
USB_PWR_SHR_VBUS_EN: length 63
  IN2 w0.127: v1(240.18,76.11) 240.23,76.11 240.26,76.14 240.42,76.14 242.43,78.15 242.43,78.94 243.06,79.58 v1(243.09,79.58)
  IN4 w0.109: v1(285.33,64.71) 284.17,65.86 279.16,65.86 278.46,66.56 277.67,66.56 274.13,70.1 274.13,71.76 273.4,72.49 273.4,74.99 271.99,76.39 264.39,76.39 263.94,76.84 258.61,76.84 258.22,76.45 251.4,76.45 250.44,75.49 247.24,75.49 246.77,75.96 245.16,75.96 244.59,75.4 242.75,75.4 242.55,75.2 241.52,75.2 240.61,76.11 v1(240.18,76.11)
  BOTTOM w0.102: v1(240.18,76.11) 240.23,76.11 240.33,76.21 U46.B50 ; v1(285.33,64.71) v2(285.33,63.89) R784.1 ; v1(243.09,79.58) 243.18,79.67 R778.2
USB_SIDE_EN#: length 386.5
  TOP w0.102: v1(251.81,61.68) 252.59,62.46 v2(252.59,64.44) 252.59,71.82 250.42,73.98 248.44,73.98 247.6,74.83 247.6,75.14 246.24,76.49 245.68,76.49 243.32,78.85 242.25,78.85 241.37,79.73 239.81,79.73 239.3,79.22 238.78,79.22 237.35,80.65 233.67,80.65 232.84,79.81 232.69,79.81 v1(231.61,80.89) ; JIO1.69 29.98,25.15 29.6,25.53 v1(29.6,25.54)
  IN2 w0.127: v1(251.81,61.68) 260.22,61.68 262.05,63.51 v1(262.05,64.63) 262.05,67.81 263.63,69.38 277.19,69.38 277.94,68.63 289.94,68.63 291.87,66.7 291.87,61.37 v1(291.98,61.25)
  IN4 w0.109: v1(29.6,25.54) 29.59,25.54 29.41,25.72 28.04,25.72 27.42,25.1 27.42,19.3 26.74,18.63 26.74,12.84 26.81,12.77 26.81,12.77 28.64,10.94 28.64,9.83 31.62,6.85 33.26,6.85 33.6,6.5 35.28,6.5 35.7,6.08 106.63,6.08 108.83,8.28 116.85,8.28 118.4,9.83 121.58,9.83 121.99,10.24 122.94,10.24 123.76,11.06 131.99,11.06 133.09,12.17 161.75,12.17 164.25,14.67 164.25,15.02 163.7,15.57 163.7,19.11 165.37,20.77 165.37,34.77 166.94,36.35 166.94,39.56 176.15,48.76 179.67,48.76 181.52,50.61 190.47,50.61 194.73,54.86 196.95,54.86 197.89,55.8 198.61,55.8 199.58,56.77 222.13,56.77 222.69,56.21 223.63,56.21 224.07,56.66 225.44,56.66 225.92,57.14 226.26,57.14 227.96,58.84 231.61,58.84 231.77,58.69 233.44,58.69 233.78,59.03 242.24,59.03 242.33,58.94 245.06,58.94 245.41,59.3 249.43,59.3 v1(251.81,61.68)
  BOTTOM w0.102: Q90.2 v1(262.05,64.63) ; U45.5 290.83,59.89 290.4,60.33 290.4,60.71 290.94,61.25 v1(291.98,61.25) ; R768.2 233.05,83.64 231.61,82.19 v1(231.61,80.89) 232.12,80.38 232.12,78.92 233.08,77.96 U46.A33
USBP0+: length 356.3
  TOP w0.102: UH4.A24 17.86,115.99 17.75,116.09 16.86,116.09 16.57,115.8 v1(16.57,115.67)
  IN1 w0.135: v1(297.81,115.13) 297.93,115.01 298.28,115.01 298.64,114.65 298.64,114.1 298.31,113.77 298.31,112.32 297.34,111.34 294.36,111.34 286.4,103.38 286.4,101.52 284.17,99.29 284.17,98.33 279.06,93.22 279.06,92.03 278.73,91.7 277.87,91.7 277.45,92.12 277.45,92.7 v3(277.31,92.84)
  IN4 w0.102: v1(16.57,115.67) 16.58,115.68 16.58,116.33 17.19,116.94 17.85,116.94 18.16,117.25 18.16,119.51 18.74,120.09 21.32,120.09 21.95,120.72 24.19,120.72 24.7,121.23 28.87,121.23 29.24,121.6 29.24,123.93 29.69,124.38 29.69,125.87 30.43,126.61 30.83,126.61 32.4,128.18 32.68,128.18 32.98,128.49 34.57,128.49 34.94,128.86 34.94,129.25 35,129.32 35,129.34 35.01,129.35
  IN4 w0.135: 35.01,129.35 39.31,133.65 39.86,133.65 43.15,136.94 44.62,136.94 45.97,138.29 55.91,138.29 56.71,137.49 61.87,137.49 62.31,137.05 63.42,137.05 64.44,136.02 65.99,136.02 66.13,135.88 67.28,135.88 69.4,133.75 69.4,131.44 69.29,131.33 69.29,128.78 68.94,128.43 68.94,122.74 69.7,121.98 69.7,118.33 74.68,113.35 79.43,113.35 79.83,112.95 92.49,112.95 93.92,111.51 102.95,111.51 102.95,111.51 103.45,111.51 104.26,110.7 104.26,110.2 104.89,109.57 130.94,109.57 133.13,107.38 160.68,107.38 162.37,105.69 176.4,105.69 178.97,103.12 178.97,102.64 179.14,102.47 179.85,102.47 180.39,103 184.08,103 184.34,103.26 189.08,103.26 189.29,103.05 190.45,103.05 190.66,103.26 196.83,103.26 198.59,105.02 205.45,105.02 207.19,103.29 215.48,103.29 219.55,99.22 219.55,98.67 228.48,89.74 229.23,89.74 231.55,87.42 232.97,87.42 233.32,87.06 233.64,87.06 234.52,86.18 235.74,86.18 236.64,85.28 237.83,85.28 239.12,84 241.42,84 241.63,83.79 243.32,83.79 243.79,83.32 247.57,83.32 247.71,83.18 270.99,83.18 275.89,88.08 275.89,90.35 277.45,91.91 277.45,92.7 v3(277.31,92.84)
  BOTTOM w0.102: R748.1 297.53,116.37 L39.2 297.53,115.54 297.43,115.44 297.2,115.44 297.1,115.34 297.1,115.08 297.38,114.8 297.55,114.8 297.81,115.06 v1(297.81,115.13)
USBP0-: length 356.2
  TOP w0.102: UH4.C24 18.58,115.68 18.17,115.68 18.03,115.55 17.32,115.55 v1(17.21,115.66)
  IN1 w0.135: v3(297.83,114.45) 297.83,114.56 297.97,114.7 298.15,114.7 298.33,114.52 298.33,114.22 298,113.89 298,112.45 297.21,111.65 294.23,111.65 286.09,103.51 286.09,101.65 283.86,99.42 283.86,98.46 278.75,93.35 278.75,92.16 278.6,92.01 278,92.01 277.76,92.25 277.76,92.92 277.85,93.02 277.99,93.02 v1(278.2,92.8)
  IN4 w0.102: 35.23,129.13 35.21,129.11 35.21,128.74 34.69,128.21 33.1,128.21 32.79,127.9 32.51,127.9 30.94,126.34 30.55,126.34 29.97,125.76 29.97,124.27 29.51,123.81 29.51,121.49 28.98,120.96 24.81,120.96 24.3,120.45 22.07,120.45 21.44,119.81 18.86,119.81 18.44,119.39 18.44,117.13 17.96,116.66 17.31,116.66 16.86,116.22 16.86,115.97 17.17,115.66 v1(17.21,115.66)
  IN4 w0.135: v1(278.2,92.8) 278,93 277.86,93 277.76,92.9 277.76,91.78 276.2,90.22 276.2,87.95 271.12,82.87 247.58,82.87 247.45,83.01 243.66,83.01 243.19,83.48 241.5,83.48 241.29,83.69 238.99,83.69 237.7,84.97 236.52,84.97 235.61,85.87 234.39,85.87 233.51,86.75 233.2,86.75 232.84,87.11 231.42,87.11 229.1,89.43 228.35,89.43 219.24,98.54 219.24,99.09 215.35,102.98 207.06,102.98 205.33,104.71 198.72,104.71 196.96,102.95 190.79,102.95 190.58,102.74 189.16,102.74 188.96,102.95 184.47,102.95 184.21,102.69 180.52,102.69 179.98,102.16 179.01,102.16 178.66,102.51 178.66,103 176.27,105.38 162.25,105.38 160.55,107.07 133,107.07 130.81,109.26 104.76,109.26 103.95,110.07 103.95,110.57 103.32,111.2 102.82,111.2 102.82,111.2 93.79,111.2 92.36,112.64 79.7,112.64 79.3,113.04 74.55,113.04 69.39,118.2 69.39,121.86 68.63,122.61 68.63,128.56 68.98,128.91 68.98,131.46 69.09,131.57 69.09,133.62 67.15,135.57 66,135.57 65.86,135.71 64.32,135.71 63.29,136.74 62.18,136.74 61.74,137.18 56.59,137.18 55.79,137.98 46.1,137.98 44.75,136.63 43.28,136.63 39.99,133.34 39.44,133.34 35.23,129.13
  BOTTOM w0.102: R749.1 296.68,116.37 L39.3 296.68,115.58 296.89,115.37 296.89,114.99 297.29,114.58 297.7,114.58 v3(297.83,114.45)
USBP0_D+: length 9.4
  BOTTOM w0.102: JUSB1.3 293.26,120.84 294.04,120.05 294.4,120.05 295.59,121.25 296.28,121.25 296.86,120.66 296.86,120.08 296.96,119.98 297.69,119.98 D15.2 296.89,119.08 296.89,118.99 297.17,118.72 297.17,118.58 297.53,118.22 L39.1 297.61,117.7 R748.2
USBP0_D-: length 9.3
  BOTTOM w0.102: JUSB1.2 293.26,119.26 293.84,119.84 294.49,119.84 295.68,121.03 296.19,121.03 296.65,120.57 296.65,119.98 296.59,119.93 D15.3 295.81,119.91 296.68,119.04 296.68,118.9 296.95,118.63 296.95,118.5 296.68,118.23 L39.4 296.59,117.7 R749.2
USBP1+: length 317.6
  TOP w0.102: UH4.B25 18.49,116.35 18.58,116.44 18.58,116.57 18.46,116.69 18.16,116.69 17.99,116.52 15.96,116.52 15.47,116.03 15.26,115.82 v3(15.26,115.76)
  IN4 w0.102: v3(15.26,115.76) 15.38,115.64 15.38,115.15 15.67,114.86 17.61,114.86 18.13,115.38 18.13,115.71 18.32,115.9 18.65,115.9 18.66,115.9 24.64,115.9 25.89,117.16 25.89,118.01 26.28,118.39 33.61,118.39 34.77,119.55 36.59,119.55 37.49,120.45 40.43,120.45 41.63,121.65 41.63,125.93 42.77,127.08
  IN4 w0.135: 42.77,127.08 43.31,127.61 43.31,131.21 44.79,132.7 51.18,132.7 52.41,133.93 56.04,133.93 57.48,132.48 60.01,132.48 60.49,132.96 61.9,132.96 62.4,132.46 65.23,132.46 65.84,131.85 65.84,129.5 66.11,129.23 66.11,122.58 65.89,122.36 65.89,118.03 68.86,115.06 68.86,113.72 70.53,112.05 71.1,112.05 73.06,110.09 78.72,110.09 79.07,109.74 80.85,109.74 81.1,109.99 84.35,109.99 85.14,109.2 87.44,109.2 88.81,107.83 102.39,107.83 103.95,106.27 130.06,106.27 132.12,104.22 149.71,104.22 150.51,103.42 159.16,103.42 159.71,102.87 162.49,102.87 163.71,101.65 175.61,101.65 181.81,95.45 182.95,95.45 184,94.4 195.34,94.4 198.38,91.36 199.78,91.36 200.89,90.25 203.17,90.25 203.81,89.61 207.81,89.61 208.83,88.59 216.41,88.59 218.03,86.97 220.69,86.97 221.52,86.14 224.6,86.14 226.75,83.99 226.75,83.52 229.64,80.63 229.64,80.37 231.14,78.88 231.68,78.88 233.01,77.55 233.67,77.55 234.42,76.8 235.09,76.8 235.09,76.8 240.64,76.8 241.73,75.71 242.34,75.71 242.54,75.91 244.38,75.91 244.97,76.5 247.74,76.5 248.2,76.04 250.24,76.04 251.16,76.95 257.96,76.95 258.36,77.35 265.46,77.35 265.88,76.93 274.32,76.93 275.33,75.92 276.02,75.92 276.33,76.23 v1(276.33,76.8)
  BOTTOM w0.102: U2.6 276.32,76.8 v1(276.33,76.8)
USBP1-: length 317.4
  TOP w0.102: v3(15.91,115.67) 15.87,115.67 15.68,115.86 15.68,115.94 16.05,116.31 17.87,116.31 18.14,116.03 18.46,116.03 18.78,116.35 UH4.C25
  IN4 w0.102: 42.55,127.3 41.35,126.09 41.35,121.76 40.31,120.73 37.36,120.73 36.46,119.83 34.75,119.83 33.52,118.6 26.09,118.6 25.61,118.12 25.61,117.17 24.63,116.18 18.31,116.18 17.85,115.72 17.85,115.49 17.5,115.14 15.78,115.14 15.66,115.26 15.66,115.57 15.76,115.67 v3(15.91,115.67)
  IN4 w0.135: v1(275.6,76.78) 275.77,76.61 275.85,76.61 276.02,76.45 276.02,76.35 275.89,76.23 275.46,76.23 274.45,77.24 266.01,77.24 265.59,77.66 258.23,77.66 257.84,77.26 251.03,77.26 250.11,76.35 248.33,76.35 247.86,76.81 244.84,76.81 244.25,76.22 242.41,76.22 242.21,76.02 241.86,76.02 240.77,77.11 234.97,77.11 234.96,77.11 234.55,77.11 233.8,77.86 233.14,77.86 231.81,79.19 231.27,79.19 229.95,80.5 229.95,80.76 227.06,83.65 227.06,84.12 224.73,86.45 221.65,86.45 220.82,87.28 218.15,87.28 216.54,88.9 208.96,88.9 207.94,89.92 203.94,89.92 203.3,90.56 201.02,90.56 199.9,91.67 198.51,91.67 195.47,94.71 184.13,94.71 183.08,95.76 181.94,95.76 175.73,101.96 163.83,101.96 162.62,103.18 159.84,103.18 159.29,103.73 150.64,103.73 149.84,104.53 132.25,104.53 130.19,106.58 104.08,106.58 102.52,108.14 88.94,108.14 87.56,109.51 85.27,109.51 84.48,110.3 80.97,110.3 80.72,110.05 79.2,110.05 78.85,110.4 73.19,110.4 71.23,112.36 70.66,112.36 69.17,113.85 69.17,115.19 66.2,118.16 66.2,122.23 66.42,122.45 66.42,129.36 66.15,129.63 66.15,131.98 65.36,132.77 62.53,132.77 62.03,133.27 60.36,133.27 59.88,132.79 57.61,132.79 56.16,134.24 52.28,134.24 51.05,133.01 44.66,133.01 43,131.34 43,127.74 42.55,127.3
  BOTTOM w0.102: v1(275.6,76.78) 275.78,76.78 275.89,76.9 275.89,76.99 276.11,77.2 276.11,78.08 276.06,78.13 275.87,78.13 275.82,78.18 U2.7
USBP1_D+: length 20
  TOP w0.102: v3(280.06,93.37) 280.26,93.17 280.27,93.17 280.31,93.13 280.57,93.13 281.52,94.08 281.7,94.08 282.21,94.59 L41.2 282.69,94.59 R764.1
  IN1 w0.135: v1(278.37,87.11) 278.37,88.61 279.72,89.96 280.05,89.96 281.16,91.07 281.16,92.8 280.82,93.14 280.29,93.14 v3(280.06,93.37)
  BOTTOM w0.102: U2.3 276.32,81.74 275.49,82.58 275.49,84.43 276.87,85.81 277.42,85.81 278.23,86.63 278.23,86.97 v1(278.37,87.11)
USBP1_D-: length 19.8
  TOP w0.102: v1(280.06,92.61) 280.36,92.91 280.66,92.91 281.61,93.87 281.71,93.87 282.18,93.39 L41.3 282.69,93.39 R754.1
  IN1 w0.135: v1(277.73,87.11) 278.06,87.43 278.06,88.74 279.6,90.27 279.92,90.27 280.85,91.19 280.85,92.67 280.69,92.83 280.28,92.83 v1(280.06,92.61)
  BOTTOM w0.102: U2.2 275.82,81.39 275.89,81.45 276.04,81.45 276.11,81.52 276.11,81.65 275.27,82.49 275.27,84.52 276.79,86.04 v1(277.02,86.04) 277.34,86.04 278.01,86.72 278.01,86.83 v1(277.73,87.11)
USBP1_R_D+: length 25.3
  TOP w0.102: R764.2 283.83,94.59 L41.1 284.3,94.59 284.87,94.02 285.82,94.02 D17.2 286.56,94.07 286.77,93.86 287.33,93.86 288.94,92.25 290.23,92.25 290.23,92.25 v3(290.42,92.44)
  IN4 w0.135: v3(290.42,92.44) 290.31,92.32 289.4,92.32 288.97,91.89 288.97,91.12 289.66,90.43 291.21,90.43 292.87,92.1 293.77,92.1 295.85,94.18 295.85,96.42 295.06,97.21 293.8,97.21 JUSB2.3
USBP1_R_D-: length 25.3
  TOP w0.102: R754.2 283.83,93.39 L41.4 284.3,93.39 284.71,93.8 285.58,93.8 D17.3 286.56,93.44 286.76,93.65 287.24,93.65 288.85,92.04 290.14,92.04 290.14,92.03 290.19,92.03 v1(290.42,91.8)
  IN4 w0.135: JUSB2.2 293.26,95.75 292.67,95.75 292.48,95.94 292.48,96.28 293.1,96.9 294.93,96.9 295.54,96.29 295.54,94.3 293.64,92.41 292.75,92.41 291.08,90.74 289.79,90.74 289.28,91.25 289.28,91.76 289.53,92.01 290.21,92.01 v1(290.42,91.8)
USBP2+: length 119.6
  TOP w0.102: UH4.A26 17.71,116.85 17.55,117.01 16.34,117.01 16.13,117.22 15.11,117.22 15.06,117.27 15.06,117.46 15.2,117.6 15.33,117.6 15.39,117.67 15.39,117.82 15.51,117.93 15.75,117.93 15.86,117.82 v1(15.86,117.81) ; JIO1.59 31.88,28.15 31.96,28.23 31.96,28.35 32.02,28.4 32.18,28.4 v1(32.43,28.15)
  IN3 w0.14: v1(15.86,117.81) 16.11,117.55 16.11,117.39 16.05,117.32 15.38,117.32 14.59,116.54 14.59,109.58 12.82,107.81 12.5,107.81 12.14,107.45 12.14,106.42 11.49,105.77 11.49,104.92 10.87,104.29 10.87,100.46 8.91,98.51 8.91,89.28 8.06,88.43 8.06,77.37 8.58,76.85 8.58,76.04 9.43,75.18 9.92,75.18 10.07,75.34 10.07,75.46 9.88,75.65 9.87,75.65 v3(9.82,75.71)
  BOTTOM w0.102: v1(32.43,28.15) 32.01,28.56 31.74,28.56 31.56,28.74 31.56,31.23 29.72,33.07 29,33.07 28.06,34.01 26.86,34.01 26.5,34.37 26.5,39.27 28.42,41.19 28.42,45.36 25.73,48.06 25.73,56.33 23.25,58.8 14.11,58.8 10.23,62.68 10.23,75.29 v3(9.82,75.71)
