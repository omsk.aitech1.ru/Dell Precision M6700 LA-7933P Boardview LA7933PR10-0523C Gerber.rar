# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCD_B1+_PCH: length 67.3
  TOP w0.102: U13.20 57.27,131.82 56.74,131.29 56.74,131.18 v3(56.91,131.01) ; v1(31.89,130.67) 31.72,130.51 31.57,130.51 31.42,130.35 31.42,130.18 31.51,130.09 31.7,130.09 31.75,130.04 31.75,129.94 31.43,129.63 31.43,129.14 31.3,129.02 31.3,128.31 UH4.AH49
  IN1 w0.117: v1(31.89,130.67) 31.94,130.72 33,130.72 33.31,130.42 34.75,130.42 34.94,130.22 37.32,130.22 37.45,130.35 37.45,130.59 37.32,130.72 36.56,130.72 36.26,131.01 36.26,131.45 36.56,131.74 37.26,131.74 37.39,131.87 37.39,132.05 37.81,132.48 38.39,132.48 38.68,132.2 38.68,131.79 38.81,131.66 39.14,131.66 39.26,131.79 39.26,132.21 39.56,132.51 40.12,132.51 40.42,132.21 40.42,131.9 40.54,131.78 40.87,131.78 41,131.9 41,132.21 41.29,132.51 41.86,132.51 42.15,132.21 42.15,131.04 42.28,130.91 42.61,130.91 42.74,131.04 42.74,132.21 43.03,132.51 43.6,132.51 43.89,132.21 43.89,131.75 44.02,131.62 44.35,131.62 44.47,131.75 44.47,132.21 44.77,132.51 45.59,132.51 45.88,132.21 45.88,131.28 46.01,131.15 46.34,131.15 46.47,131.28 46.47,132.2 46.75,132.48 47.22,132.48 47.62,132.09 47.62,131.59 47.72,131.48 48.06,131.48 48.18,131.6 48.18,132.01 48.46,132.29 49.05,132.29 49.33,132.01 49.33,131.3 49.46,131.17 49.82,131.17 49.95,131.3 49.95,132 50.24,132.29 50.82,132.29 51.12,132 51.12,131.61 51.24,131.48 51.37,131.48 51.55,131.66 52.13,131.66 52.62,131.17 53.46,131.17 53.52,131.23 53.52,131.58 53.82,131.87 54.82,131.87 54.91,131.96 54.91,133.74 54.61,134.04 54.1,134.04 53.66,134.49 53.66,134.85 53.92,135.11 55.86,135.11 56.17,134.8 56.17,133.76 56.3,133.63 59.21,133.63 59.26,133.58 60.14,133.58 60.43,133.29 60.43,131.81 60.14,131.52 59.56,131.52 59.26,131.81 59.26,132.35 59.14,132.47 58.65,132.47 58.52,132.35 58.52,131.72 58.23,131.43 57.67,131.43 57.37,131.72 57.37,132.33 57.24,132.46 55.98,132.46 55.85,132.33 55.85,131.9 55.93,131.82 56.69,131.82 56.93,131.57 56.93,131.03 v3(56.91,131.01)
LCD_B1-_PCH: length 67.2
  TOP w0.102: v1(32.18,130.11) 32.18,130 31.7,129.52 31.7,129.03 31.57,128.91 31.57,128.07 31.16,127.65 UH4.AH47 ; v3(56.13,131.06) 56.31,131.06 56.48,131.23 56.48,131.42 56.77,131.72 U13.19
  IN1 w0.117: v3(56.13,131.06) 56.19,131.01 56.4,131.01 56.48,131.09 56.48,131.2 56.65,131.37 56.65,131.45 56.57,131.53 55.81,131.53 55.57,131.78 55.57,132.45 55.86,132.75 57.36,132.75 57.66,132.45 57.66,131.84 57.78,131.71 58.11,131.71 58.24,131.84 58.24,132.47 58.53,132.76 59.26,132.76 59.55,132.47 59.55,131.93 59.68,131.8 60.02,131.8 60.15,131.93 60.15,133.17 60.02,133.3 59.14,133.3 59.09,133.35 56.18,133.35 55.88,133.64 55.88,134.68 55.74,134.83 54.04,134.83 53.94,134.73 53.94,134.61 54.22,134.33 54.73,134.33 55.19,133.86 55.19,131.84 54.94,131.59 53.93,131.59 53.81,131.46 53.81,131.11 53.58,130.89 52.5,130.89 52.01,131.38 51.67,131.38 51.49,131.2 51.13,131.2 50.83,131.49 50.83,131.88 50.7,132.01 50.36,132.01 50.23,131.88 50.23,131.18 49.94,130.89 49.34,130.89 49.05,131.18 49.05,131.89 48.93,132.01 48.58,132.01 48.46,131.89 48.46,131.48 48.18,131.2 47.6,131.2 47.33,131.47 47.33,131.97 47.11,132.19 46.87,132.19 46.75,132.08 46.75,131.16 46.46,130.87 45.89,130.87 45.6,131.16 45.6,132.1 45.47,132.22 44.89,132.22 44.76,132.1 44.76,131.63 44.47,131.34 43.9,131.34 43.61,131.63 43.61,132.1 43.48,132.22 43.15,132.22 43.02,132.1 43.02,130.92 42.73,130.63 42.16,130.63 41.87,130.92 41.87,132.1 41.74,132.22 41.41,132.22 41.28,132.1 41.28,131.79 40.99,131.49 40.42,131.49 40.13,131.79 40.13,132.1 40,132.22 39.67,132.22 39.55,132.1 39.55,131.67 39.25,131.38 38.69,131.38 38.39,131.67 38.39,132.08 38.28,132.19 37.93,132.19 37.67,131.94 37.67,131.75 37.38,131.46 36.68,131.46 36.55,131.33 36.55,131.13 36.68,131 37.44,131 37.73,130.71 37.73,130.23 37.44,129.93 34.83,129.93 34.63,130.13 33.19,130.13 32.88,130.44 32.28,130.44 32.15,130.32 32.15,130.14 v1(32.18,130.11)
LCD_B2+_PCH: length 69.3
  TOP w0.102: U13.24 59.27,131.64 59.22,131.58 59.13,131.58 59.04,131.49 59.04,130.57 59.23,130.38 65.17,130.38 65.39,130.16 65.39,129.96 65.52,129.83 66.7,129.83 66.83,129.96 66.83,130.33 66.7,130.45 66.41,130.45 66.13,130.74 66.13,131.27 66,131.39 65.67,131.39 65.54,131.27 65.54,131.1 65.3,130.86 62.28,130.86 61.99,131.15 61.99,131.56 61.86,131.69 61.86,131.78 61.62,132.02 61.62,132.22 v1(61.81,132.41) ; v3(30.78,130.09) 30.62,129.92 30.47,129.92 29.9,129.35 29.9,128.68 29.9,128.68 29.86,128.64 29.86,127.96 30.17,127.65 UH4.AF47
  IN1 w0.117: v1(61.81,132.41) 61.81,131.93 61.64,131.77 61.34,131.77 61.23,131.88 61.23,132.92 61.4,133.08 61.77,133.08 62.37,132.48 62.79,132.48 63.18,132.87 63.18,133.28 62.45,134.01 62.45,134.62 62.16,134.92 61.57,134.92 61.28,134.62 61.28,134.16 61.15,134.03 60.87,134.03 60.75,134.15 60.75,135.14 60.45,135.44 58.24,135.44 58.12,135.56 56.6,135.56 56.26,135.89 53.6,135.89 52.87,135.17 52.87,134.15 53.4,133.62 53.4,132.56 52.98,132.14 52.75,132.14 52.42,132.48 51.74,132.48 51.14,133.09 50.55,133.09 50.54,133.08 47.73,133.08 47.52,133.29 37.52,133.29 36.75,132.52 36.23,132.52 35.4,131.68 33.6,131.68 33.45,131.53 31.37,131.53 30.94,131.11 30.94,130.54 31.36,130.12 31.36,129.81 31.27,129.72 31,129.72 30.78,129.93 v3(30.78,130.09)
LCD_B2-_PCH: length 69.2
  TOP w0.102: v3(30.78,129.22) 30.81,129.2 30.95,129.2 31.04,129.29 31.04,129.59 30.97,129.65 30.61,129.65 30.38,129.43 30.38,129.32 30.29,129.24 30.21,129.24 30.17,129.2 30.17,129.02 30.21,128.97 30.45,128.97 30.52,128.91 30.52,128.83 30.39,128.71 30.24,128.71 30.19,128.66 30.19,128.47 30.13,128.41 30.13,128.2 UH4.AF49 ; U13.23 58.77,130.46 59.12,130.11 65.06,130.11 65.12,130.05 65.12,129.85 65.41,129.57 66.81,129.57 67.09,129.85 67.09,130.44 66.81,130.72 66.52,130.72 66.39,130.85 66.39,131.38 66.11,131.66 65.56,131.66 65.28,131.38 65.28,131.21 65.19,131.13 62.39,131.13 62.25,131.26 62.25,131.96 v1(62.26,131.96)
  IN1 w0.117: v1(62.26,131.96) 62.25,131.97 62.24,131.96 62.23,131.96 61.76,131.48 61.22,131.48 60.95,131.76 60.95,133.03 61.28,133.37 61.89,133.37 62.49,132.77 62.67,132.77 62.89,132.99 62.89,133.17 62.16,133.9 62.16,134.51 62.04,134.63 61.69,134.63 61.56,134.51 61.56,134.04 61.27,133.74 60.76,133.74 60.46,134.04 60.46,135.03 60.34,135.15 58.12,135.15 58,135.27 56.48,135.27 56.15,135.61 53.72,135.61 53.16,135.05 53.16,134.27 53.69,133.74 53.69,132.45 53.1,131.86 52.64,131.86 52.3,132.19 51.63,132.19 51.02,132.8 50.67,132.8 50.66,132.79 47.62,132.79 47.4,133.01 37.64,133.01 36.87,132.24 36.35,132.24 35.51,131.4 33.72,131.4 33.57,131.25 31.49,131.25 31.23,130.99 31.23,130.65 31.65,130.23 31.65,129.69 31.39,129.43 30.99,129.43 v3(30.78,129.22)
LCD_BCLK+_PCH: length 67.5
  TOP w0.102: U13.29 62.23,133.69 62.34,133.58 62.58,133.58 62.81,133.35 62.81,132.97 63.59,132.19 63.59,131.99 63.82,131.76 v3(63.82,131.76) ; v1(30.63,123.77) 30.63,123.7 30.34,123.41 UH4.AF39
  IN1 w0.102: v1(30.63,123.77) 30.51,123.89 29.58,123.89 29.2,124.28 29.2,127.36 29.07,127.48 28.28,127.48 28.2,127.4 28.2,126.98 27.91,126.69 27.43,126.69 27.15,126.98 27.15,127.4 27.06,127.48 26.02,127.48 25.74,127.77 25.74,128.25 26.02,128.53 26.71,128.53 26.77,128.59 26.77,129.19 26.76,129.2 26.76,129.4 26.75,129.41 26.75,129.43
  IN1 w0.117: v3(63.82,131.76) 63.82,131.76 63.66,131.92 63.66,132.21 63.79,132.33 64.4,132.33 64.7,132.63 64.7,133.96 64.4,134.26 63.96,134.26 63.84,134.38 63.84,135.18 63.51,135.51 62.76,135.51 62,136.27 58.65,136.27 58.54,136.38 56.88,136.38 56.2,137.06 53.65,137.06 53.28,136.7 53.08,136.7 52.99,136.78 52.99,137.18 52.71,137.46 52.28,137.46 52.2,137.54 52.2,137.65 51.9,137.95 51.25,137.95 50.96,137.65 50.96,137.27 50.83,137.14 50.46,137.14 50.33,137.27 50.33,137.65 50.04,137.95 49.47,137.95 49.18,137.65 49.18,137.57 49.06,137.46 48.7,137.46 48.23,136.99 48.23,136.25 47.42,135.44 45.19,135.44 44.61,134.85 36.34,134.85 36.06,135.13 33.11,135.13 32.03,134.05 32.03,133.78 31.39,133.14 30.27,133.14 27.91,130.78 27.91,130.35 28.59,129.68 28.59,129.5 28.33,129.24 28.15,129.24 27.49,129.9 27.02,129.9 26.75,129.62 26.75,129.43
LCD_BCLK-_PCH: length 67.5
  TOP w0.102: v1(30.66,124.42) 30.49,124.42 30.17,124.1 UH4.AF40 ; v3(62.94,131.76) 62.94,131.74 63.05,131.62 63.17,131.62 63.32,131.78 63.32,132.08 62.55,132.86 62.55,133.24 62.47,133.31 62.38,133.31 62.26,133.19 U13.28
  IN1 w0.102: v1(30.66,124.42) 30.66,124.31 30.51,124.16 29.7,124.16 29.47,124.39 29.47,127.47 29.18,127.75 28.17,127.75 27.93,127.51 27.93,127.09 27.8,126.96 27.54,126.96 27.42,127.09 27.42,127.51 27.17,127.75 26.14,127.75 26.01,127.88 26.01,128.13 26.14,128.26 26.82,128.26 27.04,128.47 27.04,129.3 27.03,129.31 27.03,129.4 27.04,129.41 27.04,129.43
  IN1 w0.117: v3(62.94,131.76) 62.94,131.38 63.07,131.26 63.25,131.26 63.38,131.38 63.38,132.33 63.67,132.62 64.29,132.62 64.41,132.75 64.41,133.85 64.29,133.97 63.84,133.97 63.56,134.26 63.56,135.06 63.39,135.23 62.64,135.23 61.88,135.98 58.53,135.98 58.42,136.09 56.77,136.09 56.08,136.78 53.77,136.78 53.4,136.41 52.96,136.41 52.7,136.67 52.7,137.06 52.6,137.17 52.16,137.17 51.91,137.42 51.91,137.53 51.78,137.66 51.37,137.66 51.24,137.53 51.24,137.15 50.95,136.86 50.34,136.86 50.05,137.15 50.05,137.53 49.92,137.66 49.59,137.66 49.46,137.53 49.46,137.45 49.18,137.17 48.81,137.17 48.52,136.88 48.52,136.13 47.54,135.15 45.31,135.15 44.72,134.57 36.22,134.57 35.94,134.85 33.23,134.85 32.31,133.93 32.31,133.66 31.51,132.86 30.39,132.86 28.2,130.67 28.2,130.47 28.87,129.8 28.87,129.38 28.44,128.96 28.03,128.96 27.38,129.61 27.14,129.61 27.04,129.51 27.04,129.43
LCD_CBL_DET#: length 119.5
  TOP w0.102: v1(84.38,129.17) 85.18,129.17 85.7,129.69 85.7,130.82 84.81,131.71 84.81,132.6 84.17,133.24 84.17,139.97 82.24,141.9 JLVDS1.1 ; v1(85.96,124.45) 86.63,123.79 86.63,120.13 84.43,117.93 v1(84.43,117.36) ; UH4.G42 20.74,124.8 21.25,124.8 21.27,124.78 v1(21.31,124.78)
  IN2 w0.127: v1(84.43,117.36) 84.29,117.36 84.06,117.59 80.94,117.59 79.89,116.55 74.97,116.55 70.1,121.41 70.1,130.07 67.89,132.28 67.89,133.25 66.83,134.32 66.44,134.32 66.32,134.19 64.57,134.19 63.89,134.86 63.89,135.28 63.41,135.76 61.72,135.76 61.59,135.89 56.15,135.89 55.32,135.07 48.02,135.07 45.96,133.01 38.78,133.01 38.34,132.56 30.03,132.56 28.92,131.45 23.01,131.45 22.52,130.95 20.75,130.95 v1(20.61,130.81)
  IN4 w0.109: v1(85.96,124.45) 85.84,124.57 85.84,127.56 84.38,129.02 v1(84.38,129.17)
  BOTTOM w0.102: v1(21.31,124.78) 21.09,125 21.09,125.97 21.12,126 21.12,127.18 v2(20.74,127.56) 20.74,127.89 20.18,128.45 20.18,130.38 v1(20.61,130.81) 20.61,130.9 19.84,131.67 RH330.2
LCD_SMBCLK: length 118.5
  TOP w0.102: v1(57.82,157.47) 57.65,157.29 57.65,157.19 57.74,157.09 JEDP1.20
  TOP w0.127: R418.1 158.68,148.58 159.53,149.43 v1(160.08,149.43) ; U54.B5 162.13,149.12 162.69,149.12 162.93,148.88 v1(162.93,148.87)
  IN4 w0.127: v3(148.21,148.69) 148.21,149.21 147.44,149.97 118.27,149.97 117.89,149.59 114.26,149.59 113.8,150.05 113.8,150.56 113.53,150.83 111.56,150.83 110.87,150.14 108.17,150.14 107.24,149.21 101.64,149.21 100.73,148.31 86.96,148.31 86.48,147.83 81.36,147.83 80.63,148.55 77.24,148.55 74.51,151.28 71.33,151.28 70.84,151.78 70.02,151.78 69.28,152.52 69.28,152.8 67.07,155.01 66.79,155.01 65.74,156.06 61.3,156.06 60.83,156.53 59.98,156.53 58.52,157.99 57.77,157.99 57.64,157.86 57.64,157.65 v1(57.82,157.47) ; v1(160.08,149.43) 160.15,149.43 160.23,149.52 161.81,149.52 162.25,149.07 162.25,149.07 162.35,148.97 162.82,148.97 v1(162.93,148.87)
  BOTTOM w0.127: v3(148.21,148.69) 148.64,148.26 153.48,148.26 154.24,149.02 156.75,149.02 156.77,149.01 156.81,149.01 156.93,148.88 158.89,148.88 159.43,149.43 v1(160.08,149.43)
LCD_SMBDAT: length 115.4
  TOP w0.102: v1(57.19,157.47) 57.42,157.24 57.42,157.13 57.24,156.95 JEDP1.21
  TOP w0.127: R420.1 159.32,149.59 v1(159.62,149.9) 160.34,149.9 160.85,149.38 U54.A4
  IN4 w0.127: v3(148.98,148.79) 147.55,150.23 118.17,150.23 117.79,149.85 114.37,149.85 114.06,150.16 114.06,150.66 113.64,151.08 111.45,151.08 110.77,150.39 108.06,150.39 107.14,149.47 101.53,149.47 100.63,148.56 86.86,148.56 86.38,148.08 81.46,148.08 80.74,148.81 77.35,148.81 74.62,151.53 71.44,151.53 70.94,152.03 70.13,152.03 69.54,152.62 69.54,152.9 67.18,155.26 66.9,155.26 65.85,156.31 61.4,156.31 60.93,156.78 60.08,156.78 58.62,158.24 57.67,158.24 57.39,157.96 57.39,157.67 v1(57.19,157.47)
  BOTTOM w0.127: v3(148.98,148.79) 149.26,148.51 153.37,148.51 154.13,149.28 156.87,149.28 157,149.15 158.71,149.15 159.43,149.87 159.6,149.87 v1(159.62,149.9)
LCD_TST: length 292.6
  TOP w0.102: v1(77.42,145.43) 76.74,144.75 JLVDS1.12 ; v1(174.29,90.87) 175.56,89.6 175.58,89.6 176.06,89.12 176.06,88.6 180.42,84.24 183.27,84.24 183.43,84.09 196.01,84.09 198.5,81.6 207.92,81.6 209.53,83.21 213.61,83.21 215.61,85.2 215.61,86.28 215.2,86.69 215.2,90.46 215.02,90.64 215.02,91.47 215.28,91.72 217.31,91.72 218.16,90.87 226.95,90.87 231.43,86.39 232.88,86.39 233.51,85.75 233.51,82.78 v1(233.48,82.74) ; v1(61.89,157.51) 61.74,157.36 JEDP1.12
  IN1 w0.109: v1(103.97,153.3) 103.91,153.3 102.67,152.06 101.12,152.06 100.4,151.35 100.4,149.39 92.95,141.94 85.98,141.94 85.11,142.8 78.85,142.8 77.87,143.78 77.87,144.97 v1(77.42,145.43) ; v1(125.3,128.56) 125.3,130.19 126.95,131.84 v1(134.05,131.84)
  IN2 w0.127: v1(79.03,149.7) 78.27,149.7 73,154.97 72.98,154.97 70.94,157 62.39,157 v1(61.89,157.51)
  IN3 w0.127: v1(158.7,121.9) 158.75,121.84 158.75,120.08 157.88,119.22 153.72,119.22 152.58,120.36 152.58,129.53 152.09,130.01 152.09,130.09 152.07,130.11 151.99,130.11 151.64,130.47 147.88,130.47 146.51,131.84 v1(134.05,131.84)
  BOTTOM w0.102: v1(158.7,121.9) 160.18,120.41 160.18,112.22 157.78,109.82 157.78,99.94 156.67,98.82 156.67,94.58 157.1,94.15 157.1,91.99 160.46,88.63 168.27,88.63 168.92,87.99 172.81,87.99 173.43,88.61 173.43,90.06 174.24,90.87 v1(174.29,90.87) ; v1(77.42,145.43) 77.42,148.08 v1(79.03,149.7) ; v1(125.3,128.56) 125.16,128.7 124.42,128.7 121.61,131.51 109.73,131.51 109.07,132.17 109.07,138.53 110.65,140.12 110.65,145.92 109.59,146.99 106.4,146.99 104.95,148.44 104.95,151.11 103.97,152.08 v1(103.97,153.3) ; U46.A36 234.58,78.59 v2(234.08,79.08) 233.59,79.58 R767.2 233.59,80.43 233.06,80.96 233.06,82.32 v1(233.48,82.74)
LCD_VCC_TEST_EN: length 248.2
  TOP w0.102: v1(82.76,152.44) 80.9,152.44 80.24,153.1 76.31,153.1 75.51,152.3 74.45,152.3 73.3,151.16 v2(72.68,151.16) 71.59,150.07 71.59,150.06 70.66,149.12 70.66,148.22 v1(68.06,145.62)
  IN2 w0.127: v1(82.76,152.44) 83.2,152.01 96.2,152.01 96.72,152.53 116.64,152.53 117.52,151.64 127.89,151.64 129.82,153.57 135.13,153.57 135.46,153.9 135.46,155.71 136.56,156.81 144.19,156.81 144.81,156.19 146.76,156.19 147.41,155.54 152.78,155.54 159.33,162.09 165.26,162.09 167.39,159.96 169.51,159.96 169.62,160.07 171.24,160.07 171.3,160.01 175.17,160.01 175.46,159.72 182.74,159.72 182.96,159.93 191.77,159.93 193.1,158.6 197.37,158.6 199.97,156.01 201.61,156.01 205.95,151.66 205.95,131.13 205.6,130.77 205.6,120.04 206.53,119.11 206.53,103.18 208.38,101.33 208.38,96.3 211.02,93.66 219.5,93.66 221.72,91.44 222.76,91.44 224.71,89.49 224.71,89.29 227.61,86.39 228.83,86.39 229.44,85.78 229.45,85.78 231.27,83.95 231.27,83.64 232.12,82.79 232.5,82.79 233.08,82.21 233.08,81.88 235.89,79.07 v1(236.1,79.07)
  BOTTOM w0.102: U46.A40 236.58,78.12 236.54,78.16 236.54,78.64 v1(236.1,79.07) ; v1(68.06,145.62) 68.25,145.43 D6.2
LDDC_CLK_PCH: length 67.6
  TOP w0.102: v3(69.81,140.07) 70.08,140.07 70.71,139.44 R1124.2 70.33,138.91 70.33,138.27 70.72,137.88 U11.6 ; v1(25.72,124.32) 25.65,124.32 25.62,124.3 25.46,124.3 UH4.T40
  IN1 w0.109: v1(25.72,124.32) 25.68,124.32 25.65,124.36 25.53,124.36 25.18,124.7 25.18,127.53 24.4,128.32 21.78,128.32 21.49,128.61 21.49,129.46 21.93,129.91 25.91,129.91 29.91,133.91 30.81,133.91 32.76,135.86 43.66,135.86 43.93,135.59 44.3,135.59 45.18,136.46 46.66,136.46 48.39,138.19 48.67,138.19 49.16,138.68 52.22,138.68 52.51,138.39 53.77,138.39 54.36,137.8 56.5,137.8 57.19,137.11 58.84,137.11 58.95,137 64.56,137 64.8,137.24 65.76,137.24 66.44,137.92 67.51,137.92 69.66,140.07 v3(69.81,140.07)
LDDC_CLK_SW: length 9.6
  TOP w0.102: C1188.1 73.51,140.6 73.74,140.84 JLVDS1.18 ; C1188.1 74.46,139.16 R159.2 ; C1188.1 72.95,140.11 v2(72.6,139.76) 72.27,139.43 72.27,138.72 72.08,138.53 71.8,138.53 71.58,138.3 71.58,138.29 71.56,138.28 71.56,138.14 71.55,138.13 71.55,137.72 71.72,137.55 U11.4
LDDC_DATA_PCH: length 64.5
  TOP w0.102: v1(22.12,129.43) 22.15,129.45 22.73,128.87 22.73,128.18 22.24,127.69 UH4.K47 ; R1123.2 65.07,132.97 65.63,133.53 66.09,133.53 66.42,133.86 v3(66.65,133.86) 66.71,133.92 68.32,133.92 U11.14
  IN1 w0.109: v1(22.12,129.43) 22.3,129.6 26,129.6 30.09,133.7 30.97,133.7 31.53,134.26 31.53,134.26 32.9,135.63 43.56,135.63 43.84,135.36 44.4,135.36 45.27,136.23 46.76,136.23 48.49,137.96 48.76,137.96 49.25,138.45 52.11,138.45 52.38,138.18 53.66,138.18 54.27,137.57 56.4,137.57 57.09,136.88 58.74,136.88 58.85,136.77 67.33,136.77 67.46,136.64 67.46,136.37 67.33,136.25 66.51,136.25 66.38,136.12 66.38,135.73 66.51,135.6 67.35,135.6 67.47,135.47 67.47,135.2 67.35,135.08 66.2,135.08 66.08,134.95 66.08,134.73 66.2,134.61 67.35,134.61 67.47,134.48 67.47,133.9 67.36,133.78 66.73,133.78 v3(66.65,133.86)
LDDC_DATA_SW: length 18.6
  TOP w0.102: U11.12 67.63,134.92 67.09,135.46 67.09,136.73 67.45,137.08 v1(67.45,137.26) ; v3(73.13,141.15) 73.24,141.26 JLVDS1.19
  IN1 w0.109: v3(73.13,141.15) 73.13,140.72 73.91,139.93 73.91,137.48 72.58,136.14 69.49,136.14 69.35,136 68.42,136 67.58,136.85 67.58,136.88 67.45,137.01 v1(67.45,137.26)
  BOTTOM w0.102: v3(73.13,141.15) 73.03,141.24 R160.2
LDO_SET: length 3
  TOP w0.102: U18.33 140.07,164.96 R392.1 v2(141.32,165.2)
LED_10_GRN#: length 52
  TOP w0.102: v1(98.25,157.12) 98.25,157.59 96.92,158.92 96.92,159.69 97.94,160.7 R1170.1 ; v1(129.31,143.57) U32.41
  IN2 w0.127: v1(127.63,154.93) 125.65,152.95 121.3,152.95 120.56,153.68 113.31,153.68 108.72,158.28 99.15,158.28 98.25,157.38 v1(98.25,157.12)
  BOTTOM w0.102: v1(127.63,154.93) 128.62,153.94 v2(128.62,149.04) 128.62,144.25 v1(129.31,143.57)
LED_100_ORG#: length 36.8
  TOP w0.102: R1167.1 96.85,159.96 96.63,159.74 96.63,159.33 v2(96.59,159.3) 96.59,158.86 97.78,157.68 v1(97.78,156.6) ; U32.18 118.62,144.07 118.53,144.16 118.53,147.18 117.96,147.75 117.96,152.22 v1(117.68,152.5)
  IN2 w0.127: v1(97.78,156.6) 97.78,154.69 98.33,154.13 99.68,154.13 101.01,152.79 117.38,152.79 v1(117.68,152.5)
LED_SATA_DIAG_OUT#: length 3.2
  BOTTOM w0.102: D62.1 235.56,64.58 v2(235.79,64.81) 236.08,65.1 U46.A10
LED_WLAN_WWAN_DIAG_OUT#: length 10.4
  IN1 w0.109: v1(234.82,69.01) 234.81,69.01 234.31,68.52 234.31,68.11 233.34,67.13 232.19,67.13 v1(230.01,64.95)
  BOTTOM w0.102: v2(230.57,65.44) 230.07,64.95 v1(230.01,64.95) 229.97,64.91 D63.1 ; v1(234.82,69.01) 234.88,69.01 235.33,68.57 U46.B12
LED_WWAN_OUT#: length 5.3
  TOP w0.102: Q77.3 105.51,159.97 106.08,160.54 v1(106.08,160.68) 106.12,160.68 v2(106.53,160.27) 106.72,160.08 R719.1
  BOTTOM w0.102: JMINI1.42 106.92,159.84 v1(106.08,160.68)
LG_3V: length 10.1
  TOP w0.102: v1(275.06,49.21) v2(275.06,49.85)
  IN3 w1.016: 278.74,57.72 278.74,52.01 276.07,49.34
  vias: v1(274.42,49.21) v1(278.36,58.48) v1(278.99,58.48)
LG_5V: length 13.8
  TOP w0.102: v1(269.09,45.72) v2(269.09,46.46)
  IN3 w1.016: 269.47,46.8 269.47,54.29 272.9,57.72 273.66,57.72
  vias: v1(269.76,45.72) v1(273.66,58.48) v1(274.29,58.48)
LG_+V1.05S_VCCPP: length 10.1
  TOP w0.762: v1(61.45,25.38) 62.05,25.97 64.43,25.97 66.01,24.38 66.01,20.71
  BOTTOM w0.127: v1(61.45,25.38) v2(61.45,26.33)
  vias: v1(60.69,25.39) v1(66.15,20.22) v1(66.8,20.22)
LG_+V1.05SP: length 17
  TOP w0.127: 2.35,152.11 v2(1.98,152.11)
  IN1 w0.762: 1.78,151.71 1.4,151.34 1.4,141.77 2.01,141.16 7.64,141.16
  vias: v1(2.54,151.71) v1(3.17,151.73) v1(8.32,141.01) v1(8.84,141.43)
LGATE1: length 22.1
  IN1 w1.016: 32.1,77.28 32.1,76.89 32.17,76.82 32.17,74.17 33.54,72.8 33.54,67.77 33.46,67.69 33.46,65.82 34.07,65.22 41.25,65.22 42.26,64.2 42.26,63.69
  vias: v1(30.64,77.47) v1(31.28,77.47) v1(42.77,62.72) v1(42.77,62.09) v1(42.77,56.75) v1(43.53,56.75) v2(43.34,56.19)
LGATE1G: length 17.2
  IN3 w1.016: 40.74,79.06 38.07,79.06 36.93,80.2 36.93,81.98 36.17,82.74 33.37,82.74 30.83,85.28 28.68,85.28 28.04,84.65
  BOTTOM w0.102: v1(27.91,83.31) v2(27.34,83.31)
  vias: v1(27.85,82.68) v1(41.63,79.36) v1(42.26,79.36)
LGATE2: length 12.7
  IN1 w1.016: 32.49,79.19 33.48,78.19 33.48,74.44 34.83,73.09 40.49,73.09
  vias: v1(30.83,79.62) v1(31.47,79.62) v1(41.5,73.26) v1(41.5,67.42) v1(42.26,73.26) v1(42.26,67.42) v2(41.67,72.75)
LGATE2G: length 10.2
  TOP w0.102: PU703.5 31.97,87.13 v2(32.15,86.94)
  IN3 w1.016: 32.49,86.74 33.18,86.74 34.52,85.41 40.87,85.41
  vias: v1(30.69,86.51) v1(31.34,86.49) v1(41.76,85.46) v1(42.39,85.46)
LGATE3: length 10.7
  IN1 w0.762: 45.88,53.09 45.88,49.92 44.05,48.1 44.05,46.24 43.41,45.59 43.41,44.04 43.39,44.03
  BOTTOM w0.102: v1(45.95,54.6) v2(46.53,54.6)
  vias: v1(43.33,43.55) v1(43.79,43.09) v1(45.95,53.96) v1(51.65,54.34) v1(51.66,53.71)
LID_CL#: length 312.8
  TOP w0.102: JIO1.71 32.27,24.55 v1(32.38,24.44)
  IN1 w0.109: v1(32.38,24.44) 30.85,22.9 30.85,12.92 31.6,12.17 32.91,12.17 32.94,12.19 33.3,12.19 33.88,11.61 33.88,11.22 36.62,8.48 107.24,8.48 108.34,9.58 108.73,9.58 109.21,10.05 109.21,11.39 110.56,12.75 111.81,12.75 114.48,15.42 117.08,15.42 119.21,13.3 121.37,13.3 121.65,13.02 121.65,12.65 122.12,12.18 131.49,12.18 132.07,12.76 152.63,12.76 155.29,15.42 155.68,15.42 158.88,12.22 170.04,12.22 v1(172.93,15.11)
  IN3 w0.127: v1(172.93,15.11) 172.93,21.6 167.03,27.51 167.03,34.42 167.66,35.05 167.66,40.37 173.79,46.5 179.61,46.5 180.55,45.56 185.51,45.56 187.85,47.89 187.85,49.43 188.46,50.05 191.14,50.05 194.29,53.2 201.62,53.2 209.26,60.83 218.86,60.83 220.88,58.81 224.04,58.81 224.2,58.98 225.8,58.98 226.51,58.27 227.38,58.27 227.95,58.84 230.8,58.84 232.38,57.25 242.62,57.25 245.5,60.14 v1(245.5,61.29)
  BOTTOM w0.102: R807.1 249.35,77.53 249.83,77.05 249.83,76.07 247.99,74.23 v2(247.99,74.04) 247.99,70.46 248.58,69.88 249.54,69.88 250.37,69.05 250.37,61.9 249.86,61.39 248.35,61.39 247.97,61.77 247.97,62.1 247.62,62.45 247.04,62.45 246.73,62.14 U58.2 246.73,61.56 246.42,61.24 245.55,61.24 v1(245.5,61.29)
LID_CL_SIO#: length 16.3
  TOP w0.102: v1(243.76,79.46) 244.69,79.46 246.57,77.58 v1(246.57,77.29)
  IN2 w0.127: v1(243.76,79.46) 243.36,79.06 243.36,78.14 243.06,77.84 242.77,77.84 241.03,76.11 241.03,75.93 240.7,75.6 v1(240.7,75.37)
  BOTTOM w0.102: v1(246.57,77.29) 247.12,77.29 247.36,77.53 R807.2 ; R807.2 247.99,77.99 v2(249.46,77.99) ; R807.2 C750.2 ; U46.B54 241.17,75.2 241.02,75.35 240.73,75.35 v1(240.7,75.37) ; v1(243.76,79.46) 243.86,79.57 R805.2 C716.1
LOM_ACTLED_YEL#: length 21
  TOP w0.102: U31.26 127.63,159.05 127.86,158.81 127.86,158 v1(127.84,157.98) ; U32.15 120.8,145.52 120.58,145.73 120.58,146.32 120.95,146.69 v1(121.05,146.69)
  BOTTOM w0.102: v1(121.05,146.69) 120.81,146.93 120.81,156.02 122.77,157.98 v2(123.25,157.98) v1(127.84,157.98)
LOM_SPD10LED_GRN#: length 21.1
  TOP w0.102: U32.42 129.63,144.07 v1(130.12,143.57) ; U31.25 127.52,158.65 127.61,158.56 127.61,158.45 127.37,158.2 127.37,157.53 127.45,157.45 127.45,156.25 128.18,155.51 U15.2 130.17,155.51 v1(130.38,155.31)
  BOTTOM w0.102: v1(130.12,143.57) 129.18,144.51 v2(129.18,153.31) 129.18,154.19 130.3,155.31 v1(130.38,155.31)
LOM_SPD100LED_ORG#: length 25.1
  TOP w0.102: v1(120.13,145.98) 120.3,145.81 U32.16 ; U15.1 129.12,156.16 128.5,156.78 128.5,158.31 128.31,158.5 v1(128.31,158.48) 128.24,158.55 128.24,159.06 127.85,159.45 U31.27
  BOTTOM w0.102: v1(128.31,158.48) 128.29,158.5 v2(126.92,158.5) 122.88,158.5 120.55,156.16 120.55,146.39 v1(120.13,145.98)
LPC_LAD0: length 345.2
  TOP w0.102: UH4.C38 18.33,122.79 18.02,123.1 16.87,123.1 v1(16.84,123.06) ; v1(171.09,109.96) 171.04,110.01 171.04,110.99 169,113.03 169,116.12 169.37,116.48 169.37,126.64 168.74,127.27 168.74,135.24 169.38,135.88 169.38,138.98 169.05,139.31 169.05,139.81 v1(169.47,140.23) U54.A30 ; v1(229.93,73.18) 228.66,73.18 227.68,72.2 225.98,72.2 225.4,71.62 224.37,71.62 223.05,70.29 222.53,70.29 222.11,69.87 221.33,69.87 v1(220.81,69.36) ; U39.26 U37.26 v1(167.61,107.52)
  IN1 w0.109: v1(167.61,107.52) 168.15,107.52 170.19,109.56 170.61,109.56 171,109.96 v1(171.09,109.96)
  IN2 w0.102: v1(16.84,123.06) 17.78,124 17.78,124.65 17.59,124.84 17.59,127.69 19.25,129.35
  IN2 w0.127: 19.25,129.35 19.92,130.02 19.92,130.75 20.44,131.27 22.45,131.27 22.85,131.68 28.82,131.68 29.94,132.79 38.16,132.79 38.76,133.39 46.02,133.39 47.92,135.29 55.23,135.29 56.05,136.12 61.94,136.12 62.56,136.74 63.35,136.74 64.4,135.69 65.73,135.69 66.1,135.32 67.03,135.32 68.73,133.62 68.73,132.7 71.59,129.85 72.01,129.85 72.97,128.88 72.97,120.59 76.15,117.41 79.5,117.41 80.82,118.73 92.12,118.73 95.52,115.34 100.09,115.34 103.26,112.17 104.93,112.17 107.05,110.05 122.63,110.05 123.12,109.55 128.43,109.55 129.29,108.69 131.25,108.69 132.99,106.95 142.5,106.95 144.11,108.56 166.57,108.56 v1(167.61,107.52) 168.36,107.52 169.06,106.82 169.06,106.58 170.75,104.89 174.32,104.89 175.79,103.42 175.79,100.94 178.12,98.61 178.12,97.25 181.02,94.34 181.02,93.68 182.02,92.69 182.66,92.69 186.92,88.43 186.92,87.95 187.66,87.21 188.14,87.21 189.71,85.64 189.71,69.1 191.15,67.67 202.62,67.67 204.74,65.55 213.6,65.55 217.41,69.36 v1(220.81,69.36)
  IN3 w0.127: v1(169.47,140.23) 169.47,141.05 170.28,141.86 170.6,141.86 171.21,142.47 171.21,143.57 173.29,145.66 174.5,145.66 174.74,145.42 175.47,145.42 176.08,146.03 176.08,147.98 176.48,148.37 177.73,148.37 178.43,149.08 178.43,150.75 178,151.18 v1(178,153.72)
  BOTTOM w0.102: v1(178,153.72) 177.44,153.16 v2(176.45,153.16) 175.84,153.77 JMINI3.16 ; v1(229.93,73.18) 230.08,73.18 230.36,73.45 U46.A27
LPC_LAD1: length 330.7
  TOP w0.102: v1(169.8,144.58) 169.72,144.5 U54.B32 ; UH4.A38 17.83,122.76 17.16,122.76 17,122.59 16.61,122.59 16.19,123.01 v1(16.19,123.05) ; U39.23 U37.23 v1(169.56,106.84) 170,107.28 170,108.12 169.31,108.8 169.31,109.24 166.89,111.67 v1(166.89,126.44) 167.96,127.51 167.96,135.8 v1(168.26,136.11) ; v1(221.5,69.36) 221.88,69.36 222.62,70.09 223.13,70.09 224.46,71.42 225.49,71.42 226.07,72 227.8,72 228.66,72.86 229.62,72.86 229.76,72.72 230.34,72.72 v1(230.57,72.95)
  IN1 w0.109: v1(168.26,136.11) 169,136.11 169.53,136.64 169.53,138.01 169.96,138.44 169.96,144.41 v1(169.8,144.58)
  IN2 w0.127: v1(221.5,69.36) 221.05,69.8 217.52,69.8 213.58,65.86 204.85,65.86 202.81,67.89 191.24,67.89 189.94,69.19 189.94,85.73 188.23,87.44 187.86,87.44 187.15,88.15 187.15,88.52 182.76,92.91 182.38,92.91 182.37,92.93 182.1,92.93 181.25,93.77 181.25,95.8 176.03,101.02 176.03,103.52 174.43,105.12 170.84,105.12 169.56,106.4 v1(169.56,106.84) ; v1(166.89,126.44) 156.49,126.44 152.28,130.65 131,130.65 129.86,129.5 124.52,129.5 124.12,129.11 116.04,129.11 114.48,130.67 106.94,130.67 106.71,130.9 104.2,130.9 103.3,131.8 84.48,131.8 84.01,132.27 80.43,132.27 79.92,131.76 77.14,131.76 75.94,132.96 74.37,132.96 73.99,133.34 71.05,133.34 70.34,134.05 70.16,134.05 67.56,136.64 66.65,136.64 66.31,136.98 65.37,136.98 64.27,138.07 61.94,138.07 61.38,137.52 55.28,137.52 55.15,137.39 47.98,137.39 44.77,134.18 36.61,134.18 35.67,135.12 29.89,135.12 29.25,134.47 29.25,133.67 28.05,132.47 22.33,132.47 22.01,132.16 17.95,132.16 17.47,131.68 17.47,130.3 16.93,129.75 16.93,127.09 15.47,125.63 15.47,124.23 16.19,123.51 v1(16.19,123.05)
  BOTTOM w0.102: v1(230.57,72.95) U46.A26 ; v1(169.8,144.58) 169.39,144.98 v2(169.39,149.53) 169.39,152.91 168.91,153.39 168.91,154.41 169.22,154.72 170.47,154.72 170.8,154.39 174.42,154.39 175.04,155.01 JMINI3.14
LPC_LAD2: length 405.4
  TOP w0.102: UH4.B37 18.21,122.39 17.77,122.39 17.61,122.56 17.25,122.56 16.82,122.12 v1(16.79,122.12) ; v1(171.26,103.24) 171.27,103.24 171.51,103.48 U39.20 U37.20 171.51,106.58 171.58,106.64 171.58,108.36 171.61,108.4 171.61,109.36 171.64,109.38 171.64,109.71 171.65,109.72 171.65,110.9 169.2,113.35 169.2,115.72 169.63,116.15 169.63,126.85 168.97,127.51 168.97,135.13 169.63,135.79 169.63,139.21 169.49,139.34 v1(169.49,139.52) 169.49,139.54 169.97,140.02 U54.A31
  IN2 w0.102: v1(16.79,122.12) 17.98,123.31 17.98,124.89 17.79,125.08 17.79,126.87 19.38,128.46 20.19,128.46 20.36,128.3 22.85,128.3 23.9,129.35
  IN2 w0.127: v1(171.26,103.24) 170.81,102.79 166.27,102.79 166.03,103.04 166.03,106.74 165.02,107.75 155.94,107.75 155.05,106.86 143.34,106.86 143.17,106.68 132.9,106.68 131.2,108.38 129.27,108.38 128.47,109.18 123.17,109.18 122.56,109.79 102.98,109.79 102.55,110.22 102.55,111.43 100.2,113.78 94.79,113.78 92.43,116.14 86.16,116.14 86.05,116.04 74.76,116.04 73.92,116.88 73.75,116.88 69.54,121.08 69.54,129.86 67.44,131.97 67.44,132.84 67.12,133.16 66.08,133.16 65.53,133.71 64.39,133.71 63.43,134.67 63.43,135.09 63.24,135.29 61.54,135.29 61.42,135.41 56.31,135.41 55.51,134.61 48.21,134.61 46.15,132.55 39.33,132.55 38.89,132.11 30.22,132.11 29.11,130.99 26.32,130.99 25.28,129.96 24.51,129.96 23.9,129.35 ; v1(174.41,155.11) 174.94,155.64 177.71,155.64 178.55,154.8 179.44,154.8 179.64,154.6 180.35,154.6 181.43,153.52 196.49,153.52 198.3,151.71 198.3,143.82 198.11,143.62 198.11,127.03 199.85,125.29 199.85,116.51 200.94,115.42 200.94,113.45 202.14,112.24 202.14,107.57 201.18,106.6 201.18,104.75 202.08,103.85 202.08,101.66 202.69,101.05 v1(203.33,101.05)
  IN3 w0.127: v1(203.33,101.05) 203.78,101.51 205,101.51 205.99,100.52 205.99,96.58 204.98,95.57 204.43,95.57 204.42,95.56 204.05,95.56 204.04,95.58 202.4,95.58 201.84,95.02 201.84,94.31 201.57,94.04 198.69,94.04 198.02,93.37 198.02,90.54 198.98,89.57 198.98,88.66 197.95,87.63 197.95,85.71 201.18,82.49 205.94,82.49 208.47,79.96 214.84,79.96 216.28,78.52 216.28,74.98 217.3,73.96 217.3,72.81 219.85,70.26 222.97,70.26 223.45,70.73 225.31,70.73 226.08,69.96 230.73,69.96 231.91,71.14 233.26,71.14 233.54,71.43 233.63,71.43 v1(233.69,71.49)
  BOTTOM w0.102: v1(233.69,71.49) 233.67,71.51 233.67,71.6 233.07,72.2 U46.B26 ; JMINI3.12 174.24,155.27 v1(174.41,155.11) 174.08,155.11 173.59,154.62 170.9,154.62 170.57,154.95 169.12,154.95 168.68,154.51 168.68,153.28 169.06,152.9 169.06,144.65 169.49,144.22 169.49,142.79 170,142.28 v2(170,141.68) 170,139.94 169.58,139.52 v1(169.49,139.52)
LPC_LAD3: length 379.1
  TOP w0.102: v1(17.43,122.12) 17.44,122.11 18.03,122.11 18.17,121.96 18.44,121.96 18.77,122.29 UH4.C37 ; v1(189.25,106.52) 189.44,106.32 194.7,106.32 v1(194.96,106.07) ; v1(170.48,143.26) 170.22,143 U54.B33 ; v1(173.44,102.88) 173.44,103.37 173.46,103.38 U39.17 U37.17 ; v1(232.95,71.6) 232.86,71.7 v2(232.23,71.7) 231.88,71.7 231.43,71.25 229.39,71.25 228.97,70.83 228.45,70.83 227.91,71.36 226.3,71.36 225.74,70.81 224.71,70.81 223.28,69.37 223.28,69.01 v1(222.43,68.16)
  IN1 w0.109: v1(189.25,106.52) 189.16,106.43 182.68,106.43 180.86,104.61 174.86,104.61 173.44,103.19 v1(173.44,102.88)
  IN2 w0.102: v1(17.43,122.12) 18.18,122.88 18.18,125.01 17.99,125.2 17.99,126.79 19.46,128.25 20.07,128.25 20.23,128.09 22.99,128.09 24.24,129.35
  IN2 w0.127: 24.24,129.35 24.57,129.68 25.33,129.68 26.41,130.76 29.2,130.76 30.31,131.88 39.43,131.88 39.88,132.32 46.37,132.32 46.95,132.91 50.93,132.91 52.38,134.35 55.58,134.35 56.41,135.18 61.33,135.18 62.3,134.2 62.3,134.18 62.79,133.69 64.06,133.69 64.28,133.47 64.72,133.47 68.05,130.15 68.05,121.98 73.47,116.56 73.91,116.56 74.66,115.81 86.15,115.81 86.25,115.91 92.31,115.91 94.69,113.54 100.11,113.54 102.3,111.35 102.3,110.04 102.78,109.56 122.46,109.56 123.07,108.95 128.3,108.95 129.11,108.14 130.59,108.14 132.32,106.41 143.25,106.41 143.43,106.59 155.13,106.59 156.06,107.52 164.86,107.52 165.8,106.58 165.8,102.95 166.25,102.49 171.35,102.49 171.44,102.4 172.96,102.4 v1(173.44,102.88) 173.54,102.88 174.62,101.8 174.62,101.11 177.43,98.3 177.43,96.93 180.34,94.02 180.34,93.39 181.73,92 182.33,92 184.86,89.48 184.86,85.98 188.15,82.69 188.15,69.26 190.43,66.98 201.08,66.98 202.19,65.88 203.17,65.88 204.19,64.86 213.94,64.86 217.52,68.44 221.06,68.44 221.56,67.95 222.21,67.95 v1(222.43,68.16) ; v1(170.48,143.26) 170.72,143.26 171.33,143.87 174.04,143.87 174.56,144.39 175.46,144.39 175.87,144.79 177.6,144.79 180.58,141.81 181.75,141.81 183.49,140.07 184.61,140.07 186.52,138.15 188.62,138.15 189.93,136.84 189.93,111.75 192.7,108.98 192.7,107.06 193.69,106.07 v1(194.96,106.07)
  IN3 w0.127: v1(173.44,155.5) 173.94,155 173.94,152.48 172.12,150.66 172.12,145.05 170.98,143.91 170.98,143.62 170.61,143.26 v1(170.48,143.26)
  BOTTOM w0.102: v1(173.44,155.5) 173.44,155.5 JMINI3.10 ; v1(232.95,71.6) 232.86,71.7 U46.B25
LPC_LDRQ1#: length 272.5
  TOP w0.102: UH4.K36 21.97,122.13 22.15,122.31 v1(22.15,122.31) ; v1(230.02,70.82) 230.02,70.37 229.82,70.17 229.09,70.17 v2(228.85,70.41) 225.94,70.41 225.75,70.6 224.79,70.6 224.46,70.27 223.53,69.34 223.53,68.58 v1(222.48,67.53)
  IN2 w0.102: 26.31,129.31 26.31,128.85 25.53,128.07 24.1,128.07 23.33,127.3 23.33,125.92 23.15,125.74 23.15,122.91 22.96,122.72 22.56,122.72 v1(22.15,122.31)
  IN2 w0.127: v1(222.48,67.53) 221.65,67.53 220.97,68.21 217.63,68.21 214.04,64.63 203.98,64.63 203.08,65.53 202.21,65.53 200.99,66.75 190.34,66.75 187.03,70.05 187.03,71.41 187.92,72.29 187.92,82.59 184.61,85.9 184.61,89.39 182.24,91.77 181.64,91.77 180.11,93.3 180.11,93.92 177.2,96.83 177.2,98.1 173.68,101.61 171.73,101.61 171.1,102.24 164.12,102.24 160.79,105.56 157.55,105.56 157,105 153.3,105 152.77,104.47 152.77,104.04 152.49,103.76 151.9,103.76 150.46,105.2 150.06,105.6 144.19,105.6 144,105.41 130.88,105.41 129.22,107.07 123.28,107.07 121.93,108.43 102.58,108.43 101.29,109.72 101.29,111.04 99.71,112.62 94.26,112.62 92.72,114.16 84.63,114.16 84.21,114.58 73.93,114.58 73.56,114.95 72.43,114.95 70.29,117.08 64.81,117.08 64.1,117.79 64.1,130.07 64.05,130.11 48.91,130.11 47.95,129.16 45.39,129.16 44.7,129.85 36.87,129.85 35.22,128.19 33.76,128.19 33.26,128.69 33.26,129.97 32.09,131.14 30.73,131.14 29.42,129.83 26.83,129.83 26.31,129.31
  BOTTOM w0.102: v1(230.02,70.82) 230.15,70.95 U46.A22
LPC_LDRQ#_MEC: length 3
  TOP w0.102: U54.B29 168.22,142.79 167.92,143.09 v1(167.92,143.27)
  BOTTOM w0.102: v2(167.33,143.87) 167.92,143.28 v1(167.92,143.27) 168.03,143.16 R823.2
LPC_LFRAME#: length 346.7
  TOP w0.102: U39.22 U37.22 170.21,107.17 170.23,107.19 170.23,108.21 169.54,108.9 169.54,109.34 167.61,111.27 167.61,112.07 v1(167.5,112.18) v2(167.5,125.41) 167.5,126.59 168.2,127.29 168.2,135.4 168.71,135.9 168.71,136.3 168.22,136.78 v1(168.22,136.86) ; v1(168.88,144.2) 169.34,143.74 169.34,142.99 169.22,142.87 U54.B31 ; UH4.D36 19.62,121.98 v1(19.62,122.31)
  IN1 w0.109: v1(230.57,70.48) 231.7,71.6 231.7,77.93 v1(231.3,78.32) ; v1(168.88,144.2) 168.98,144.2 169.38,143.8 169.38,142.11 169.26,142 169.26,140.65 169.03,140.42 169.03,137.66 v1(168.22,136.86)
  IN2 w0.102: v1(19.62,122.31) 19.62,122.48 19.95,122.81 21.76,122.81 22.17,123.23 22.17,127.09 22.67,127.58 22.97,127.89 23.11,127.89 24.57,129.35
  IN2 w0.127: v1(164.78,106.87) 164.78,106.92 164.43,107.27 156.14,107.27 155.19,106.32 143.51,106.32 143.37,106.19 132.22,106.19 130.52,107.89 129.04,107.89 128.23,108.7 123,108.7 122.55,109.16 102.86,109.16 102.06,109.96 102.06,111.27 100.01,113.31 94.58,113.31 92.2,115.68 86.45,115.68 86.35,115.58 74.38,115.58 73.75,116.22 72.6,116.22 67.75,121.07 67.75,130.06 64.57,133.24 64.16,133.24 63.96,133.45 62.68,133.45 62.52,133.6 55.65,133.6 55.13,134.13 52.47,134.13 51.03,132.68 47.05,132.68 46.46,132.09 43.57,132.09 41.91,130.43 37.87,130.43 36.65,131.65 30.41,131.65 29.29,130.53 26.65,130.53 25.54,129.43 24.64,129.43 24.57,129.35 ; v1(231.3,78.32) 231.3,78.49 228.52,81.28 225.1,81.28 224.53,81.85 224.53,82.62 224.79,82.87 224.79,83.64 223.02,85.41 220.68,85.41 219.69,86.4 218.76,86.4 216.57,88.6 213.02,88.6 212.81,88.81 208.99,88.81 208.15,89.65 203.21,89.65 202.17,90.69 199.57,90.69 198.11,92.16 198.11,94.47 196.89,95.69 196.89,96.77 194.68,98.97 194.51,98.97 192.71,100.78 192.71,104.12 191.08,105.74 191.08,107.58 190.3,108.36 189.92,108.36 186.73,111.55 186.73,116.22 183.72,119.23 182.8,119.23 179.91,122.12 179.91,123.55 168.81,134.65 168.81,136.25 168.22,136.83 v1(168.22,136.86)
  IN3 w0.127: v1(172.79,155.49) 173.4,154.88 173.4,152.55 171.73,150.88 171.73,146.96 171.4,146.63 169.44,146.63 169.24,146.43 169.24,144.74 168.88,144.39 v1(168.88,144.2)
  BOTTOM w0.102: v1(164.78,106.87) 164.78,108.79 167.5,111.51 v1(167.5,112.18) ; v1(172.79,155.49) 172.64,155.64 JMINI3.8 ; U46.A21 230.59,70.45 v1(230.57,70.48)
LVD_IBG: length 2
  TOP w0.102: UH4.AF37 30.27,122.07 30.57,122.37 30.57,122.4 v1(30.58,122.41)
  BOTTOM w0.102: RH344.2 30.63,122.35 v1(30.58,122.41) v2(29.94,122.41)
LX_3V: length 7
  TOP w1.016: 283.31,50.27 283.31,55.72 282.24,56.78
  vias: v1(281.32,57.25) v1(281.95,57.25) v1(282.04,49.59) v1(282.7,49.58) v2(280.25,58.43)
LX_5V: length 10.9
  TOP w0.762: 264.37,51.22 v4(268.04,54.89) 271.85,58.7 v1(272.15,58.7)
  vias: v1(264.22,50.37) v1(264.26,51.12) v1(272.65,59.14)
M_CLK_DDR0: length 69.6
  TOP w0.089: v1(94.39,61.92) 94.43,61.92 94.9,62.39 JCPU1.AB6
  IN1 w0.089: v1(94.39,61.92) 94.37,61.9 94.37,61.67 94.46,61.58 94.58,61.58 95,61.16 95,60.69 95.17,60.52 95.6,60.52 95.81,60.73 95.81,62.26 96.15,62.6 97.15,62.6 97.24,62.52 97.57,62.52 97.8,62.75 97.8,63.24 98.08,63.52 101.08,63.52 101.11,63.55
  IN1 w0.109: 101.11,63.55 101.18,63.61 101.37,63.61 101.48,63.72 101.48,64.33 101.74,64.59 102.22,64.59 102.48,64.33 102.48,63.01 102.6,62.88 102.9,62.88 103.02,63.01 103.02,64.33 103.28,64.59 103.76,64.59 104.02,64.33 104.02,62.74 104.14,62.61 104.5,62.61 104.62,62.74 104.62,64.11 104.88,64.37 105.45,64.37 105.7,64.11 105.7,62.76 105.81,62.65 106.14,62.65 106.25,62.76 106.25,64.11 106.51,64.37 106.99,64.37 107.24,64.11 107.24,62.76 107.35,62.65 107.68,62.65 107.79,62.76 107.79,64.11 108.05,64.37 108.53,64.37 108.78,64.11 108.78,62.76 108.89,62.65 109.22,62.65 109.33,62.76 109.33,64.11 109.59,64.37 110.06,64.37 110.32,64.11 110.32,62.94 110.45,62.82 110.74,62.82 110.87,62.94 110.87,64.11 111.13,64.37 112.57,64.37 113.43,63.5 117.2,63.5 125.88,54.81 128.8,54.81 129.55,54.06 130.62,54.06 131.36,53.32 v3(131.37,53.32)
  BOTTOM w0.099: v3(131.37,53.32) 131.1,53.59 131.1,53.95 131.25,54.1 132.15,54.1 133.18,53.07 133.57,53.07 133.74,52.9 JDIMM2.101
M_CLK_DDR1: length 67.4
  TOP w0.089: JCPU1.AA5 95.9,61.42 v1(95.4,60.92)
  IN1 w0.089: 104.49,65 101.34,65 100.84,64.51 98.48,64.51 97.54,63.57 97.15,63.57 96.7,63.12 96.12,63.12 95.52,62.51 94.98,62.51 94.8,62.34 94.8,61.61 95.4,61.01 v1(95.4,60.92)
  IN1 w0.109: v1(140.56,52.42) 140.28,52.69 140.28,52.85 140.34,52.91 142.96,52.91 143.03,52.85 143.03,52.4 143.28,52.14 143.72,52.14 143.97,52.4 143.97,53.6 143.72,53.86 132.42,53.86 132.3,53.98 131.66,53.98 130.9,54.75 129.77,54.75 129.07,55.45 126.15,55.45 117.46,64.14 113.7,64.14 112.83,65 104.49,65
  BOTTOM w0.099: v1(140.56,52.42) 140.52,52.39 140.4,52.39 140.31,52.48 140.31,53.07 140.39,53.15 141.35,53.15 141.59,53.39 141.75,53.39 141.94,53.2 JDIMM2.102
M_CLK_DDR2: length 84.2
  TOP w0.089: v3(99.4,64.94) 98.9,65.45 JCPU1.AE2
  IN3 w0.089: 104.49,64.41 101.99,64.41 100.9,63.32 99.12,63.32 99.12,63.33 99.11,63.33 98.77,63.67 98.77,63.92 99.4,64.55 v3(99.4,64.94)
  IN3 w0.094: 104.49,64.41 109.83,64.41 115.88,58.36 116.19,58.36 116.19,58.35 116.56,57.99 116.57,57.99 117.61,56.95 120.78,56.95 121.49,56.24 121.49,55.27 122.19,54.56 122.78,54.56 122.85,54.49 122.85,54.2 123.08,53.96 123.85,53.96 124.09,54.2 124.09,54.37 124.16,54.43 124.47,54.43 124.63,54.59 124.63,54.78 124.75,54.9 124.97,54.9 125.1,54.78 125.1,54.57 125.3,54.37 125.74,54.37 125.95,54.57 125.95,54.87 126.04,54.96 126.32,54.96 126.42,54.87 126.42,54.57 126.62,54.37 127.06,54.37 127.27,54.57 127.27,54.87 127.36,54.96 127.64,54.96 127.74,54.87 127.74,54.57 127.94,54.37 128.38,54.37 128.59,54.57 128.59,54.87 128.68,54.96 128.96,54.96 129.06,54.87 129.06,54.57 129.26,54.37 129.7,54.37 129.91,54.57 129.91,54.87 130,54.96 130.29,54.96 130.38,54.87 130.38,54.57 130.58,54.37 131.02,54.37 131.23,54.57 131.23,54.87 131.32,54.96 131.61,54.96 131.7,54.87 131.7,54.57 131.91,54.37 132.35,54.37 132.55,54.57 132.55,54.87 132.64,54.96 132.93,54.96 133.02,54.87 133.02,54.57 133.23,54.37 133.78,54.37 133.99,54.57 133.99,55.38 134.12,55.51 134.33,55.51 134.46,55.38 134.46,54.41 134.7,54.17 135.07,54.17 135.31,54.41 135.31,55.38 135.44,55.51 135.65,55.51 135.78,55.38 135.78,54.5 136.02,54.26 136.49,54.26 136.72,54.5 136.72,54.66 136.85,54.79 141.23,54.79 142.09,53.94 143.19,53.94 143.27,53.85 143.27,53.41 143.51,53.17 143.89,53.17 144.12,53.41 144.12,53.86 144.22,53.96 149.46,53.96 149.58,53.83 149.58,53.25 149.82,53.01 150.19,53.01 150.43,53.25 150.43,53.74 150.56,53.87 154.24,53.87 154.38,53.73 154.38,53.31 v1(154.2,53.14)
  BOTTOM w0.099: v1(154.2,53.14) 154.49,53.43 154.49,53.58 154.31,53.77 150.96,53.77 150.89,53.7 150.89,53.49 150.49,53.09 150.28,53.09 150.09,52.9 JDIMM4.101
M_CLK_DDR3: length 84.6
  TOP w0.089: v1(100.44,64.92) 99.91,65.45 JCPU1.AE1
  IN3 w0.089: 104.49,65.22 101.41,65.22 100.72,64.54 100.54,64.54 100.44,64.64 v1(100.44,64.92)
  IN3 w0.094: v3(160.98,54.22) 160.76,54.45 160.76,55.72 160.52,55.96 159.95,55.96 159.71,55.72 159.71,54.99 159.59,54.86 159.33,54.86 159.21,54.99 159.21,55.36 158.97,55.6 158.55,55.6 158.32,55.36 158.32,53.88 158.22,53.79 157.94,53.79 157.85,53.88 157.85,54.73 157.61,54.97 157.23,54.97 157,54.73 157,53.88 156.9,53.79 156.62,53.79 156.53,53.88 156.53,54.68 156.29,54.92 155.91,54.92 155.67,54.68 155.67,53.88 155.58,53.79 155.3,53.79 155.2,53.88 155.2,54.38 154.94,54.65 150.64,54.65 150.55,54.74 142.41,54.74 141.56,55.58 136.68,55.58 135.98,56.29 133.16,56.29 132.62,55.74 123.87,55.74 123.53,55.4 122.57,55.4 122.4,55.56 122.27,55.7 122.27,56.56 121.01,57.82 119.1,57.82 118.97,57.94 118.97,58.16 119.1,58.29 120.27,58.29 120.51,58.52 120.51,59.01 120.27,59.25 119.25,59.25 119.16,59.33 119.16,59.82 118.52,60.46 114.89,60.46 110.13,65.22 104.49,65.22
  BOTTOM w0.099: v3(160.98,54.22) 160.69,53.93 160.69,53.59 160.49,53.39 158.63,53.39 158.44,53.2 JDIMM4.102
M_CLK_DDR4: length 66.7
  TOP w0.089: JCPU1.AB4 96.9,62.45 96.46,62.01 v1(96.4,62.01)
  TOP w0.099: JDIMM1.101 142.11,52.9 141.92,53.09 141.85,53.09 141.64,52.88 138.42,52.88 138.08,53.22 137.93,53.22 137.83,53.11 137.83,52.96 137.96,52.83 137.96,52.73 v1(138.27,52.42)
  IN1 w0.089: 99.73,61.55 99.71,61.55 99.7,61.54 99.64,61.54 99.63,61.52 99,61.52 98.81,61.34 98.81,60.75 98.38,60.32 98.38,60.06 98.28,59.96 98.1,59.96 98.04,60.02 98.04,60.31 97.83,60.52 97.1,60.52 97,60.61 97,61.43 96.84,61.6 96.53,61.6 96.47,61.54 96.26,61.54 96.2,61.6 96.2,61.88 96.33,62.01 v1(96.4,62.01)
  IN1 w0.109: 99.73,61.55 99.84,61.55 99.93,61.63 99.93,61.85 100.13,62.06 101.13,62.06 101.37,61.82 101.37,61.2 101.49,61.07 101.78,61.07 101.91,61.21 101.91,61.82 102.15,62.06 102.69,62.06 102.91,61.84 102.91,61.18 103,61.08 103.3,61.08 103.36,61.15 103.36,61.33 103.56,61.52 104.02,61.52 104.21,61.34 113.43,61.34 113.63,61.14 113.63,60.86 114.16,60.33 114.27,60.33 114.63,60.69 115.2,60.69 115.45,60.43 115.45,60.07 115.2,59.81 115.01,59.81 114.91,59.71 114.91,59.57 116.43,58.05 116.8,58.05 117.64,57.22 117.64,56.85 117.95,56.54 118.03,56.54 118.09,56.6 118.09,56.77 118.09,56.95 118.28,57.15 118.73,57.15 119.01,56.87 119.01,56.62 119.09,56.54 119.28,56.54 119.49,56.33 120.14,56.33 120.37,56.1 120.37,55.45 120.69,55.13 121.77,55.13 122.1,54.79 122.77,54.79 123.04,54.52 123.04,53.86 123.27,53.63 123.54,53.63 123.91,53.26 123.91,52.99 124.01,52.89 125.57,52.89 125.82,52.63 125.82,52.5 125.95,52.37 126.24,52.37 126.37,52.5 126.37,52.63 126.62,52.89 127.1,52.89 127.36,52.63 127.36,52.5 127.49,52.37 127.78,52.37 127.91,52.5 127.91,52.63 128.16,52.89 128.75,52.89 129.01,52.63 129.01,52.5 129.13,52.37 129.47,52.37 129.59,52.5 129.59,52.67 129.81,52.89 132.99,52.89 133.05,52.95 133.05,53.02 133.25,53.22 133.81,53.22 134.03,53 134.03,52.75 134.16,52.62 134.46,52.62 134.59,52.75 134.59,52.96 134.85,53.22 135.38,53.22 135.64,52.96 135.64,52.75 135.77,52.62 135.98,52.62 136.11,52.75 136.11,53.02 136.31,53.22 137.82,53.22 138.08,52.96 138.08,52.61 v1(138.27,52.42)
M_CLK_DDR5: length 65.8
  TOP w0.089: JCPU1.AB3 97.9,62.41 97.41,61.93 v3(97.4,61.93)
  TOP w0.099: v1(129.46,53.32) 129.25,53.54 129.25,53.72 129.32,53.8 132.45,53.8 132.79,53.45 133.68,53.45 133.93,53.2 JDIMM1.102
  IN1 w0.089: 103.03,62.41 102.99,62.46 100.93,62.46 100.87,62.52 99.65,62.52 99.64,62.53 99.31,62.53 99.14,62.53 99.13,62.52 98.15,62.52 98.14,62.51 97.8,62.17 97.8,62.17 97.79,62.16 97.79,61.65 97.72,61.58 97.51,61.58 97.4,61.69 v3(97.4,61.93)
  IN1 w0.109: v1(129.46,53.32) 129.34,53.32 128.49,54.18 127.79,54.18 127.5,53.88 127.09,53.88 126.8,54.18 124.96,54.18 124.77,53.98 124.14,53.98 124.06,54.07 124.06,54.28 124.18,54.41 124.4,54.41 124.68,54.7 124.68,55.11 124.36,55.43 122.4,55.43 122.07,55.77 121.13,55.77 121,55.89 121,56.06 121.13,56.19 121.8,56.19 122.06,56.45 122.06,56.84 121.8,57.1 121.11,57.1 121.03,57.18 121.03,57.74 120.77,57.99 120.35,57.99 120.09,57.74 120.09,57.09 119.97,56.96 119.76,56.96 119.63,57.09 119.63,57.51 119.4,57.74 119.16,57.74 119.07,57.84 119.07,58.44 119.17,58.55 119.48,58.55 119.63,58.4 120.25,58.4 120.5,58.65 120.5,59.12 120.25,59.38 119.87,59.38 119.81,59.44 119.81,59.79 119.6,60 119.02,60 118.94,60.09 118.94,60.81 118.7,61.05 118.18,61.05 117.97,60.84 117.97,60.46 117.85,60.34 117.63,60.34 117.5,60.46 117.5,60.74 117.24,60.99 116.87,60.99 116.61,60.74 116.61,60.64 116.48,60.51 116.2,60.51 116.08,60.64 116.08,61.73 116.2,61.85 116.93,61.85 117.19,62.11 117.19,62.61 116.93,62.86 114.96,62.86 114.7,62.61 114.7,61.46 114.57,61.33 114.34,61.33 114.21,61.46 114.21,62.61 113.95,62.86 113.41,62.86 113.16,62.61 113.16,62.1 113.03,61.97 112.69,61.97 112.56,62.1 112.56,63.47 112.3,63.73 111.76,63.73 111.51,63.47 111.51,62.1 111.38,61.97 104.15,61.97 103.71,62.41 103.03,62.41
M_CLK_DDR6: length 83.1
  TOP w0.089: v1(98.39,61.91) 98.47,61.91 98.9,62.34 JCPU1.AB2
  TOP w0.099: JDIMM3.101 158.32,52.9 158.55,53.12 160.3,53.12 160.51,52.91 160.51,52.75 v3(160.19,52.43)
  IN3 w0.089: 104.49,62.72 102.96,62.72 100.76,60.52 99.15,60.52 99,60.67 99,61.31 98.79,61.52 98.31,61.52 98.19,61.63 98.19,61.8 98.31,61.91 v1(98.39,61.91)
  IN3 w0.094: v3(160.19,52.43) 160.45,52.43 160.53,52.35 160.53,51.21 160.4,51.08 159.1,51.08 158.98,51.21 158.98,52.96 158.74,53.2 158.36,53.2 158.13,52.96 158.13,50.86 158,50.74 157.78,50.74 157.66,50.86 157.66,52.96 157.42,53.2 157.04,53.2 156.81,52.96 156.81,52.77 156.71,52.68 152.99,52.68 152.3,51.99 142.63,51.99 141.44,53.19 136.64,53.19 135.67,52.22 132.5,52.22 131.83,52.89 122.46,52.89 121.39,53.96 121.01,53.96 120.37,54.61 119.59,54.61 118.38,55.81 116.41,55.81 109.51,62.72 104.49,62.72
M_CLK_DDR7: length 81.5
  TOP w0.089: JCPU1.AA1 99.9,61.42 v1(99.4,60.92)
  TOP w0.099: JDIMM3.102 150.1,53.2 150.29,53.01 150.29,52.6 150.59,52.3 152.06,52.3 152.33,52.58 152.33,52.79 v1(152.68,53.14)
  IN3 w0.089: 104.49,63.11 102.95,63.11 101.18,61.35 99.66,61.35 99.4,61.09 v1(99.4,60.92)
  IN3 w0.094: v1(152.68,53.14) 152.6,53.14 152.47,53.01 152.47,52.73 152.14,52.4 149.27,52.4 148.98,52.7 148.98,53.24 148.85,53.37 148.63,53.37 148.51,53.24 148.51,52.63 148.27,52.39 147.89,52.39 147.65,52.63 147.65,52.98 147.53,53.11 147.31,53.11 147.18,52.98 147.18,52.64 146.95,52.4 142.9,52.4 142.67,52.63 142.67,53.21 142.58,53.3 141.89,53.3 141.61,53.58 136.12,53.58 136.03,53.49 136.03,53.14 135.79,52.9 135.42,52.9 135.18,53.14 135.18,53.46 135.05,53.58 134.83,53.58 134.71,53.46 134.71,52.86 134.47,52.62 134.09,52.62 133.86,52.86 133.86,53.65 133.73,53.78 133.49,53.78 133.36,53.65 133.36,52.86 133.12,52.62 132.72,52.62 132.48,52.86 132.48,53.66 132.37,53.77 124.5,53.77 124.09,53.37 122.62,53.37 122.38,53.6 122.38,53.83 122.33,53.88 122.04,53.88 121.56,54.36 121.18,54.36 120.9,54.64 120.9,55.87 120.77,55.99 120.5,55.99 120.37,55.87 120.37,55.24 120.13,55 119.75,55 119.52,55.24 119.52,56.04 119.35,56.21 117.26,56.21 116.98,56.49 116.98,56.75 116.82,56.9 116.64,56.9 116.41,56.67 116.12,56.67 115.81,56.98 115.81,57.27 115.98,57.44 115.98,57.62 115.83,57.78 115.65,57.78 115.48,57.6 115.18,57.6 114.87,57.91 114.87,58.2 114.95,58.28 114.95,58.46 114.8,58.61 114.62,58.61 114.54,58.54 114.25,58.54 113.94,58.85 113.94,59.14 114.01,59.21 114.01,59.39 113.86,59.55 113.68,59.55 113.63,59.49 113.29,59.49 113.03,59.76 113.03,60.1 113.08,60.15 113.08,60.33 112.93,60.48 112.75,60.48 112.67,60.41 112.38,60.41 112.07,60.72 112.07,61.01 112.15,61.08 112.15,61.26 111.99,61.41 111.81,61.41 111.76,61.36 111.42,61.36 111.16,61.63 111.16,61.96 111.21,62.02 111.21,62.2 111.06,62.35 110.88,62.35 110.84,62.31 110.5,62.31 110.17,62.63 110.17,62.97 110.25,63.05 110.25,63.16 110.16,63.25 109.33,63.25 109.15,63.43 109.15,63.7 109.02,63.82 108.73,63.82 108.6,63.7 108.6,63.35 108.36,63.11 107.99,63.11 107.75,63.35 107.75,63.7 107.62,63.82 107.4,63.82 107.28,63.7 107.28,63.32 107.07,63.11 106.63,63.11 106.43,63.32 106.43,63.7 106.3,63.82 106.08,63.82 105.96,63.7 105.96,63.35 105.72,63.11 104.49,63.11
M_CLK_DDR#0: length 69.8
  TOP w0.089: JCPU1.AA6 94.9,61.43 v1(94.4,60.92)
  IN1 w0.089: v1(94.4,60.92) 94.39,60.92 94.22,61.09 94.22,61.26 94.35,61.39 94.48,61.39 94.81,61.07 94.81,60.54 95.02,60.33 95.67,60.33 96,60.66 96,62.18 96.23,62.41 97.08,62.41 97.16,62.33 97.65,62.33 97.99,62.67 97.99,63.15 98.17,63.33 101.21,63.33 101.27,63.39
  IN1 w0.109: 101.27,63.39 101.27,63.39 101.47,63.39 101.71,63.63 101.71,64.24 101.83,64.37 102.13,64.37 102.25,64.24 102.25,62.92 102.51,62.66 102.99,62.66 103.25,62.92 103.25,64.24 103.37,64.37 103.67,64.37 103.79,64.24 103.79,62.65 104.05,62.39 104.59,62.39 104.85,62.65 104.85,64.02 104.97,64.14 105.35,64.14 105.48,64.02 105.48,62.67 105.72,62.43 106.23,62.43 106.47,62.67 106.47,64.02 106.6,64.14 106.89,64.14 107.02,64.02 107.02,62.67 107.26,62.43 107.77,62.43 108.01,62.67 108.01,64.02 108.14,64.14 108.43,64.14 108.56,64.02 108.56,62.67 108.8,62.43 109.31,62.43 109.55,62.67 109.55,64.02 109.68,64.14 109.97,64.14 110.1,64.02 110.1,62.85 110.36,62.59 110.83,62.59 111.09,62.85 111.09,64.02 111.22,64.14 112.47,64.14 113.34,63.28 117.11,63.28 125.79,54.59 128.71,54.59 129.46,53.84 130.47,53.84 130.78,53.53 130.78,53.37 v3(130.73,53.32)
  BOTTOM w0.099: JDIMM2.103 133.74,53.5 133.53,53.29 133.27,53.29 132.24,54.32 131.16,54.32 130.88,54.04 130.88,53.48 130.73,53.32 v3(130.73,53.32)
