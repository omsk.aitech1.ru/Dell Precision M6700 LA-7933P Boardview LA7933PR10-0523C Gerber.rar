# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_NVR_PRX_DTX_P2: length 2.8
  TOP w0.102: C447.2 32.62,144.29 v1(32.62,144.68) 32.62,144.83 32.21,145.25 32.21,145.38 32.32,145.5 U12.24
SATA_NVR_PTX_DRX_N2: length 2.8
  TOP w0.102: C445.2 30.73,144.15 30.73,144.26 31.27,144.8 v1(31.27,144.96) 31.27,145.59 31.32,145.65 U12.22
SATA_NVR_PTX_DRX_P2: length 2.8
  TOP w0.102: U12.21 30.82,145.66 31,145.48 31,144.91 30.47,144.37 30.47,144.19 C446.2
SATA_NVRAM_PRX_DTX_N2_C: length 64.8
  TOP w0.102: C448.1 32.11,142.84 32.11,142.39 32,142.29 32,141.74 32.25,141.49 v3(32.84,141.49) ; v1(29.68,107.73) 29.33,107.38 UH4.AD7
  IN3 w0.102: 22.73,129.34 22.73,127.88 23.13,127.48 23.13,122.61 23.2,122.53 23.2,122.09 22.85,121.73 22.85,120.98 24.06,119.76 24.06,119.2 25.25,118.02 25.25,117.4 26.76,115.89 27.48,115.89 27.71,115.66 27.71,113.26 28.18,112.79 29.03,112.79 29.37,112.45 29.37,112.12 29.03,111.77 29.03,110.16 29.82,109.37 29.82,107.87 v1(29.68,107.73)
  IN3 w0.127: 22.73,129.34 22.72,129.35 22.72,130.05 21.45,131.32 20.42,131.32 19.1,132.64 19.1,135.54 18.83,135.8 18.83,138.21 20.22,139.6 20.22,140.58 25.94,146.3 27.08,146.3 27.62,146.84 31.46,146.84 32.73,145.57 32.73,144.21 34.4,142.53 34.4,141.87 33.81,141.28 33.27,141.28 33.06,141.49 v3(32.84,141.49)
SATA_NVRAM_PRX_DTX_P2_C: length 64.7
  TOP w0.102: C447.1 32.63,142.85 32.56,142.77 32.56,142.48 32.27,142.19 32.27,141.85 32.36,141.76 32.49,141.76 32.84,142.11 v1(32.84,142.13) ; v6(29.68,107.06) 29.68,106.91 29.52,106.75 UH4.AD5
  IN3 w0.102: 23.33,127.61 23.33,122.75 23.44,122.63 23.44,121.98 23.13,121.67 23.13,121.1 24.34,119.88 24.34,119.32 25.45,118.21 25.45,117.49 26.85,116.09 27.57,116.09 27.91,115.75 27.91,113.34 28.27,112.99 29.12,112.99 29.58,112.53 29.58,112.01 29.23,111.67 29.23,110.35 30.1,109.49 30.1,107.39 30.05,107.34 29.78,107.34 29.68,107.24 v6(29.68,107.06)
  IN3 w0.127: v1(32.84,142.13) 32.9,142.13 33.18,141.85 33.18,141.8 33.4,141.58 33.68,141.58 34.1,142 34.1,142.41 32.42,144.08 32.42,145.44 31.33,146.53 27.74,146.53 27.21,146 26.07,146 20.52,140.45 20.52,139.47 19.14,138.09 19.14,135.93 19.4,135.66 19.4,132.77 20.55,131.62 21.58,131.62 23.02,130.17 23.02,127.91 23.33,127.61
SATA_NVRAM_PTX_DRX_N2_C: length 58.8
  TOP w0.102: v1(30.64,107.15) 30.67,107.15 31.07,106.75 UH4.AH5 ; v1(30.88,142.14) 30.71,142.32 30.71,142.46 C445.1
  IN3 w0.102: v1(30.64,107.15) 31.05,107.56 31.05,111.21 30.64,111.62 30.11,111.62 29.88,111.85 29.88,112.7 29.3,113.28 28.62,113.28 28.28,113.63 28.28,116.07 27.84,116.51 26.94,116.51 25.84,117.6 25.84,118.5 24.92,119.43 24.92,120.37 25.3,120.75 25.3,123.15 24.93,123.52 24.66,123.52 24.14,124.04 24.14,125.83 23.91,126.06 23.91,127.46 23.71,127.66 23.71,129.31
  IN3 w0.127: 23.71,129.31 23.67,129.35 23.67,131.34 22.88,132.13 20.76,132.13 19.91,132.98 19.91,135.9 20.22,136.21 20.22,138.15 27.1,145.03 27.3,145.03 28.24,145.97 30.99,145.97 31.47,145.49 31.47,144.18 30.88,143.6 v1(30.88,142.14)
SATA_NVRAM_PTX_DRX_P2_C: length 58.8
  TOP w0.102: v3(30.25,142.14) 30.44,142.33 30.44,142.48 C446.1 ; UH4.AH4 30.99,106.11 v1(30.63,106.48)
  IN3 w0.102: 23.98,129.46 24,129.43 24,129.19 23.99,129.18 23.99,127.78 24.14,127.62 24.14,126.12 24.34,125.92 24.34,124.13 24.74,123.74 25.06,123.74 25.58,123.22 25.58,120.64 25.2,120.26 25.2,119.51 26.05,118.66 26.05,117.69 27.02,116.71 27.93,116.71 28.48,116.15 28.48,113.72 28.71,113.49 29.39,113.49 30.08,112.79 30.08,112.07 30.25,111.9 30.76,111.9 31.25,111.41 31.25,107.37 31.06,107.18 31.06,106.87 30.94,106.74 30.69,106.74 30.63,106.68 v1(30.63,106.48)
  IN3 w0.127: v3(30.25,142.14) 30.58,142.47 30.58,143.73 31.16,144.31 31.16,145.36 30.86,145.67 28.37,145.67 27.43,144.73 27.23,144.73 20.52,138.02 20.52,136.08 20.22,135.78 20.22,133.11 20.89,132.44 23.01,132.44 23.98,131.47 23.98,129.46
SATA_ODD_PRX_DTX_N3: length 2.9
  TOP w0.102: C432.1 26.31,36.15 25.88,36.15 25.48,36.55 JODD1.5
SATA_ODD_PRX_DTX_N3_C: length 106.4
  TOP w0.102: UH4.AB8 28.18,108.17 28.48,108.47 v1(28.68,108.47) ; C432.2 27.75,36.2 27.9,36.06 28.45,36.06 v3(28.71,36.32)
  IN3 w0.102: 28.61,102.99 28.61,103 28.6,103.02 28.6,103.68 28.21,104.08 28.21,104.7 28.27,104.76 28.27,108.66 28.36,108.75 28.48,108.75 28.68,108.56 v1(28.68,108.47)
  IN3 w0.127: 28.61,102.99 28.61,100.81 26.95,99.15 26.95,98.86 26.82,98.73 26.82,98.25 26.45,97.88 24.37,97.88 22.98,96.49 21.22,96.49 19.8,95.07 18.01,95.07 17.38,94.45 17.38,94.08 15.43,92.13 15.43,85.8 v1(15.66,85.57)
  IN4 w0.117: v3(28.71,36.32) 28.71,36.31 28.38,35.97 27.92,35.97 27.45,36.44 27.45,39.33 26.81,39.97 26.81,49.44 25.13,51.12 25.13,56.08 21.93,59.28 9.74,59.28 8.51,60.51 8.51,78.08 9.13,78.7 13.66,78.7 15.42,80.46 15.42,85.34 v1(15.66,85.57)
SATA_ODD_PRX_DTX_P3: length 3
  TOP w0.102: C430.1 26.29,35.88 25.98,35.88 25.38,35.28 JODD1.6
SATA_ODD_PRX_DTX_P3_C: length 106.4
  TOP w0.102: UH4.AB10 28.21,108.65 v1(28.68,109.12) ; C430.2 28.17,35.79 28.61,35.79 v1(28.71,35.69)
  IN3 w0.102: 28.31,102.99 28.32,103 28.32,103.65 27.93,104.04 27.93,104.81 28.07,104.95 28.07,108.75 28.31,108.99 28.55,108.99 v1(28.68,109.12)
  IN3 w0.127: v3(15.02,85.57) 15.12,85.67 15.12,92.25 17.08,94.21 17.08,94.58 17.88,95.38 19.68,95.38 21.09,96.79 22.85,96.79 24.24,98.18 26.32,98.18 26.52,98.37 26.52,98.86 26.64,98.98 26.64,99.28 28.31,100.94 28.31,102.99
  IN4 w0.117: v3(15.02,85.57) 15.14,85.46 15.14,80.58 13.54,78.98 9.02,78.98 8.23,78.19 8.23,60.39 9.63,58.99 21.82,58.99 24.84,55.96 24.84,51 26.52,49.32 26.52,39.85 27.17,39.21 27.17,36.33 27.8,35.69 v1(28.71,35.69)
SATA_ODD_PTX_DRX_N3: length 3
  TOP w0.102: C434.1 26.3,39.68 26.15,39.68 25.56,39.09 JODD1.3
SATA_ODD_PTX_DRX_N3_C: length 96.3
  TOP w0.102: C434.2 28.22,39.65 28.54,39.65 v3(28.7,39.48) ; UH4.AF3 30.05,105.31 30.05,104.87 29.86,104.69 29.86,104.33 30.19,104.01 30.19,103.5 v1(30.79,102.9)
  IN3 w0.127: v1(17.11,81.6) 16.94,81.43 16.78,81.43 16.66,81.54 16.66,86.55 16.48,86.73 16.48,92.03 17.63,93.17 18.54,93.17 19.61,94.23 20.28,94.23 21.7,95.65 23.6,95.65 25.01,97.06 27.58,97.06 28.18,97.66 28.18,98.87 28.42,99.11 28.42,99.43 30.52,101.53 30.52,102.77 30.66,102.9 v1(30.79,102.9)
  IN4 w0.117: v1(17.11,81.6) 16.85,81.34 16.39,81.34 16.09,81.03 16.09,80.34 9.24,73.5 9.24,62.42 11.78,59.88 22.06,59.88 25.63,56.31 25.63,51.36 28.53,48.46 28.53,41.24 27.82,40.53 27.82,39.98 28.18,39.62 28.57,39.62 v3(28.7,39.48)
SATA_ODD_PTX_DRX_P3: length 2.9
  TOP w0.102: C433.1 26.3,39.95 25.67,39.95 25.26,40.36 JODD1.2
SATA_ODD_PTX_DRX_P3_C: length 96.4
  TOP w0.102: C433.2 28.29,39.91 28.56,39.91 28.7,40.06 v3(28.7,40.12) ; UH4.AF1 30.17,104.7 30.29,104.82 30.37,104.82 30.57,104.62 30.78,104.62 30.85,104.55 30.85,104.34 30.79,104.28 30.4,104.28 30.34,104.22 30.34,104.15 30.39,104.1 30.39,103.62 30.47,103.54 v1(30.79,103.54)
  IN3 w0.127: v1(30.79,103.54) 30.22,102.97 30.22,101.66 28.12,99.56 28.12,99.24 27.87,99 27.87,97.79 27.45,97.37 24.89,97.37 23.47,95.96 21.57,95.96 20.15,94.54 19.48,94.54 18.41,93.47 17.5,93.47 16.18,92.15 16.18,86.6 16.36,86.42 16.36,81.42 16.65,81.13 16.93,81.13 17.09,80.96 v1(17.11,80.96)
  IN4 w0.117: v3(28.7,40.12) 28.49,39.91 28.3,39.91 28.11,40.09 28.11,40.42 28.81,41.12 28.81,48.58 25.91,51.48 25.91,56.43 22.18,60.17 11.9,60.17 9.53,62.54 9.53,73.38 16.37,80.22 16.37,80.91 16.51,81.05 17.01,81.05 v1(17.11,80.96)
SATA_PRX_DKTX_N5: length 7.2
  BOTTOM w0.102: JDOCK1.56 96.24,127.57 96.12,127.69 96.12,128.21 95.25,129.08 94.73,129.08 v1(93.98,129.83) 93.2,130.61 93.2,131.8 C698.2
SATA_PRX_DKTX_N5_C: length 116.4
  TOP w0.102: v1(27.53,103.85) 27.54,103.86 27.54,104.65 27.19,105 UH4.Y3
  IN1 w0.102: 32.45,104.78 32.36,104.87 28.24,104.87 27.91,104.53 27.91,103.92 27.84,103.85 v1(27.53,103.85)
  IN1 w0.117: 32.45,104.78 32.55,104.67 36.97,104.67 38.29,103.35 38.7,103.35 39.58,102.48 39.58,101.9 39.92,101.55 40.41,101.55 41.74,100.22 46.92,100.22 47.35,99.79 55.01,99.79 55.83,98.97 61.28,98.97 62.41,100.09 65.21,100.09 66,100.88 68.6,100.88 69.25,101.53 70.53,101.53 72.43,103.43 72.73,103.43 74.72,105.42 76.88,105.42 77.35,104.95 85.36,104.95 88.17,107.76 88.17,108.63 89.01,109.47 89.01,110.15 91.53,112.67 95.51,112.67 96.95,114.1 96.95,115.84 98,116.89 99.05,116.89 99.34,116.6 99.34,116.26 99.34,116.26 v1(99.45,116.15)
  IN3 w0.127: v1(99.45,116.15) 99.45,117.64 100.6,118.78 100.6,122.24 101.06,122.71 101.66,122.71 102.26,123.31 102.26,126.2 97.79,130.67 94.35,130.67 93.38,131.64 v3(93.38,135.38)
  BOTTOM w0.102: C698.1 93.2,133.5 93.2,135.21 93.37,135.38 v3(93.38,135.38)
SATA_PRX_DKTX_P5: length 7.2
  BOTTOM w0.102: JDOCK1.54 95.74,127.71 95.86,127.83 95.86,128.1 95.14,128.81 94.62,128.81 92.93,130.5 v1(92.93,131.2) 92.93,131.8 C697.2
SATA_PRX_DKTX_P5_C: length 116.4
  TOP w0.102: v1(27.84,103.25) 27.81,103.25 27.8,103.26 27.44,103.26 27.06,103.65 27.06,104.41 UH4.Y1
  IN1 w0.102: 32.25,104.57 32.16,104.66 28.42,104.66 28.18,104.42 28.18,103.78
  IN1 w0.117: v3(98.82,116.15) 98.82,116.15 99.03,116.35 99.05,116.38 99.05,116.48 98.93,116.61 98.11,116.61 97.23,115.72 97.23,113.98 95.63,112.39 91.65,112.39 89.3,110.03 89.3,109.35 88.46,108.51 88.46,107.64 85.48,104.67 77.24,104.67 76.76,105.14 74.84,105.14 72.85,103.15 72.55,103.15 70.65,101.24 69.37,101.24 68.71,100.59 66.12,100.59 65.33,99.8 62.52,99.8 61.4,98.68 55.71,98.68 54.89,99.51 47.23,99.51 46.8,99.94 41.62,99.94 40.29,101.27 39.81,101.27 39.29,101.78 39.29,102.36 38.58,103.07 38.17,103.07 36.85,104.39 32.43,104.39 32.25,104.57 ; v1(27.84,103.25) 27.84,103.44 28.18,103.78
  IN3 w0.127: v1(92.75,135.38) 93.08,135.05 93.08,131.51 94.22,130.37 97.66,130.37 101.95,126.07 101.95,123.43 101.53,123.01 100.94,123.01 100.29,122.37 100.29,118.91 99.15,117.77 99.15,116.48 v3(98.82,116.15)
  BOTTOM w0.102: C697.1 92.93,133.5 92.93,135.2 v1(92.75,135.38)
SATA_PRX_DTX_N0: length 3.4
  TOP w0.102: JSATA1.5 201.9,40.99 v3(202.24,41.33)
  BOTTOM w0.102: C385.1 203.09,41.59 202.49,41.59 v3(202.24,41.33)
SATA_PRX_DTX_N1: length 3.3
  TOP w0.102: JSATA2.5 69.08,33.72 69.56,34.2 69.56,34.78 C414.1
SATA_PRX_DTX_N1_C: length 108.9
  TOP w0.102: UH4.AM10 32.96,108.65 v1(32.66,108.95) ; v3(69.13,36.81) 69.23,36.81 69.53,36.5 69.53,36.3 69.33,36.1 C414.2
  IN1 w0.117: v3(69.13,36.81) 69.13,36.97 69.26,37.1 69.49,37.1 69.57,37.02 69.57,36.04 69.27,35.74 64.59,35.74 63.35,36.98 63.35,39.95 61.11,42.19 61.11,43.55 58.46,46.2 58.46,67.57 59.75,68.86 59.75,72.95 60.12,73.32 60.12,82.75 63.1,85.73 63.1,89.07 60.14,92.03 56.26,92.03 55.73,91.5 55.41,91.5 54.33,92.58 53.22,92.58 52.97,92.82 49.64,92.82 48.9,93.57 45.96,93.57 45.35,94.18 43.82,94.18 43.48,94.51 43.48,94.97 43.56,95.05 v1(43.67,95.05)
  IN4 w0.102: v1(32.66,108.95) 32.8,108.82 33.27,108.82 33.73,108.35 33.73,104.95 35.43,103.25
  IN4 w0.117: v1(43.67,95.05) 43.52,95.2 43.52,95.58 43.19,95.91 42.54,95.91 39.85,98.61 38.97,98.61 35.43,102.14 35.43,103.25
SATA_PRX_DTX_N4: length 3.5
  TOP w0.102: C673.2 13.66,167.26 13.66,167.77 12.76,168.67 12.76,169.22 JESA1.9
SATA_PRX_DTX_P0: length 3.4
  TOP w0.102: JSATA1.6 201.94,42.26 v1(202.24,41.96)
  BOTTOM w0.102: v1(202.24,41.96) 202.35,41.85 203.09,41.85 C386.1
SATA_PRX_DTX_P1: length 3.4
  TOP w0.102: JSATA2.6 70.35,33.64 69.82,34.16 69.82,34.77 C412.1
SATA_PRX_DTX_P1_C: length 108.9
  TOP w0.102: UH4.AM8 32.91,108.02 v1(32.65,108.28) ; v1(70.01,36.81) 69.8,36.59 69.8,36.22 69.92,36.1 C412.2
  IN1 w0.117: v1(70.01,36.81) 69.86,36.65 69.86,35.93 69.39,35.45 64.47,35.45 63.06,36.87 63.06,39.84 60.83,42.07 60.83,43.44 58.18,46.09 58.18,67.68 59.47,68.98 59.47,73.07 59.84,73.44 59.84,82.87 62.81,85.85 62.81,88.95 60.02,91.75 56.37,91.75 55.85,91.22 55.29,91.22 54.21,92.3 53.1,92.3 52.86,92.54 49.52,92.54 48.78,93.28 45.85,93.28 45.23,93.89 43.7,93.89 43.2,94.4 43.2,94.85 v3(43.04,95.01)
  IN4 w0.102: v1(32.65,108.28) 32.59,108.28 32.52,108.34 32.52,108.45 32.62,108.55 33.16,108.55 33.46,108.24 33.46,104.84 35.09,103.21 35.09,103.2 35.15,103.14
  IN4 w0.117: v3(43.04,95.01) 43.24,95.21 43.24,95.46 43.07,95.63 42.43,95.63 39.73,98.32 38.85,98.32 35.15,102.02 35.15,103.14
SATA_PRX_DTX_P4: length 3.6
  TOP w0.102: JESA1.10 13.03,169.22 13.03,168.78 13.93,167.88 13.93,167.3 C674.2
SATA_PTX_DKRX_N5: length 6.7
  BOTTOM w0.102: JDOCK1.62 97.74,127.72 97.65,127.81 97.65,128.4 v1(96.1,129.95) 95.23,130.82 95.23,131.8 C700.1
SATA_PTX_DKRX_N5_C: length 117.8
  TOP w0.102: UH4.AB3 28.18,105 27.88,104.7 27.88,104.06 28.03,103.91 28.03,103.64 28.37,103.29 28.37,102.47 28.76,102.08 29.31,102.08 v1(29.48,101.92)
  IN1 w0.117: v1(29.48,101.92) 31.34,101.92 32.89,103.47 35.51,103.47 38.49,100.48 39.97,100.48 41.3,99.15 46.34,99.15 46.77,98.72 54.08,98.72 55.37,97.43 56.77,97.43 57,97.21 61.06,97.21 62.83,98.98 65.67,98.98 66.09,99.4 69.73,99.4 70.52,100.19 70.71,100.19 72.55,102.03 72.95,102.03 74.81,103.88 86.12,103.88 91.67,109.43 91.67,110.61 92.67,111.6 95.96,111.6 97.43,113.08 99.31,113.08 100.76,114.53 v1(100.76,116.19)
  IN3 w0.127: v1(100.76,116.19) 100.76,117.6 101.67,118.52 101.67,120.12 103.14,121.58 103.14,124.8 103.91,125.58 103.91,128.73 100.86,131.78 96.35,131.78 95.41,132.72 v3(95.41,135.46)
  BOTTOM w0.102: C700.2 95.41,133.32 v3(95.41,135.46)
SATA_PTX_DKRX_P5: length 6.7
  BOTTOM w0.102: JDOCK1.60 97.24,127.7 97.38,127.84 97.38,128.29 94.96,130.71 v1(94.96,131.17) 94.96,131.8 C699.1
SATA_PTX_DKRX_P5_C: length 117.8
  TOP w0.102: v1(29.77,102.49) 29.77,102.39 29.73,102.35 28.87,102.35 28.64,102.58 28.64,103.4 28.29,103.75 28.29,104.02 28.15,104.17 28.15,104.5 UH4.AB1
  IN1 w0.117: v3(100.13,116.19) 100.13,116.19 100.48,115.84 100.48,114.65 99.19,113.37 97.32,113.37 95.84,111.89 92.55,111.89 91.39,110.73 91.39,109.55 86,104.17 74.69,104.17 72.84,102.31 72.43,102.31 70.59,100.48 70.4,100.48 69.61,99.68 65.97,99.68 65.56,99.26 62.72,99.26 60.94,97.49 57.12,97.49 56.89,97.72 55.49,97.72 54.2,99.01 46.89,99.01 46.46,99.44 41.41,99.44 40.09,100.77 38.61,100.77 35.63,103.75 32.77,103.75 31.22,102.2 29.81,102.2 29.77,102.25 v1(29.77,102.49)
  IN3 w0.127: v1(94.72,135.37) 94.85,135.37 95.11,135.12 95.11,132.59 96.23,131.47 100.74,131.47 103.61,128.6 103.61,125.7 102.83,124.93 102.83,121.7 101.37,120.24 101.37,118.64 100.46,117.73 100.46,116.52 100.13,116.19 v3(100.13,116.19)
  BOTTOM w0.102: v1(94.72,135.37) 94.88,135.37 95.15,135.1 95.15,132.87 95.06,132.78 94.93,132.78 94.59,133.12 C699.2
SATA_PTX_DRX_N0: length 3.5
  TOP w0.102: JSATA1.3 201.78,38.45 202.25,37.98 202.37,37.98 v3(202.52,38.13)
  BOTTOM w0.102: v3(202.52,38.13) 202.63,38.01 203.05,38.01 C384.1
SATA_PTX_DRX_N1: length 3.4
  TOP w0.102: C411.1 66.34,35.15 66.03,34.84 66.03,34.54 66.15,34.42 66.26,34.42 66.54,34.15 JSATA2.3
SATA_PTX_DRX_N1_C: length 101.7
  TOP w0.102: UH4.AP11 34.31,109.29 v1(34.59,109.01) ; v3(66.17,36.86) 66.04,36.73 66.03,36.73 66,36.7 66,36.49 C411.2
  IN1 w0.089: 66,39.69 66,40.23 64.87,41.36
  IN1 w0.117: v3(66.17,36.86) 66,37.02 66,39.69 ; 64.87,41.36 64.58,41.66 64.58,44.63 62.02,47.19 62.02,67.4 62.57,67.96 62.57,73.3 64.82,75.55 64.82,77.97 64.64,78.15 64.64,83.39 64.01,84.02 64.01,91.45 63.38,92.08 61.42,92.08 60.56,92.94 55.43,92.94 54.86,93.51 53.7,93.51 53.45,93.76 50.16,93.76 49.83,94.09 49.83,94.25 v1(50.02,94.44)
  IN3 w0.102: 41.39,103.49 41.03,103.85 41.03,107.37 40.42,107.98 37.95,107.98 37.18,107.21 36.09,107.21 35.21,108.1 35.21,108.59 35,108.8 34.8,108.8 v1(34.59,109.01)
  IN3 w0.127: 41.39,103.49 42.45,102.43 42.45,101.7 43,101.15 45.84,101.15 48.12,98.87 48.54,98.87 49.95,97.46 49.95,96.32 49.88,96.25 49.88,94.58 v1(50.02,94.44)
SATA_PTX_DRX_N4: length 5.4
  TOP w0.102: C672.2 11.92,167.28 11.92,168.03 11.42,168.53 9.59,168.53 9.22,168.9 9.22,169.22 JESA1.7
SATA_PTX_DRX_P0: length 3.5
  TOP w0.102: v1(202.52,37.49) 202.34,37.67 202.22,37.67 201.73,37.18 JSATA1.2
  BOTTOM w0.102: v1(202.52,37.49) 202.73,37.71 203.16,37.71 C383.1
SATA_PTX_DRX_P1: length 3.5
  TOP w0.102: C413.1 65.4,35.15 65.76,34.78 65.76,34.56 65.75,34.55 65.68,34.47 65.49,34.47 65.27,34.25 JSATA2.2
SATA_PTX_DRX_P1_C: length 101.7
  TOP w0.102: UH4.AP10 34.29,108.65 v1(34.6,108.34) ; C413.2 65.73,36.45 65.73,36.65 v1(65.53,36.86)
  IN1 w0.117: v3(49.39,94.44) 49.55,94.28 49.55,93.97 50.04,93.48 53.33,93.48 53.58,93.23 54.74,93.23 55.32,92.65 60.44,92.65 61.31,91.79 63.27,91.79 63.72,91.34 63.72,83.91 64.36,83.27 64.36,78.03 64.53,77.85 64.53,75.67 62.29,73.42 62.29,68.08 61.73,67.52 61.73,47.07 64.29,44.51 64.29,41.54 65.72,40.12 65.72,37.04 v1(65.53,36.86)
  IN3 w0.102: v1(34.6,108.34) 34.53,108.41 34.53,108.55 34.58,108.6 34.9,108.6 35,108.5 35,107.9 35.97,106.93 37.3,106.93 38.14,107.77 40.23,107.77 40.75,107.25 40.75,103.73 41.17,103.31 41.17,103.28
  IN3 w0.127: v3(49.39,94.44) 49.49,94.44 49.58,94.53 49.58,96.38 49.64,96.44 49.64,97.33 48.41,98.57 47.99,98.57 45.71,100.85 42.88,100.85 42.15,101.58 42.15,102.3 41.17,103.28
SATA_PTX_DRX_P4: length 5.4
  TOP w0.102: JESA1.6 8.95,169.22 8.95,168.79 9.48,168.26 11.31,168.26 11.65,167.92 11.65,167.28 C671.2
SATA_REPEATER_EN: length 5.1
  BOTTOM w0.102: U26.7 214.32,85.4 v2(214.82,84.9) 214.87,84.85 215.47,84.85 C24.2 216.33,84.61 217.73,84.61 R85.1
SATA_SIDE_LED: length 263.4
  TOP w0.102: JIO1.88 35.06,19.75 v1(34.8,20.02)
  IN1 w0.109: v1(34.8,20.02) 34.35,19.57 31.99,19.57 31.55,19.13 31.55,14.97 37.46,9.06 104.44,9.06 106.49,11.1 107.61,11.1 108.73,12.22 109.38,12.22 110.37,13.21 111.62,13.21 114.29,15.88 117.3,15.88 119.41,13.78 127.02,13.78 128.18,12.62 131.28,12.62 131.91,13.25 150.3,13.25 152.7,15.65 155.82,15.65 159.02,12.45 169.62,12.45 v1(172.3,15.13)
  IN3 w0.127: v1(172.3,15.13) 172.3,19.41 166.8,24.91 166.8,34.51 167.43,35.14 167.43,40.46 173.75,46.78 179.64,46.78 180.64,45.78 185.42,45.78 187.62,47.98 187.62,49.53 188.37,50.28 191.05,50.28 194.2,53.43 201.5,53.43 209.13,61.06 219.09,61.06 221.11,59.04 223.94,59.04 224.11,59.21 225.89,59.21 226.39,58.71 v1(227.07,58.71)
  BOTTOM w0.102: v1(227.07,58.71) 227.18,58.71 228.23,59.77 228.23,61.03 R943.2 ; v1(34.8,20.02) v2(35.38,20.02)
SB#: length 20.9
  IN1 w0.109: v1(273.15,77.7) 273.15,81.7 276.76,85.31 280.72,85.31 281.28,84.75 v1(281.28,83.55)
  BOTTOM w0.102: Q338.2 280.44,83.51 280.64,83.31 281.04,83.31 v1(281.28,83.55) ; U2.8 275.32,77.93 v2(275.09,77.7) 274.55,77.7 274.29,77.95 R1626.2 273.48,78.58 273.15,78.26 v1(273.15,77.7)
SCLK: length 3.8
  TOP w0.102: PU702.5 24.05,78.99 23.94,78.88 v2(23.43,78.88) 23.23,78.88 v1(22.96,78.61) 22.52,79.06 PR722.2
  BOTTOM w0.102: v1(22.96,78.61) 22.74,78.61 PR737.1
SDA: length 5.2
  TOP w0.102: PU702.7 23.87,78.19 v1(23.48,77.8) 23.48,77.79 22.72,77.03 PR727.2
  BOTTOM w0.102: v1(23.48,77.8) 23.14,77.46 v2(23.14,77.15) 23.14,76.98 22.17,76.01 PR745.1
SEL: length 8.4
  BOTTOM w0.102: R1613.2 277.19,82.36 v2(276.82,81.99) U2.4 ; R1613.2 R1614.1 ; R1613.2 277.81,82.9 278.04,83.13 279.39,83.13 279.79,83.54 Q338.1
SIO_14M: length 5.2
  TOP w0.102: v1(19.72,127.64) 19.88,127.64 20.25,127.27 UH4.F47 ; v1(19,130.49) 19,131.05 18.64,131.41 RH313.2
  BOTTOM w0.102: v1(19,130.49) 19.34,130.15 v2(19.34,128.08) 19.34,128.02 v1(19.72,127.64)
SIO_A20GATE: length 245.8
  TOP w0.102: v1(172.96,149.38) U54.A45 ; v1(23.67,106.41) 23.67,106.4 23.96,106.11 UH4.P4
  IN2 w0.102: 16.36,109.44 17.52,109.44 18.15,108.81 19.46,108.81 19.48,108.83 21.09,108.83 21.12,108.8 22.8,108.8 23.05,108.55 23.05,107.29 23.1,107.24 23.1,106.99 23.67,106.42 v1(23.67,106.41)
  IN2 w0.127: 16.36,109.44 15.56,110.24 14.8,110.24 13.91,111.13 13.91,113.36 13.17,114.1 13.17,116.47 8.86,120.78 8.86,121.8 9.36,122.3 9.36,124.07 9.92,124.63 9.92,124.86 10.7,125.65 10.7,129.34 12.86,131.5 12.86,132.54 14.18,133.86 14.18,136.41 17.47,139.7 18.52,139.7 20.9,142.09 25.9,142.09 25.93,142.06 25.94,142.06 26.75,141.25 30.99,141.25 32.43,139.81 32.83,139.81 32.97,139.68 35.72,139.68 36.79,138.61 42.52,138.61 43.56,139.65 45.11,139.65 45.93,140.46 51.37,140.46 52.37,141.47 63.07,141.47 64.27,142.66 66.19,142.66 66.48,142.95 67.65,142.95 68.29,142.3 68.65,142.3 69.89,141.06 70.1,141.06 71.87,139.29 72.89,139.29 73.33,138.85 74.56,138.85 74.97,138.44 75.03,138.44 75.56,137.91 75.86,137.91 76.45,138.51 81.47,138.51 83.99,141.02 91.84,141.02 92.78,141.96 108.05,141.96 109.08,140.93 110.46,140.93 111.87,142.34 117.59,142.34 119.43,140.51 119.43,140.32 120.86,138.89 123.59,138.89 125,137.48 150.29,137.48 151.2,138.39 153.63,138.39 155.37,136.65 158.13,136.65 158.56,136.22 159.33,136.22 162.67,132.88 168.2,132.88 v1(171.42,129.65)
  IN4 w0.109: v1(22.2,102.01) 22.27,102.08 22.27,102.74 22.63,103.1 22.63,104.24 23.47,105.08 23.47,105.43 23.68,105.65 23.68,106.39 v1(23.67,106.41)
  BOTTOM w0.102: v1(172.96,149.38) 172.96,149.17 175.54,146.6 v2(175.54,144.48) 175.54,140.06 172.86,137.38 172.86,136.25 172.63,136.02 172.63,130.85 171.44,129.65 v1(171.42,129.65) ; v1(22.2,102.01) RH158.1
SIO_EXT_SCI#: length 224.3
  TOP w0.102: U54.A33 172.46,143.38 172.6,143.23 172.6,141.54 v1(172.78,141.36) ; v1(172.1,136.44) 172.07,136.41 172.01,136.41 171.22,135.62 171.22,135.44 170.98,135.2 170.98,116.33 176.86,110.45 176.86,107.16 175.39,105.68 175.39,97.17 175.77,96.79 v1(175.89,96.79) ; v1(27.02,93.4) 26.64,93.4 24.99,91.75 v1(24.95,91.75)
  IN1 w0.109: v1(172.78,141.36) 172.58,141.36 171.78,140.56 171.78,136.93 172.1,136.61 v1(172.1,136.44)
  IN2 w0.127: v1(169.91,96.75) 169.87,96.79 169.45,96.79 169.16,97.08 157.16,97.08 156.93,96.85 150.67,96.85 149.88,97.64 143.42,97.64 138.31,92.53 134.36,92.53 133.15,93.74 110.91,93.74 108.21,96.43 86.63,96.43 85.15,94.96 77.07,94.96 75.5,93.39 74.81,93.39 74.7,93.28 74.36,93.28 73.61,92.53 73.61,92.08 73.21,91.68 67.71,91.68 66.1,93.29 64.1,93.29 64.06,93.26 56.09,93.26 55.97,93.38 38.49,93.38 37.78,92.67 36.8,92.67 35.4,91.28 25.42,91.28 v1(24.95,91.75)
  IN3 w0.127: v1(169.91,96.75) 169.91,96.74 170.97,95.68 173.37,95.68 174.47,96.79 v1(175.89,96.79)
  BOTTOM w0.102: RH259.1 22.85,99.8 22.85,99.04 v2(23.37,98.51) 24.65,97.23 RH263.2 24.51,96.79 24.12,96.39 24.12,95.2 25.82,93.5 26.87,93.5 26.97,93.4 v1(27.02,93.4)
SIO_EXT_SCI#_R: length 65.5
  TOP w0.102: UH4.T7 24.84,107.01 v1(24.7,107.01)
  TOP w0.127: v1(74.83,98.03) 75.16,98.36 RH53.1
  IN2 w0.127: v1(74.83,98.03) 74.83,97.73 73.66,96.57 67.12,96.57 63.58,100.11 59.79,100.11 58.85,101.05 46.96,101.05 46.2,100.29 42.84,100.29 42.49,100.64 36.91,100.64 36.81,100.54 33.2,100.54 32.83,100.17 31.98,100.17 31.69,99.87 28.48,99.87 27.5,100.85 25.02,100.85 24.27,101.6 24,101.6 23.53,102.06 v1(23.53,102.17)
  IN4 w0.109: v1(23.53,102.17) 23.83,102.17 24.29,102.64 24.29,102.91 24.62,103.24 24.62,104.81 25.13,105.32 25.13,106.58 v1(24.7,107.01)
  BOTTOM w0.102: RH259.2 23.21,101.85 v1(23.53,102.17) ; v2(25.39,106.6) 24.98,107.01 v1(24.7,107.01)
SIO_EXT_SMI#: length 236.9
  TOP w0.102: 66.91,114.81 66.6,115.13 v1(66.6,115.37) ; 66.91,114.81 67.54,114.19 RH9.1 ; 66.91,114.81 v2(66.91,114.8) ; v1(6.59,111.32) 6.55,111.32 6.41,111.17 RPH2.2 ; U54.A6 160.25,148.38 v1(159.76,148.87) ; v1(159.99,142.3) 159.99,140.32 159.19,139.52 159.19,136.77 160.04,135.92 160.04,131.72 160.88,130.89 160.88,112.13 159.66,110.91 159.66,104.48 v1(159.51,104.33) ; v1(15.28,111.38) 15.28,111.35 15.75,110.88 16.05,110.88 16.36,111.19 16.5,111.19 16.62,111.32 17.94,111.32 18.36,110.9 UH4.C14
  IN1 w0.109: v1(159.99,142.3) 161.3,143.61 161.3,147.23 159.76,148.77 v1(159.76,148.87) ; v1(15.28,111.38) 14.77,111.38 12.94,109.55 12.48,109.55 12.23,109.31 10.82,109.31 9.35,110.78 8.22,110.78 7.82,110.38 7.02,110.38 6.59,110.81 6.59,111.31 v1(6.59,111.32)
  IN2 w0.102: 42.77,119.01 42.02,119.01 40.57,120.46 37.09,120.46 36.48,119.85 34.14,119.85 33.93,120.05 33.93,120.88 33.46,121.35 30.82,121.35 30.79,121.31 30.16,121.31 29.56,120.71 29.56,120.08 28.68,119.19 26.53,119.19 26.33,118.99 25.55,118.99 24.92,118.36 24.92,117.29 24.38,116.75 18.54,116.75 17.61,115.83 17.61,112.45 17.28,112.12 16.36,112.12
  IN2 w0.127: v1(159.51,104.33) 159.51,104.5 159.17,104.84 158.51,104.84 156.67,103 151.7,103 149.78,104.92 144.56,104.92 144.3,104.65 130.47,104.65 128.75,106.37 124.94,106.37 123.99,105.42 123.99,104.52 123.8,104.33 100.24,104.33 98.96,105.62 98.96,110.85 98.7,111.1 93.9,111.1 92.26,112.74 81.49,112.74 81.18,112.42 79.86,112.42 78.74,113.54 73.87,113.54 73.25,114.16 70.65,114.16 70.37,113.88 69.51,113.88 69.25,114.14 69.25,114.68 68.57,115.37 v1(66.6,115.37) 66.55,115.37 66.14,115.77 62.37,115.77 61.47,114.88 52.36,114.88 49.38,117.86 47.34,117.86 46.19,119.01 42.77,119.01 ; v1(15.28,111.38) 16.01,112.12 16.36,112.12
SIO_EXT_WAKE#: length 325.3
  TOP w0.102: UH4.C10 18.31,108.92 18,109.23 17.41,109.23 17,108.82 17,108.76 16.58,108.34 16.58,107.87 15.81,107.1 v3(15.56,107.1) 15.56,106.8 14.99,106.24 RH177.1 ; v1(221.26,84.68) 221.45,84.49 221.85,84.49 224.74,81.61 227.56,81.61 228.94,83 231.99,83 233.63,81.36 241.13,81.36 v1(241.83,82.06)
  IN2 w0.127: v1(221.26,84.68) 219.52,84.68 216.76,87.45 208.96,87.45 207.21,89.19 202.68,89.19 201.64,90.23 199.38,90.23 197.61,92.01 197.61,94.18 196.54,95.24 196.13,95.24 193.1,98.27 193.1,99.1 192.09,100.11 192.09,104.36 190.85,105.59 190.85,107.48 190.21,108.13 189.83,108.13 186.5,111.46 186.5,116.13 183.69,118.94 182.76,118.94 179.68,122.02 179.68,123.37 169.35,133.71 164.43,133.71 163.69,134.44 162.89,134.44 158.6,138.74 154.93,138.74 154.2,139.47 148.58,139.47 147.53,140.51 131.45,140.51 129.13,142.84 118.51,142.84 118.3,143.05 108.52,143.05 108.14,142.67 92.52,142.67 91.67,141.82 86.59,141.82 85.36,143.05 82.99,143.05 79.3,139.36 75.03,139.36 74.63,139.76 73.67,139.76 73.25,140.19 73.01,140.19 71.22,141.98 71.22,142.46 70.69,142.99 68.58,142.99 67.93,143.63 66.2,143.63 65.91,143.35 63.98,143.35 63.47,142.84 62.41,142.84 61.76,142.19 52.12,142.19 51.18,141.25 50.81,141.25 50.23,141.25 49.52,141.96 49.23,141.96 48.96,142.23 44.26,142.23 43.95,141.92 43.95,140.81 43.61,140.46 41.23,140.46 41.18,140.51 40.04,140.51 38.96,139.43 36.93,139.43 36,140.36 36,140.36 35.84,140.53 35.84,140.84 35.58,141.1 34.15,141.1 33.98,140.93 32.46,140.93 32.23,141.16 32.23,142.47 31.85,142.85 20.56,142.85 18.93,141.22 18.03,141.22 13.5,136.7 13.5,134.17 12.25,132.92 9.71,132.92 9.07,132.28 9.07,132.07 8.28,131.29 8.28,124.94 8.84,124.38 8.84,122.51 8.19,121.86 8.19,121.02 7.96,120.79 7.96,117.18 6.93,116.15 6.93,114.63 7.77,113.79 12.04,113.79 13.12,112.72 13.12,110.48 14.95,108.65 15.36,108.65 16.04,107.97 16.04,107.58 v3(15.56,107.1)
  BOTTOM w0.102: v1(241.83,82.06) 241.83,81.64 R797.1
SIO_PWRBTN#: length 222.2
  TOP w0.102: v1(167.72,150.99) U54.B58
  IN1 w0.109: v1(167.72,150.99) 167.72,150.98 168.13,150.57 168.13,149.31 167.74,148.92 167.74,144.8 167.42,144.48 167.42,142.21 167.19,141.98 167.19,139.94 166.29,139.04 166.29,137.23 166.28,137.22 166.28,136.42 166.53,136.17 v1(166.7,136.17)
  IN2 w0.127: v1(8.39,110.3) 8.39,111.07 7,112.47 7,112.64 6.74,112.9 6.39,112.9 5.51,113.78 5.51,119.67 6.65,120.82 6.65,123.27 7.2,123.81 7.2,132.48 8.39,133.67 9.29,133.67 13.94,138.33 13.94,139.07 14.23,139.35 14.66,139.35 17.7,142.39 19.15,142.39 20.38,143.62 32.37,143.62 32.37,143.63 33.04,143.63 35.09,141.58 35.74,141.58 36.3,141.03 36.3,140.84 36.3,140.84 36.3,140.72 37.07,139.94 38.82,139.94 39.85,140.97 41.37,140.97 41.42,140.92 43.26,140.92 43.48,141.14 43.48,142.14 44.07,142.72 45.57,142.72 46.24,143.4 48.44,143.4 49.15,142.69 49.15,142.69 49.34,142.49 49.65,142.49 50.44,141.71 50.62,141.71 50.62,141.71 50.99,141.71 51.97,142.69 61.59,142.69 62.2,143.29 63.27,143.29 63.78,143.8 65.72,143.8 66.01,144.09 68.12,144.09 68.76,143.45 70.96,143.45 71.47,142.94 73.18,142.94 73.6,142.52 73.6,141.64 73.8,141.45 73.8,140.84 74.36,140.28 74.75,140.28 75.22,139.81 79.11,139.81 82.8,143.51 85.55,143.51 86.78,142.28 91.35,142.28 92.19,143.13 107.72,143.13 108.1,143.51 116.43,143.51 117.39,144.46 118.69,144.46 118.89,144.26 135.67,144.26 135.96,143.97 144.97,143.97 148.93,140.01 154.51,140.01 155.31,139.21 159.18,139.21 160.04,138.34 164.74,138.34 166.28,136.8 166.28,136.59 v1(166.7,136.17)
  BOTTOM w0.102: v1(8.39,110.3) 8.39,110.55 v2(8.7,110.86) 9.33,110.86 RH122.1
SIO_PWRBTN#_R: length 108.3
  TOP w0.102: v1(71.89,94.32) 72.44,93.78 72.44,92.52 72.05,92.13 72.05,88.51 v1(71.75,88.21) ; v1(19.68,114.38) 20.07,114 UH4.E20 ; RH21.1 65.51,113.11 v1(65.75,113.35)
  IN1 w0.109: v1(7.61,115.11) 7.54,115.05 7.54,114.3 7.81,114.03 9.38,114.03 10.34,113.08 10.34,112.83 10.34,112.47 10.58,112.22 12.86,112.22 14.08,113.44 17.41,113.44 18.35,114.38 v1(19.68,114.38)
  IN2 w0.102: v1(19.68,114.38) 18.99,114.38 18.45,114.92 18.45,115.52 18.87,115.94 24.75,115.94 24.76,115.95 25.86,115.95 26.11,116.2 26.11,116.58 26.88,117.36 26.88,118.1 27.12,118.34 27.13,118.34 27.17,118.38 29.08,118.38 29.08,118.38 29.54,118.38 29.54,118.38 29.88,118.38 29.89,118.38 30.39,118.38 30.4,118.39 30.74,118.39 30.75,118.38 31.17,118.38 31.18,118.38 31.51,118.38 31.52,118.38 32.28,118.38 32.52,118.13 32.52,117.8 32.61,117.71 32.61,117.51 34.36,115.76 41.38,115.76 42.72,114.41 42.77,114.41
  IN2 w0.127: 42.77,114.41 45.36,114.41 45.74,114.8 48.69,114.8 49.52,113.96 50.8,113.96 51.19,113.56 52.13,113.56 52.52,113.96 62.61,113.96 63.6,112.97 64.98,112.97 65.36,113.35 v1(65.75,113.35)
  IN3 w0.127: v1(65.75,113.35) 66,113.09 66,104.94 v1(65.82,104.76)
  BOTTOM w0.102: RC9.1 71.75,88.26 v1(71.75,88.21) ; v1(7.61,115.11) 7.61,114 7.09,113.48 7.09,112.97 7.34,112.71 8.02,112.71 8.92,111.81 10.24,111.81 RH122.2 ; v1(71.89,94.32) 71.89,100.1 69.9,102.1 68.25,102.1 v2(66.13,104.22) 66.13,104.43 65.82,104.74 v1(65.82,104.76)
SIO_RCIN#: length 224.7
  TOP w0.102: U54.A27 167.97,141.33 168.11,141.2 168.11,140.72 167.85,140.46 167.38,140.46 167,140.08 167,139.26 167.17,139.09 167.17,131.6 v1(166.98,131.41) ; UH4.P5 23.96,107.01 23.69,107.01 v1(23.68,107.02)
  IN2 w0.102: 16.36,109.8 17.72,109.8 18.52,109.01 19.37,109.01 19.39,109.03 21.17,109.03 21.19,109.02 22.87,109.02 23.25,108.64 23.25,107.5 23.68,107.07 v1(23.68,107.02)
  IN2 w0.127: 16.36,109.8 15.7,110.47 14.9,110.47 14.14,111.23 14.14,113.49 13.42,114.21 13.42,116.54 9.21,120.76 9.21,121.82 10.76,123.37 10.76,125.37 12,126.62 12,128.56 13.13,129.69 13.13,132.48 14.41,133.76 14.41,136.32 17.57,139.47 18.67,139.47 21.06,141.86 25.8,141.86 26.64,141.02 28.96,141.02 30.39,139.59 32.74,139.59 32.88,139.45 35.63,139.45 36.69,138.38 42.62,138.38 43.66,139.42 45.09,139.42 45.36,139.14 45.92,139.14 46.79,140.01 51.56,140.01 52.51,140.96 63.21,140.96 63.62,141.36 65.95,141.36 66.23,141.08 66.23,140.65 66.49,140.39 66.86,140.39 67.07,140.6 69.91,140.6 71.78,138.73 72.65,138.73 73.13,138.25 73.13,138.11 74.81,136.42 75.37,136.42 75.68,136.73 75.68,137.05 76.6,137.97 81.68,137.97 84.25,140.54 88.39,140.54 89.29,139.64 91.2,139.64 93.06,141.5 104.29,141.5 105.07,140.73 107.31,140.73 108.71,139.33 110.6,139.33 111.47,140.2 114.82,140.2 117.8,137.21 150.44,137.21 151.38,138.15 153.31,138.15 155.17,136.3 157.92,136.3 158.46,135.76 159.09,135.76 162.63,132.22 166.17,132.22 v1(166.98,131.41)
  BOTTOM w0.102: RH203.1 23.21,105.25 v2(23.21,106.08) 23.21,106.55 v1(23.68,107.02)
SIO_SLP_A#: length 467.9
  TOP w0.102: v1(136.51,154.8) 136.27,154.56 133.66,154.56 133.2,155.02 Q306.2 ; v1(8.43,158.33) 7.66,158.33 6.46,157.13 PR404.1 ; UH4.G10 20.7,108.64 v1(20.92,108.42)
  IN1 w0.109: v1(8.43,158.33) 14.03,158.33 19.07,163.37 38.53,163.37 40.28,165.13 44.32,165.13 49.08,160.36 56.63,160.36 57.75,159.25 61.49,159.25 61.94,159.69 64.35,159.69 66.11,157.93 70.05,157.93 72.27,155.7 76.78,155.7 81.48,151 93.31,151 96.56,154.25 96.56,157.06 99.72,160.23 99.72,162.81 108.24,171.32 128.72,171.32 130.45,169.59 130.45,167.46 v1(131.48,166.43) ; v1(126.85,165.24) 127.07,165.01 127.07,160.38 129.08,158.38 130.9,158.38 131.29,158 132.61,158 133.69,156.92 133.69,154.71 133.82,154.58 135.89,154.58 136.1,154.8 v1(136.51,154.8) ; v1(229.13,83.5) 229.56,83.07 230.65,83.07 232.66,81.06 237.87,81.06 238.13,80.8 240.2,80.8 242.2,78.8 242.2,77.87 241.36,77.03 241.36,76.07 241.63,75.8 241.63,71.33 241.23,70.93 240.14,70.93 v1(239.76,70.55)
  IN2 w0.102: 27.13,103.19 26.11,104.2 23.95,104.2 23.44,104.71 22.66,104.71 21.27,106.1 21.27,108.07 v1(20.92,108.42)
  IN2 w0.127: v1(229.13,83.5) 228.83,83.5 228.58,83.75 228.58,84.69 224.12,89.16 224.12,89.43 222.58,90.97 221.54,90.97 219.33,93.18 210.8,93.18 207.92,96.06 207.92,101.14 206.07,102.99 206.07,118.89 205.14,119.82 205.14,130.96 205.45,131.27 205.45,151.53 201.42,155.55 199.78,155.55 197.18,158.14 191.51,158.14 190.29,159.36 184.5,159.36 183.45,158.31 179.77,158.31 179.44,158.64 170.23,158.64 169.36,159.51 167.2,159.51 165.18,161.52 160.46,161.52 157.85,158.9 156.79,158.9 152.21,154.32 148.72,154.32 148.44,154.6 147.01,154.6 146.11,155.5 144.47,155.5 143.96,156.01 137.08,156.01 136.51,155.44 v1(136.51,154.8) ; v1(126.85,165.24) 126.99,165.38 130.43,165.38 v1(131.48,166.43) ; 27.13,103.19 27.53,102.78 27.53,102.77 28.87,101.44 29.65,101.44 30.4,102.18 31.11,102.18 31.78,102.86 33.16,102.86 v1(33.17,102.85) ; v1(5.65,135.2) 5.65,133.96 4.63,132.94 4.63,128.63 4.37,128.36 4.37,120.68 4.13,120.43 4.13,113.57 4.13,113.19 4.14,113.18 4.14,113.15 4.89,112.4 4.89,110.28 5.16,110.01 6.06,109.11 6.25,109.11 6.92,109.11 8.13,107.9 8.13,105.84 8.57,105.4 9.87,105.4 v1(10.32,104.94)
  IN4 w0.102: v1(20.92,108.42) 20.35,107.85 20.13,107.85 20.09,107.81 19.39,107.81 19.36,107.84 18.79,107.84 17.51,106.56 17.51,105.5 16.96,104.95
  IN4 w0.109: v1(10.32,104.94) 10.34,104.94 10.93,104.34 14.27,104.34 14.62,104 16.01,104 16.96,104.95 ; v1(8.43,158.33) 8.43,158.27 9.24,157.46 9.24,155.04 10.15,154.14 10.15,149.75 9.88,149.48 9.88,142.67 9.57,142.36 9.57,142 9.88,141.69 9.88,140.59 9.26,139.97 7.34,139.97 5.65,138.28 v1(5.65,135.2)
  BOTTOM w0.102: U46.B63 241.42,70.7 239.91,70.7 v1(239.76,70.55) ; v1(33.17,102.85) 33.17,102.45 v2(35.51,100.11) 38.42,97.21 38.84,97.21 39.32,96.73 UC4.1
SIO_SLP_LAN#: length 364.4
  TOP w0.102: v1(137.51,139.19) Q297.2 ; UH4.K14 21.97,110.69 v1(21.69,110.41)
  IN1 w0.109: v1(165.14,100.33) 165.14,102.88 168.51,106.26 168.51,107.44 169.2,108.13 171.26,108.13 171.87,108.74 171.87,110.17 174.35,112.64 179.96,112.64 181.92,110.69 184.39,110.69 184.8,111.1 v1(185.84,111.1)
  IN2 w0.102: 42.77,108.42 41.97,108.42 41.37,107.82 41.37,105.7 40.8,105.13 28.44,105.13 28.3,105.26 24.56,105.26 24.29,105.52 24.29,110.39 23.85,110.83 22.12,110.83 v1(21.69,110.41)
  IN2 w0.127: v1(165.14,100.33) 164.41,101.05 161.03,101.05 160.6,101.49 151.21,101.49 149.85,102.85 128.46,102.85 127.66,102.05 99.87,102.05 90.69,111.23 81.99,111.23 81.79,111.02 79.11,111.02 78.17,111.96 74.55,111.96 71.14,108.56 64.04,108.56 61.43,111.18 51.18,111.18 50.46,110.45 46.98,110.45 44.94,108.42 42.77,108.42 ; v1(223.57,83.88) 223.22,84.23 220.93,84.23 220.76,84.39 219.49,84.39 216.66,87.22 208.86,87.22 207.12,88.96 202.56,88.96 201.52,90.01 199.29,90.01 197.38,91.91 197.38,93.1 192.64,97.84 192.64,98.91 191.57,99.99 191.57,104.17 190.23,105.51 190.23,106.72 189.52,107.43 189.52,108.08 186.5,111.1 v1(185.84,111.1) 185.84,116.47 183.6,118.71 181.82,118.71 179.45,121.08 179.45,123.28 169.25,133.48 164.34,133.48 163.6,134.21 162.77,134.21 158.56,138.43 154.92,138.43 154.1,139.24 150.4,139.24 149.92,138.76 137.95,138.76 v1(137.51,139.19)
  IN3 w0.127: v1(239.04,65.25) 240.79,65.25 242.37,66.83 243.1,66.83 243.56,67.29 243.88,67.29 245.15,68.56 245.15,71.43 245.68,71.96 245.68,79.46 244.04,81.1 243.67,81.1 243.13,80.57 238.94,80.57 236.87,82.64 236.87,82.99 236.35,83.5 233.43,83.5 232.73,84.2 230.87,84.2 230.22,84.86 224.88,84.86 223.91,83.88 v1(223.57,83.88)
  BOTTOM w0.102: v1(21.69,110.41) 21.63,110.34 21.54,110.34 21.15,109.94 19.91,109.94 19.91,109.94 19.57,109.94 19.17,110.34 v2(17.56,110.34) 15.85,110.34 15.44,110.74 14.86,110.74 RH319.2 ; U46.A5 238.58,65.71 v1(239.04,65.25)
SIO_SLP_S3#: length 527.6
  TOP w0.102: R1624.1 183.74,55.88 v1(183.41,55.55) ; v1(20.7,105.74) 20.43,105.74 20.26,105.91 UH4.F4 ; v1(212.95,78.42) 214.4,76.98 214.4,74.48 217.55,71.33 217.55,65.93 218.15,65.33 227.82,65.33 228.04,65.55 230.24,65.55 231.96,63.82 235.3,63.82 235.89,64.4 235.89,66.12 236.46,66.69 236.83,66.69 238.35,68.21 238.35,69.2 238.61,69.46 239.95,69.46 v1(240.19,69.7) ; v1(105.79,24.09) 109.37,27.68 109.37,43.92 112.47,47.02 114.17,47.02 114.57,46.61 118.59,46.61 119.45,47.47 RC82.1 ; v1(37.6,35.6) 37.6,35.75 37.4,35.95 JIO1.34 ; v1(51.19,115.17) 51.19,115.24 51.27,115.32 51.27,115.86 50.06,117.07 50.06,117.86 49.26,118.66 49.26,119.21 47.85,120.62 R781.1
  IN2 w0.102: 21.69,103.19 21.69,103.65 20.7,104.64 v1(20.7,105.74)
  IN2 w0.127: 21.69,103.19 21.69,101.87 22.73,100.84 24.06,100.84 24.78,100.11 27.27,100.11 28.23,99.15 28.23,98.55 28.56,98.22 31.76,98.22 32.22,97.77 34.05,97.77 34.09,97.8 36.35,97.8 36.52,97.63 37.66,97.63 38.64,98.6 49.88,98.6 50.11,98.37 v1(50.11,98.27)
  IN3 w0.102: 19.1,103.19 20.7,104.79 v1(20.7,105.74)
  IN3 w0.127: v1(37.6,35.6) 36.02,35.6 34.37,37.24 34.37,42.33 33.27,43.43 33.27,45.32 32.49,46.11 32.49,47.68 31.31,48.85 31.31,58.82 24.53,65.6 12.55,65.6 11.91,66.23 11.91,73.98 12.67,74.74 12.67,74.77 13.61,75.71 13.61,83.51 12.67,84.45 12.67,95.49 14.58,97.4 14.58,98.63 14.84,98.9 15.52,98.9 15.59,98.97 16.15,98.97 16.61,99.43 16.61,99.99 18.67,102.05 18.67,102.3 18.92,102.55 18.92,103.01 19.1,103.19 ; v1(212.95,78.42) 212.28,77.75 208.68,77.75 207.41,79.02 199.96,79.02 198.72,77.78 198.72,68.94 199.59,68.07 199.59,61.08 198.97,60.47 191.62,60.47 190.24,59.09 185.98,59.09 183.41,56.52 v1(183.41,55.55)
  IN4 w0.109: v1(37.6,35.6) 37.6,34.38 38.15,33.83 38.82,33.83 39.13,33.52 40.45,32.2 40.45,31.11 43.14,28.41 44.95,28.41 48.02,25.34 48.33,25.34 51.08,22.59 51.08,16.09 52.55,14.62 64.15,14.62 66.07,12.7 87.44,12.7 97.96,23.22 104.91,23.22 v1(105.79,24.09) 105.79,26.46 114.86,35.53 119.43,35.53 120.18,34.79 120.18,33.21 120.72,32.66 120.72,30.25 120.23,29.76 120.23,19.95 120.93,19.25 122.33,19.25 123,18.58 130.53,18.58 133.32,15.79 150.32,15.79 151.89,17.36 154.23,17.36 154.75,17.88 156.35,17.88 162.41,23.95 162.41,38.95 162.54,39.08 162.55,39.08 176.81,53.34 179.16,53.34 180.88,55.07 182.93,55.07 v1(183.41,55.55)
  BOTTOM w0.102: v1(50.11,98.27) 50.11,98.24 50.24,98.11 50.24,96.58 52.36,94.46 58.58,94.46 58.95,94.83 58.95,96.52 59.19,96.76 59.19,101.07 61.23,103.1 61.23,111.15 58.85,113.53 51.89,113.53 v2(51.6,113.81) 51.19,114.22 v1(51.19,115.17) ; v1(240.19,69.7) U46.B65 ; PR307.1 v1(105.79,24.09)
  BOTTOM w0.127: v1(212.95,78.42) 213.21,78.17 PR311.1
SIO_SLP_S4#: length 365.8
  TOP w0.102: v1(243.69,69.42) 243.95,69.16 244.02,69.16 244.49,68.69 244.49,61.44 244.24,61.2 244.24,60.11 v1(243.52,59.39) 243.18,59.04 243.18,48.72 241.01,46.55 v1(236.56,46.55) ; R808.1 126.37,25.84 v1(127,26.47) ; UH4.H4 20.95,106.41 v1(20.7,106.41)
  IN2 w0.102: 21.42,103.19 21.42,103.42 20.29,104.55 20.29,106.01 v1(20.7,106.41)
  IN2 w0.127: v1(113.89,95.71) 113.63,95.71 112.55,96.79 109.63,96.79 108.87,97.55 82.91,97.55 82.63,97.27 75.91,97.27 74.3,95.66 66.51,95.66 65.85,96.32 64.93,96.32 64.67,96.58 64.67,97.04 62.73,98.97 59.32,98.97 58.38,99.91 52.38,99.91 50.3,97.83 49.9,97.83 49.35,98.37 38.73,98.37 37.76,97.4 36.4,97.4 36.22,97.57 34.21,97.57 34.16,97.52 32.68,97.52 32.34,97.18 30.55,97.18 30.26,97.47 30.26,97.8 30.1,97.97 28.49,97.97 28,98.45 28,99.05 27.17,99.89 24.69,99.89 23.99,100.58 22.66,100.58 21.42,101.82 21.42,103.19
  IN4 w0.109: v1(243.52,59.39) 243.29,59.61 235.98,59.61 234.68,60.91 221.88,60.91 220.33,59.36 207.21,59.36 202,64.57 192.84,64.57 190.83,62.56 189.52,62.56 186.59,59.63 181.32,59.63 178.4,56.71 174.64,56.71 169.3,51.37 164.95,51.37 162.06,48.49 162.06,43.82 159.33,41.09 159.33,40.07 157.75,38.48 157.75,37.77 156.65,36.68 151.36,36.68 150.15,35.47 150.15,31.02 149.14,30.01 136.99,30.01 134.23,27.25 130.12,27.25 129.33,26.47 v1(127,26.47) 127,34.42 121.87,39.54 111.26,39.54 110.2,40.6 110.2,77.23 113.75,80.79 113.75,95.57 v1(113.89,95.71)
  BOTTOM w0.102: v1(236.56,46.55) PR226.1 ; v1(243.69,69.42) 243.69,69.45 243.19,69.95 U46.A61 ; v1(20.7,106.41) 20.2,105.92 T59.1
SIO_SLP_S5#: length 207.2
  TOP w0.102: v1(162.86,143.57) 162.86,143.58 162.81,143.63 U54.B16 ; v1(19.65,109.45) 19.65,109.42 19.57,109.35 19.57,109.06 UH4.D10
  IN2 w0.102: v1(19.65,109.45) 19.57,109.53 19.57,109.6 18.91,110.26 16.36,110.26
  IN2 w0.127: 16.36,110.26 15.92,110.69 14.99,110.69 14.37,111.32 14.37,113.59 13.65,114.3 13.65,116.64 10.98,119.3 10.98,125.28 13.17,127.46 13.17,129.06 13.36,129.25 13.36,132.39 15.15,134.18 15.15,135.46 15.82,136.13 15.82,136.54 16.52,137.24 16.53,137.24 17.87,138.58 20.09,138.58 22.49,140.98 22.5,140.98 22.54,141.02 25.34,141.02 25.38,140.98 25.39,140.98 26.3,140.07 27.1,140.07 28.01,139.17 28.72,139.17 29.14,138.75 32.39,138.75 32.53,138.61 35.28,138.61 36.34,137.54 45.51,137.54 47.13,139.17 53.79,139.17 54.72,140.09 61.76,140.09 62,139.85 65.14,139.85 65.58,139.41 68.55,139.41 70.59,137.38 70.72,137.38 71.14,136.96 73.05,136.96 75.15,134.86 77.31,134.86 77.8,135.34 77.8,135.88 78.03,136.11 78.23,136.11 79.25,137.12 82.1,137.12 82.59,137.61 86.83,137.61 87.84,136.59 103.11,136.59 104.05,135.65 108.65,135.65 109.12,136.12 112.75,136.12 114.99,133.88 130.83,133.88 132.59,135.64 152.32,135.64 154.72,133.24 v1(157,133.24)
  BOTTOM w0.102: v1(19.65,109.45) 19.12,109.97 T58.1 ; v1(157,133.24) 157,134.25 155.07,136.18 155.07,140.21 155.69,140.83 160.07,140.83 161.17,141.94 161.17,142.79 161.96,143.57 v1(162.86,143.57)
SIO_SLP_SUS#: length 266.1
  TOP w0.102: UH4.G16 20.7,111.79 20.33,111.42 v1(20.33,111.4) ; v1(237.81,69.01) 237.63,69.01 237.17,68.56 237.17,67.96 237.01,67.79 229.81,67.79 228.96,68.64 224.89,68.64 224.63,68.39 224.63,67.14 224.31,66.82 222.53,66.82 v1(222.45,66.89)
  IN2 w0.102: 42.77,110.78 41.13,110.78 40.11,111.8 33.47,111.8 33.4,111.73 30.13,111.73 29.09,112.76 27.87,112.76 27.34,112.23 27.05,112.23 25.98,111.16 25.5,111.16 24.62,112.05 22.63,112.05 22.45,111.87 20.81,111.87 v1(20.33,111.4)
  IN2 w0.127: 42.77,110.78 44.21,110.78 45.5,112.07 49.1,112.07 49.53,112.5 52.57,112.5 52.97,112.89 61.49,112.89 64.64,109.74 70.65,109.74 74.17,113.26 78.61,113.26 79.68,112.19 81.29,112.19 81.61,112.51 92.13,112.51 96.94,107.7 96.94,106.58 100.08,103.44 124.31,103.44 125.56,104.69 125.56,105.14 126.1,105.68 128.4,105.68 130.48,103.61 145.25,103.61 145.87,104.23 149.49,104.23 151.49,102.24 161.26,102.24 161.57,101.93 167.22,101.93 168.5,100.65 173.23,100.65 176.83,97.04 176.83,96.86 178.87,94.83 178.87,93.54 179.12,93.28 179.73,93.28 181.49,91.53 182.16,91.53 184.39,89.3 184.39,85.8 187.69,82.5 187.69,72.39 186.81,71.5 186.81,69.96 190.24,66.52 200.89,66.52 202.11,65.3 202.99,65.3 203.9,64.39 214.17,64.39 217.77,67.98 220.87,67.98 221.54,67.32 221.54,67.32 221.96,66.89 v1(222.45,66.89)
  BOTTOM w0.102: T62.1 20.33,111.63 v1(20.33,111.4) ; v1(237.81,69.01) 238.33,68.49 U46.B6
SL_BAT_PRES#: length 2.5
  TOP w0.254: PU1001.21 177.87,75.96 177.86,75.97 177.86,76.39 v2(177.87,76.4) 177.87,76.77 PR1023.1
SLICE_BAT_ON: length 88.8
  TOP w0.254: v1(174.03,78.93) 174.34,78.61 PR1016.2
  IN2 w0.127: v1(174.03,78.93) 174.34,78.93 175.25,79.83 178.46,79.83 179.87,78.42 179.87,76.52 182.65,73.74 182.65,62.56 184.07,61.14 184.66,61.14 184.78,61.02 187.1,61.02 188.87,62.79 193.03,62.79 193.95,61.86 197.76,61.86 198.09,61.53 202.3,61.53 204.01,63.25 223.49,63.25 v1(224.31,64.06)
  BOTTOM w0.102: v1(224.31,64.06) 224.42,64.17 v2(224.42,66.87) 224.42,68.2 223.8,68.82 223.8,73.21 225.07,74.47 225.41,74.47 226.36,73.52 227.71,73.52 R791.1 228.73,73.06 228.92,73.3 228.92,73.48 229.54,74.11 229.54,74.66 230.32,75.45 U46.A31
SLICE_BAT_PRES#: length 260.3
  TOP w0.102: PR6.1 v1(209.4,9.46) ; v1(200.57,91.81) 200.1,91.34 194.22,91.34 193.75,91.81 v1(192.99,91.81) ; PR1023.2 v1(178.41,78.93)
  IN1 w0.109: v1(228.92,76.84) 228.32,76.24 228.32,73.14 226.68,71.5 221.49,71.5 220.36,70.37 220.36,68.54 221.17,67.73 221.17,66.35 220.51,65.68 220.31,65.68 209.14,54.52 209.14,43.52 211.16,41.5 v1(211.16,38.98)
  IN2 w0.127: v1(209.4,9.46) 209.4,13.55 210.27,14.43 210.27,38.09 v1(211.16,38.98) ; v1(232.92,75.74) 232.9,75.76 232.9,77.35 228.74,81.51 226.67,81.51 225.02,83.16 225.02,83.74 223.12,85.64 220.78,85.64 219.79,86.63 218.86,86.63 216.66,88.82 213.12,88.82 212.9,89.04 209.08,89.04 208.24,89.88 203.31,89.88 202.27,90.92 201.46,90.92 v1(200.57,91.81) ; v1(118.97,119.95) 119,119.93 119,118.52 120.94,116.57 127.49,116.57 128.22,117.3 130.35,117.3 131.71,115.93 131.71,115.11 132.46,114.36 132.46,113.94 132.98,113.42 155.15,113.42 157.25,115.52 165.14,115.52 167.09,113.56 169.01,113.56 169.18,113.4 177.38,113.4 180.44,110.33 180.44,106.97 180.92,106.49 180.94,106.49 181.87,105.56 181.87,105.2 182.45,104.62 182.45,103.73 182.95,103.23 183.65,103.23 184.2,102.68 184.2,101.93 185.27,100.86 185.27,100.17 188.24,97.21 188.24,96.51 189.99,94.76 190.47,94.76 192.94,92.28 192.94,91.9 192.99,91.85 v1(192.99,91.81)
  IN3 w0.127: v1(178.41,78.93) 177.29,80.05 177.29,83.34 178.23,84.28 188.95,84.28 191.72,87.05 191.72,89 192.99,90.27 v1(192.99,91.81)
  IN4 w0.109: v1(228.92,76.84) 229.83,75.92 232.74,75.92 v1(232.92,75.74)
  BOTTOM w0.102: v1(232.92,75.74) 232.88,75.7 U46.B33 ; JDOCK1.143 119.24,119.72 119,119.96 118.99,119.96 118.74,119.71 JDOCK1.141 ; v1(228.92,76.84) 228.92,76.61 R760.2 ; v2(211.71,38.96) 211.69,38.98 v1(211.16,38.98)
  BOTTOM w0.127: 118.98,119.95 v1(118.97,119.95)
SLP_ME_CSW_DEV#: length 297.2
  TOP w0.102: UH4.P8 24.12,108.02 23.81,108.33 v1(23.67,108.33) ; RH10.1 74.14,98.41 72.79,97.07 67.88,97.07 67.13,96.32 63.93,96.32 v1(63.75,96.5) ; v1(223.96,67.3) 223.53,67.73 223.53,68.17 223.76,68.4 223.76,69.28 224.88,70.4 225.66,70.4 225.93,70.13 228.46,70.13 228.62,69.96 230.73,69.96 231.91,71.14 233.19,71.14 233.29,71.04 v2(235.91,71.04) 238.36,71.04 v1(239.84,72.53)
  IN1 w0.109: v1(16.01,97.83) 16.67,97.17 22.21,97.17 v1(22.7,97.66)
  IN2 w0.127: v1(22.7,97.66) 22.74,97.61 23.56,97.61 24.26,96.91 27.2,96.91 28.09,96.03 33.15,96.03 33.77,95.4 35,95.4 35.85,96.25 38.23,96.25 38.55,96.57 40.72,96.57 41.33,97.18 48.02,97.18 48.57,96.63 50.4,96.63 52.76,99 58,99 58.94,98.06 60.83,98.06 62.77,96.11 63.31,96.11 63.69,96.5 v1(63.75,96.5) 63.75,95.83 64.24,95.35 64.64,95.35 65.12,95.83 66.01,95.83 66.41,95.43 75.5,95.43 77.11,97.04 82.72,97.04 82.99,97.31 108.74,97.31 111.3,94.74 130.22,94.74 135.39,99.91 148.79,99.91 151.01,97.69 155.98,97.69 156.88,98.59 172.41,98.59 173.75,97.26 173.75,94.18 177.79,90.15 181.59,90.15 182.98,88.75 182.98,85.05 185.51,82.52 185.51,69.63 189.76,65.38 198.27,65.38 200.8,62.85 203.24,62.85 203.86,63.48 221.41,63.48 222.99,65.05 222.99,66.32 v1(223.96,67.3)
  IN4 w0.109: v1(22.7,97.66) 22.88,97.84 22.88,102.49 23.65,103.25 24.12,103.25 24.41,103.54 24.41,104.14 24.28,104.27 24.28,107.72 v1(23.67,108.33)
  BOTTOM w0.102: RH54.1 23.4,96.79 22.7,97.49 v1(22.7,97.66) ; v1(239.84,72.53) 240.14,72.53 240.45,72.84 240.82,72.84 241.18,73.2 U46.B58 ; v1(16.01,97.83) 16.01,97.51 16.1,97.42 RH353.1
SM_RCOMP0: length 5.1
  TOP w0.508: v1(100.4,70.99) 99.9,70.48 JCPU1.AK1
  BOTTOM w0.508: v1(100.4,70.99) v2(102.65,70.99) 103.96,70.99 RC50.1
SM_RCOMP1: length 5.7
  TOP w0.508: RC48.1 v2(95.1,37.19) 95.1,40.2 95.9,41.01 JCPU1.A5
SM_RCOMP2: length 5.7
  TOP w0.381: RC47.1 96.11,36.91 v2(96.44,37.24) 96.44,40.02 96.9,40.48 JCPU1.A4
SML1_SMBCLK: length 195.1
  TOP w0.102: v1(20.39,110.35) 20.39,110.43 20.07,110.75 UH4.E14 ; v1(163.6,148.74) 163.28,148.43 162.74,148.43 162.53,148.63 162.13,148.63 U54.B6
  IN1 w0.102: 42.17,103.74 41.98,103.92 41.77,103.92 40.26,105.43 39.56,105.43 38.7,106.29 38.7,106.63 38.09,107.24 35.94,107.24 35.27,107.91 33.44,107.91 33.34,107.81 30.54,107.81 29.92,108.43 29.92,109.82 29.56,110.17 28.71,110.17 28.45,110.44 28.45,111.29 28.07,111.67 26.39,111.67 25.87,111.15 25.49,111.15 24.37,112.27 23,112.27 22.68,111.95 21.56,111.95 20.39,110.79 v1(20.39,110.35)
  IN1 w0.109: v3(155.68,134.47) 155.68,134.21 155.41,133.95 137.63,133.95 136.81,133.12 126.76,133.12 121.97,128.33 120.83,128.33 117.96,125.45 117.96,125.28 117.2,124.52 115.8,124.52 112.75,121.48 111.72,121.48 111.1,120.85 111.1,120 109.74,118.64 109.74,116.55 109.33,116.14 107.55,116.14 107.02,116.68 105.32,116.68 102.45,119.55 97.07,119.55 93.86,116.34 90.48,116.34 86.59,112.45 85.19,112.45 82.96,110.22 81.26,110.22 79.63,108.59 72.84,108.59 71.44,107.19 71.44,106.39 69.31,104.27 68,104.27 67.18,103.44 63.42,103.44 63.12,103.14 61.54,103.14 60.96,102.56 60.67,102.56 59.88,101.77 57.78,101.77 57.57,101.55 57.03,101.55 56.26,102.32 49.85,102.32 49.37,102.81 45.9,102.81 45.58,103.12 43.25,103.12 43.2,103.07 42.84,103.07 42.17,103.74
  BOTTOM w0.102: RH298.2 14.62,111.82 16.15,111.82 17.22,110.76 19.99,110.76 v1(20.39,110.35) ; v1(163.6,148.74) 163.28,148.43 162.74,148.43 162.71,148.45 160.68,148.45 160.34,148.11 159.05,148.11 158.82,147.88 156.25,147.88 155.4,147.03 155.4,145.36 154.25,144.22 154.25,134.72 155.03,133.93 155.49,133.93 155.68,134.12 v3(155.68,134.47)
SML1_SMBDATA: length 192.7
  TOP w0.102: v1(22.86,111.42) 22.88,111.42 23.32,111.85 UH4.M16 ; v1(160.45,148.88) U54.A5
  IN1 w0.102: 42.09,103.48 41.87,103.7 41.68,103.7 40.17,105.21 39.43,105.21 38.48,106.16 38.48,106.53 38.02,106.99 35.85,106.99 35.15,107.68 33.54,107.68 33.42,107.57 30.48,107.57 29.68,108.37 29.68,109.63 29.36,109.94 28.64,109.94 28.22,110.36 28.22,111.13 27.93,111.42 26.5,111.42 25.98,110.9 25.44,110.9 24.36,111.98 23.21,111.98 22.86,111.62 v1(22.86,111.42)
  IN1 w0.109: v1(156.13,134.01) 156.09,133.97 155.79,133.97 155.51,133.69 137.74,133.69 136.91,132.87 126.86,132.87 122.07,128.08 120.94,128.08 118.21,125.35 118.21,125.17 117.18,124.14 115.8,124.14 112.88,121.22 111.83,121.22 111.35,120.75 111.35,119.9 109.99,118.54 109.99,116.45 109.43,115.89 107.45,115.89 106.92,116.42 105.21,116.42 102.34,119.29 97.18,119.29 93.97,116.08 90.58,116.08 86.69,112.19 85.29,112.19 83.09,109.99 81.39,109.99 79.74,108.34 72.94,108.34 71.69,107.09 71.69,106.29 69.42,104.01 68.11,104.01 67.28,103.19 63.53,103.19 63.22,102.88 61.64,102.88 61.07,102.31 60.77,102.31 59.98,101.51 57.89,101.51 57.67,101.3 56.93,101.3 56.15,102.07 49.74,102.07 49.26,102.55 45.74,102.55 45.45,102.85 43.38,102.85 43.32,102.78 42.78,102.78 42.09,103.48
  BOTTOM w0.102: RH299.2 14.62,112.85 14.62,112.45 14.91,112.15 v2(15.42,112.15) 16.23,112.15 16.85,111.54 16.85,111.51 17.37,110.99 21.02,110.99 21.17,111.14 21.17,111.62 21.36,111.81 22.48,111.81 22.86,111.43 v1(22.86,111.42) ; v1(156.13,134.01) 155.93,134.01 155.6,133.68 154.93,133.68 154,134.61 154,144.32 155.08,145.41 155.08,147.13 156.08,148.13 158.71,148.13 159,148.43 160.13,148.43 160.45,148.74 v1(160.45,148.88)
