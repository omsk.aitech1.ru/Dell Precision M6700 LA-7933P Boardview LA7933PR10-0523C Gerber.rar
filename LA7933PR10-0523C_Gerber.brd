# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMC4022_GPIO2: length 2.7
  TOP w0.102: R404.1 146.12,156.78 v2(145.97,156.94) 145.33,157.58 U18.14
EN_1.5VSP: length 5.9
  BOTTOM w0.102: v2(215.15,76.84) PR314.2
  BOTTOM w0.254: PR314.2 213.3,76.84 PR311.2 212.17,76.74 PR312.1 211,76.82 PC311.1 210.92,76.66 210.08,75.82 PU302.5
EN_1.8VSP: length 6.4
  BOTTOM w0.102: v2(108.91,22.06) PC305.1
  BOTTOM w0.254: PC305.1 106.89,22.06 PR305.1 106.82,22.05 PR307.2 PR304.2 104.58,22.05 104.34,21.81 104.34,20.52 104.54,20.32 PU301.5
EN_+V1.05S_VCCPP: length 3.3
  BOTTOM w0.254: PR504.2 PC507.1 56.46,22.54 56.98,23.07 56.98,23.07 56.99,23.07 56.99,23.26 57.58,23.85 PU501.3
EN_+V1.05SP: length 2.8
  TOP w0.254: PR404.2 PC407.1 4.71,155.46 PU401.3
EN_DK_PWRBAR: length 3.8
  TOP w0.254: PU1001.17 180.68,73.68 v2(181.04,74.04) PR1028.1 PR1027.1
EN_DOCK_PWR_BAR: length 72.3
  TOP w0.254: v1(234.16,75.34) 234.13,75.34 233.97,75.5 233.97,76.31 233.65,76.63 233.09,76.63 231.65,75.2 228.23,75.2 227.62,74.59 225.11,74.59 222.54,72.02 222.21,72.02 221.74,71.55 218.48,71.55 v2(217.61,72.42) 215.12,74.91 215.12,79.07 214.53,79.67 198.89,79.67 195.56,83 184.49,83 v1(184.22,82.73) ; PR1027.2 183.6,73.98 184.42,74.79 v1(184.42,74.97)
  IN2 w0.254: v1(184.42,74.97) 184.47,75.02 184.72,75.02 184.89,75.18 184.89,82.06 184.22,82.72 v1(184.22,82.73)
  BOTTOM w0.127: U46.B37 233.83,76.44 234.06,76.21 234.06,75.44 v1(234.16,75.34)
EN_I2S_NB_CODEC#: length 282.6
  TOP w0.102: JIO1.29 32.01,37.15 v1(32.32,36.84)
  IN1 w0.109: v1(224.01,57.91) 224.01,58.23 226.86,61.07 229.53,63.74 229.53,65.13 230.82,66.42 230.82,67.87 232.38,69.43 232.38,75.91 232.66,76.19 233.36,76.19 v1(233.43,76.12)
  IN4 w0.109: v1(224.01,57.91) 223.61,58.32 195.57,58.32 193.1,55.85 193.1,54.85 192,53.75 186.15,53.75 185.38,52.97 180.87,52.97 178.04,50.14 175.58,50.14 163.9,38.46 163.9,23.12 156.98,16.19 155,16.19 154.8,15.99 152.83,15.99 151.05,14.21 124.11,14.21 122.81,12.91 122.81,12.5 122.46,12.15 120.81,12.15 120.62,12.35 120.62,12.64 117.51,15.75 114.43,15.75 111.66,12.97 111.66,11.91 110.8,11.06 110.19,11.06 110.07,11.18 109.56,11.18 109.29,10.91 109.29,10 108.95,9.65 108.12,9.65 106.01,7.54 36.69,7.54 34.26,9.97 31.77,9.97 30.07,11.67 30.07,20.59 30.28,20.79 30.28,22.83 31.19,23.74 31.19,35.72 v1(32.32,36.84)
  BOTTOM w0.102: v1(224.01,57.91) v2(224.01,58.52) ; v1(233.43,76.12) 233.43,76.13 233.33,76.23 U46.B36
EN_INVPWR: length 104.5
  TOP w0.102: U54.A25 166.97,140.48 166.79,140.3 166.55,140.3 v1(166.51,140.26) 166.64,140.13 v2(166.64,139.68) 166.64,139.38 166.72,139.29 R882.2
  IN2 w0.127: v1(74.61,141.77) 74.71,141.77 75.09,141.39 75.09,140.59 75.41,140.27 78.27,140.27 78.73,140.73 78.73,142.4 79.37,143.04 81.69,143.04 82.61,143.97 85.74,143.97 86.97,142.74 91.1,142.74 91.95,143.59 107.53,143.59 107.92,143.98 111.57,143.98 112.34,144.74 117.02,144.74 117.2,144.92 118.88,144.92 119.08,144.72 136.04,144.72 136.33,144.42 153.95,144.42 156.11,142.27 157.64,142.27 158.05,141.86 164.91,141.86 v1(166.51,140.26)
  BOTTOM w0.102: v1(74.61,141.77) 74.06,141.22 74.06,140.95 73.61,140.49 Q22.2
EN_LCDPWR: length 31.9
  TOP w0.102: v1(56.86,155.26) 56.56,155.55 55.95,155.55 55.74,155.76 JEDP1.24
  IN3 w0.127: v1(62.81,158.86) 62.39,158.45 62.39,157.32 61.78,156.71 58.61,156.71 57.16,155.26 v1(56.86,155.26) 56.86,153.48 57.42,152.92 59.88,152.92 63.69,149.11 65.12,149.11 67.19,147.04 v1(68.24,147.04)
  BOTTOM w0.102: v1(62.81,158.86) 62.81,158.92 v2(63.24,159.35) Q23.2 ; D53.1 68.9,147.67 68.84,147.73 Q20.2 67.47,147.14 D6.1 68.03,146.53 68.24,146.74 v1(68.24,147.04)
ENTRIP1: length 8.5
  BOTTOM w0.254: PQ106.6 270.75,66.5 270.93,66.68 271.43,66.68 271.63,66.49 271.63,65.12 PR107.1 272.39,63.73 v2(272.86,63.25) 273,63.12 274.74,63.12 274.95,62.91 PU101.1
ENTRIP2: length 15.7
  IN4 w0.254: v1(268.71,65.09) 275.18,65.09 277.47,62.8 v1(278.23,62.8)
  BOTTOM w0.254: PR106.2 279.25,63.79 278.85,63.4 ; v1(268.71,65.09) 269.45,64.34 PQ106.3 ; PU101.6 277.45,62.97 277.66,63.18 277.85,63.18 v1(278.23,62.8) 278.26,62.8 278.85,63.4 ; v2(278.85,63.39) 278.85,63.4
ENVDD_PCH: length 398.8
  TOP w0.102: v1(94.61,144.4) 94.61,144.22 91.81,141.42 91.81,140.08 91.58,139.84 91.58,135.19 91.96,134.81 91.96,127.83 90.8,126.67 90.8,121.97 90.14,121.31 90.14,118.35 91.5,116.99 91.5,115.04 91.2,114.73 v1(91.2,114.71) ; UH4.M45 23.04,125.76 22.77,125.76 22.75,125.73 v1(22.72,125.73)
  IN1 w0.109: v1(69.95,146.42) 73.52,146.42 73.9,146.04 78.49,146.04 78.88,145.64 80.29,145.64 82.83,143.1 85.14,143.1 86.07,142.16 92.38,142.16 v1(94.61,144.4) 95.09,144.4 100.16,149.47 100.16,151.47 101.28,152.59 102.6,152.59 103.68,153.67 103.68,156.14 107.54,160 108.11,160 116.59,168.48 126.91,168.48 127.3,168.09 127.3,160.49 129.18,158.61 131,158.61 131.38,158.23 132.7,158.23 133.92,157.01 133.92,155.87 134.21,155.58 136.55,155.58 137.21,156.24 143.8,156.24 144.31,155.73 148.98,155.73 149.68,156.43 151.66,156.43 158.82,163.59 172.24,163.59 173.46,162.37 174.85,162.37 175.88,161.34 179.49,161.34 v1(180.08,161.94)
  IN2 w0.102: 33.49,129.35 33.49,128.88 33.9,128.47 35.15,128.47 36.03,129.35 ; 24.9,129.15 23.13,127.38 23.13,126.14 v1(22.72,125.73)
  IN2 w0.127: v1(236.07,82.79) 236.07,82.92 234.31,84.67 232.38,84.67 228.29,88.76 227.38,88.76 217.93,98.21 217.93,99.79 213.25,104.47 211.94,104.47 211.21,105.19 211.21,133.02 212.09,133.9 212.09,152.79 211.3,153.58 210.93,153.58 208.42,156.1 208.42,156.27 207.06,157.63 201.81,157.63 196.4,163.04 194.27,163.04 193.91,162.69 180.83,162.69 v1(180.08,161.94) ; 33.49,129.35 33.49,130.1 32.19,131.39 30.48,131.39 29.39,130.31 26.74,130.31 25.59,129.15 24.9,129.15 ; 36.03,129.35 36.76,130.09 44.78,130.09 45.48,129.39 47.83,129.39 48.78,130.34 64.2,130.34 64.32,130.22 64.32,118.01 65.03,117.31 70.39,117.31 72.52,115.18 73.65,115.18 73.93,114.9 91.01,114.9 v1(91.2,114.71)
  IN3 w0.127: v1(234.55,75.84) 234.55,75.89 234.52,75.92 234.52,81.13 235.13,81.75 235.13,82.22 235.71,82.79 v1(236.07,82.79)
  BOTTOM w0.102: v1(234.55,75.84) 234.54,75.84 234.33,76.06 U46.B38 ; RH134.2 21.69,130.94 v2(22.06,130.57) 22.06,130.04 21.56,129.55 21.56,128.19 22.21,127.55 22.21,126.28 22.72,125.77 v1(22.72,125.73) ; D53.2 v1(69.95,146.42)
ER_EDP#: length 36.4
  TOP w0.102: JEDP1.17 59.24,158.2 60.65,159.61 60.65,160.5 v1(60.54,160.6)
  IN1 w0.109: v1(60.54,160.6) 62.09,162.15 70.63,162.15 v1(71.32,162.84)
  BOTTOM w0.102: Q13.3 70.57,154.85 69.39,156.03 69.39,157.54 70.14,158.3 Q12.3 71.48,158.3 71.8,158.62 71.8,158.8 72.71,159.7 74.29,159.7 76.58,161.99 76.58,163.13 76.3,163.41 v2(74.36,163.41) 74.01,163.41 73.45,162.84 R158.2 C255.1 v1(71.32,162.84)
ERC1:
  vias: v2(175.96,67.93)
ERC2: length 2.3
  TOP w0.254: PC1009.1 v2(181.04,71.95) 180.88,71.95 180.62,71.68 PU1001.13
ERC3: length 1.8
  TOP w0.102: v2(182.55,69.22) 181.76,70 PC1008.1
ESATA_PRX_DTX_N4_C: length 104.7
  TOP w0.102: v1(13.52,165.26) 13.52,165.74 C673.1 ; v6(27.66,107.05) 27.52,107.05 UH4.Y7
  IN4 w0.102: v6(27.66,107.05) 27.67,107.05 28.23,106.49 28.23,104.03 28.54,103.72 28.54,103.19
  IN4 w0.117: v1(13.52,165.26) 13.52,157.59 13.79,157.32 13.79,150.3 15.46,148.63 15.46,139.28 13.97,137.79 13.97,134.8 12.01,132.83 11.15,132.83 10.03,131.72 10.03,130.84 6.08,126.89 6.08,125.67 5.22,124.81 5.22,123.52 5.79,122.95 5.79,122.22 6.65,121.35 6.65,121.08 5.66,120.09 5.66,111.03 6.12,110.57 6.54,110.57 7.21,109.9 7.21,109.76 8.26,108.71 8.26,108.2 9.53,106.93 9.53,104.55 10.62,103.46 10.62,101.6 10.95,101.27 10.95,97.74 11.41,97.28 13.22,97.28 13.52,96.97 20.95,96.97 21.24,96.68 22.9,96.68 23.81,97.59 25.01,97.59 25.36,97.95 26.37,97.95 26.92,98.5 26.92,99.37 28,100.46 28,102.41 28.54,102.95 28.54,103.19
ESATA_PRX_DTX_P4_C: length 104.6
  TOP w0.102: UH4.Y5 27.19,106.75 27.19,106.48 27.25,106.41 27.66,106.41 v5(27.66,106.42) ; v3(14.41,165.26) 14.14,165.26 13.79,165.61 13.79,165.89 13.86,165.96 C674.1
  IN4 w0.102: v5(27.66,106.42) 27.74,106.5 27.84,106.5 27.96,106.38 27.96,103.91 28.27,103.61 28.27,103.31 28.26,103.3 28.26,103.21 28.25,103.21 28.25,103.19
  IN4 w0.117: v3(14.41,165.26) 14.17,165.26 13.81,164.9 13.81,157.7 14.08,157.44 14.08,150.41 15.75,148.74 15.75,139.17 14.25,137.67 14.25,134.68 12.12,132.55 11.26,132.55 10.31,131.6 10.31,130.72 6.36,126.77 6.36,125.55 5.5,124.69 5.5,123.64 6.07,123.07 6.07,122.34 6.94,121.47 6.94,120.96 5.95,119.97 5.95,111.15 6.23,110.86 6.65,110.86 7.5,110.01 7.5,109.87 8.55,108.83 8.55,108.32 9.82,107.05 9.82,104.67 10.91,103.58 10.91,101.71 11.24,101.38 11.24,97.85 11.53,97.56 13.33,97.56 13.64,97.26 21.06,97.26 21.36,96.97 22.78,96.97 23.7,97.88 24.89,97.88 25.25,98.24 26.25,98.24 26.63,98.62 26.63,99.49 27.72,100.58 27.72,102.53 28.25,103.06 28.25,103.19
ESATA_PTX_DRX_N4_C: length 106.2
  TOP w0.102: v1(12.13,165.26) 11.86,165.52 11.86,165.75 12.07,165.96 C672.1 ; v3(29.78,103.81) 29.73,103.81 29.49,104.05 29.49,104.69 29.17,105 UH4.AD3
  IN4 w0.102: 29.05,103.03 29.05,103.04 29.06,103.05 29.06,103.14 29.07,103.15 29.07,103.4 29.31,103.65 29.62,103.65 v3(29.78,103.81)
  IN4 w0.117: v1(12.13,165.26) 11.93,165.06 11.93,165.05 11.92,165.05 11.92,162.9 11.15,162.13 11.15,159.22 12.13,158.24 12.13,153.52 12.84,152.8 12.84,150.08 14.96,147.97 14.96,141.38 13.65,140.07 13.65,138.61 13.41,138.37 13.41,137.3 10.85,134.74 10.85,134.14 9.24,132.54 9.24,131.9 6.95,129.6 6.95,128.56 6.29,127.9 5.89,127.9 4.71,126.73 4.71,123.08 4.98,122.81 4.99,122.81 5.15,122.65 5.15,109.87 5.59,109.43 6.79,109.43 7.76,108.46 7.76,107.47 8.2,107.02 8.2,105.99 8.62,105.58 8.62,104.23 8.73,104.13 9.22,104.13 9.88,103.46 9.88,101.23 10.45,100.66 10.45,97.47 11.14,96.78 12.9,96.78 13.22,96.46 20.74,96.46 21.12,96.08 23.33,96.08 24.33,97.08 25.21,97.08 25.56,97.43 26.55,97.43 26.76,97.63 27.44,97.63 27.88,98.08 27.88,99.32 28.74,100.17 28.74,102.43 29.05,102.75 29.05,103.03
ESATA_PTX_DRX_P4_C: length 106.2
  TOP w0.102: UH4.AD1 29.17,103.73 29.77,103.14 v1(29.77,103.13) ; v3(11.49,165.26) 11.59,165.36 11.59,165.65 11.28,165.96 C671.1
  IN4 w0.102: 29.34,103.03 29.34,103.29 29.42,103.38 29.52,103.38 29.71,103.19
  IN4 w0.117: v3(11.49,165.26) 11.49,165.25 11.64,165.11 11.64,163.02 10.86,162.25 10.86,159.1 11.84,158.12 11.84,153.4 12.56,152.68 12.56,149.97 14.67,147.85 14.67,141.5 13.37,140.19 13.37,138.73 13.13,138.48 13.13,137.42 10.57,134.86 10.57,134.26 8.96,132.66 8.96,132.02 6.66,129.72 6.66,128.68 6.17,128.19 5.77,128.19 4.43,126.84 4.43,122.97 4.86,122.53 4.87,122.53 4.87,109.75 5.48,109.14 6.67,109.14 7.47,108.34 7.47,107.35 7.92,106.91 7.92,105.88 8.34,105.46 8.34,104.11 8.61,103.84 9.1,103.84 9.59,103.35 9.59,101.11 10.17,100.54 10.17,97.36 11.03,96.5 12.78,96.5 13.1,96.17 20.62,96.17 21,95.79 23.45,95.79 24.45,96.79 25.33,96.79 25.68,97.14 26.67,97.14 26.88,97.35 27.55,97.35 28.17,97.96 28.17,99.2 29.02,100.06 29.02,102.32 29.34,102.63 29.34,103.03 ; v1(29.77,103.13) 29.71,103.19
ESATA_USB_PWR_EN#: length 299.1
  TOP w0.102: U48.4 15.98,159.58 15.78,159.39 15.78,159.22 ; U48.5 15.92,159.08 15.78,159.22 ; 15.78,159.22 15.78,158.85 v1(16.23,158.4)
  IN1 w0.109: v1(225.79,84.3) 231,84.3 232.06,83.24 233.63,83.24 234.11,82.75 v1(234.11,82.74)
  IN2 w0.127: v1(237.23,76.09) 237.59,76.45 237.59,78.43 237.15,78.87 236.96,78.87 235.85,79.97 235.48,79.97 233.97,81.48 233.97,82.46 234.11,82.6 v1(234.11,82.74) ; v1(225.79,84.3) 225.79,84.75 223,87.54 219.36,87.54 216.41,90.49 209.65,90.49 206.26,93.88 206.26,94.98 205.15,96.08 205.15,96.68 204.6,97.23 202.64,97.23 201.99,97.88 200.63,97.88 197.72,100.79 197.72,101.8 195.86,103.66 195.86,105.08 196.18,105.4 196.18,106.71 195.15,107.73 195.15,110.61 191.89,113.86 191.89,137.56 187.2,142.25 185.41,142.25 184.99,141.83 184.42,141.83 v1(183.97,142.28)
  IN4 w0.109: v1(183.97,142.28) 181.91,140.22 177.77,140.22 176.92,141.07 173.79,141.07 173.38,140.67 173.38,139.69 172.6,138.91 165.73,138.91 164.35,140.3 164.35,140.69 162.52,142.52 162.43,142.52 161.81,143.14 161.81,143.81 160.43,145.19 159.59,145.19 159.56,145.16 158.35,145.16 157.01,146.51 155.23,146.51 154.08,147.66 154.08,149.32 147.17,156.24 142.41,156.24 139.83,153.66 127.96,153.66 127.95,153.68 116.44,153.68 116.01,153.24 110.92,153.24 110.35,153.81 107.99,153.81 107.45,153.28 105.08,153.28 104.41,152.6 97.46,152.6 95.45,150.6 86.13,150.6 85.54,150 82.38,150 81.07,151.31 77.9,151.31 73.8,155.41 72.44,155.41 68.17,159.68 67.27,159.68 66.9,159.31 64.76,159.31 62.19,161.87 51.87,161.87 51.65,161.66 45.65,161.66 44.36,160.36 20.6,160.36 18.64,158.4 v1(16.23,158.4)
  BOTTOM w0.102: v1(183.97,142.28) v2(183.97,141.61) ; U46.B44 237.33,76.19 v1(237.23,76.09) ; v1(234.11,82.74) 233.97,82.6 233.97,81.8 234.03,81.74 234.03,80.87 R769.2
EXPCLK_REQ#: length 120
  TOP w0.102: JIO1.54 37.23,29.95 v1(37.64,30.35) ; UH4.L12 22.34,110.18 22.34,110.39 v1(22.33,110.4)
  IN3 w0.102: 16.36,103.89 17.5,105.03 17.5,107.49 18.12,108.12 18.12,109.36 18.67,109.91 18.67,110.07 19.53,110.94 21.8,110.94 v1(22.33,110.4)
  IN3 w0.127: v1(37.64,30.35) 37.67,30.35 38.52,31.2 38.52,33.78 38.15,34.15 35.72,34.15 33.32,36.55 33.32,42.66 32.8,43.18 32.8,45.14 32.03,45.92 32.03,47.49 30.85,48.66 30.85,58.27 24.01,65.11 12.27,65.11 11.4,65.98 11.4,74.36 12.98,75.93 12.98,83.12 12.22,83.88 12.22,96.13 13.18,97.09 13.18,98.97 15.9,101.69 15.9,103.43 16.36,103.89
  IN4 w0.109: v1(22.33,110.4) 21.82,109.89 18.05,109.89 16.53,108.38 15.51,108.38 14.96,107.84 v1(14.96,107.77)
  BOTTOM w0.102: v2(15.4,108.55) 14.96,108.1 v1(14.96,107.77) 14.84,107.77 14.35,108.27 RH94.1
FAN1_PWM: length 261
  TOP w0.127: U18.20 145.45,160.58 145.85,160.19 v1(146.49,160.19) 146.85,159.83 R407.2
  IN4 w0.254: v1(2.28,84.15) 1.94,84.15 1.51,84.58 1.51,122.21 2.65,123.36 2.65,124.32 2.17,124.8 2.17,132.82 2.65,133.3 5.29,133.3 6.53,134.53 6.53,138.23 7.44,139.14 9.45,139.14 10.87,140.56 10.87,149.04 11.05,149.21 11.05,154.14 9.88,155.31 9.88,157.95 9.35,158.48 9.35,159.13 7.9,160.58 7.9,164.83 9.49,166.42 16.74,166.42 18.88,164.28 36.07,164.28 36.51,164.72 43.19,164.72 43.82,164.08 54.97,164.08 55.63,163.42 71.87,163.42 76.53,158.76 76.53,156.14 79.99,152.68 80.35,152.32 80.86,152.32 81.93,151.25 95.28,151.25 97.8,153.78 98.86,153.78 100.62,155.54 100.62,157.53 101.09,158 109.02,158 110.03,159.02 118.01,159.02 119.55,157.48 125.05,157.48 126.65,159.08 130.8,159.08 131.8,158.08 132.49,158.08 133.31,157.26 135.82,157.26 138.53,159.97 138.53,161.44 139.91,162.83 142.77,162.83 143.44,162.15 144.52,162.15 v1(146.49,160.19)
  BOTTOM w0.102: v2(12.65,83.65) JFAN1.2 2.79,83.65 v1(2.28,84.15)
FAN1_TACH_FB: length 270.8
  TOP w0.127: U18.15 145.68,158.08 v1(145.71,158.05) 145.71,157.73 146.12,157.32 149.51,157.32 R408.2
  IN4 w0.254: v1(2.35,83.4) 2.07,83.4 1.15,84.32 1.15,122.42 2.3,123.56 2.3,124.16 1.79,124.66 1.79,133.02 2.45,133.68 5.17,133.68 6.17,134.68 6.17,138.38 7.39,139.6 9.29,139.6 10.51,140.82 10.51,154.17 9.52,155.16 9.52,157.65 8.95,158.22 8.95,158.95 7.33,160.58 7.33,165.08 9.12,166.87 17.05,166.87 19.14,164.78 36.07,164.78 36.47,165.19 43.31,165.19 44.05,164.44 55.12,164.44 55.78,163.78 72.07,163.78 76.88,158.97 76.88,156.29 80.49,152.68 81,152.68 82.08,151.61 95.13,151.61 97.75,154.23 98.61,154.23 100.19,155.8 100.19,157.77 100.77,158.36 108.75,158.36 109.85,159.46 118.07,159.46 119.7,157.84 124.88,157.84 126.48,159.44 131.13,159.44 131.96,158.6 132.6,158.6 133.59,157.61 135.67,157.61 137.97,159.91 137.97,162 139.39,163.42 142.89,163.42 143.6,162.71 144.63,162.71 146.35,160.99 146.48,160.99 147.09,160.38 147.09,160.01 145.71,158.62 v1(145.71,158.05)
  BOTTOM w0.102: v1(2.35,83.4) 4.6,81.15 JFAN1.4 12.3,81.15 v2(12.57,80.87)
FAN2_PWM: length 143.4
  TOP w0.102: U18.13 145.36,157.08 146.26,156.17 146.79,156.17 R403.2 147.2,154.91 v2(146.3,154.01) 145.97,153.68 v1(145.97,153.1)
  IN2 w0.127: v1(145.97,153.1) 146.38,153.1 147.26,152.22 152.18,152.22 153.42,153.47 156.49,153.47 157.06,154.04 164.01,154.04 164.48,154.51 165.16,154.51 165.68,155.03 167.45,155.03 167.73,155.31 169.75,155.31 170.39,155.94 177.73,155.94 178.64,155.03 179.56,155.03 179.77,154.83 180.44,154.83 181.5,153.77 196.59,153.77 197.45,152.91 198.52,151.83 198.52,143.38 198.36,143.22 198.36,132.72 200.07,131 200.07,116.61 201.17,115.51 201.17,113.54 202.37,112.34 202.37,107.47 201.41,106.51 201.41,104.95 203.22,103.14 203.22,101.79 204.5,100.51 205.08,100.51 206.07,99.52 206.07,96.46 210.35,92.18 219.04,92.18 220.5,90.73 220.5,89.33 v1(220.48,89.32)
  BOTTOM w0.102: v1(220.48,89.32) 220.97,88.84 R213.2 221.89,88.47 222.39,88.96 D90.1
FAN2_PWM_D: length 14
  BOTTOM w0.102: JFAN2.2 225.89,81.58 225.89,82.6 223.99,84.51 223.59,84.51 223.39,84.3 222.63,84.3 221.61,85.32 220.94,85.32 v2(220.49,85.77) 220.14,85.77 219.71,86.21 R409.2 219.75,87.05 R213.1 221.44,87.05 D90.2
FAN2_TACH_FB: length 156.8
  TOP w0.102: v1(228.02,87.24) 228.01,87.24 v1(224.12,83.34)
  TOP w0.127: R405.2 146.66,157.8 v1(146.39,158.06) 145.88,158.58 U18.16
  IN2 w0.127: v1(228.02,87.24) 227.61,87.24 216.95,97.89 216.95,99.47 213.85,102.57 207.85,102.57 206.98,103.44 206.98,104.77 208.53,106.32 208.53,115.63 207,117.16 207,119.29 206.06,120.24 206.06,130.58 206.45,130.98 206.45,151.82 201.78,156.49 200.13,156.49 197.56,159.06 193.33,159.06 191.99,160.39 182.62,160.39 182.41,160.17 175.98,160.17 174.06,162.09 172.76,162.09 171.93,162.92 158.65,162.92 152.82,157.09 151.38,157.09 151.15,157.32 147.2,157.32 146.45,158.06 v1(146.39,158.06)
  BOTTOM w0.102: v1(224.12,83.34) 223.25,82.48 JFAN2.4 ; v2(228.13,88) 228.02,87.89 v1(228.02,87.24)
FB_3V: length 4.2
  BOTTOM w0.254: PU101.5 v2(276.95,63.42) 276.95,64.03 PR101.2 PC120.1 PR103.2
FB_5V: length 5.7
  BOTTOM w0.102: PR104.1 274.39,66.86 v2(273.96,67.29)
  BOTTOM w0.254: PR104.1 PC121.2 PR102.1 275.45,63.26 PU101.2
FB_+V1.05S_VCCPP: length 4.6
  BOTTOM w0.102: v2(56.46,26.41) PR511.2
  BOTTOM w0.254: PU501.4 56.55,24.35 PR512.1 ; PR508.2 PR512.1 ; PR512.1 PR511.2
FB_+V1.05SP: length 2.6
  TOP w0.254: PU401.4 4.21,155.98 PR408.2 PR407.2
FDI_CTX_PRX_N0: length 106.6
  TOP w0.089: v1(79.34,40.88) 79.9,41.44 JCPU1.A21
  TOP w0.102: UH4.BJ14 41.48,110.68 41.53,110.64 41.79,110.64 41.83,110.68 41.83,110.99 41.87,111.02 43.23,111.02 44.44,109.82 44.44,109.55 44.23,109.35 44.23,109.17 44.17,109.11 44,109.11 43.8,109.31 v3(43.8,109.42)
  IN4 w0.089: 74.63,78.38 74.64,78.37 75.8,77.22 75.8,68.64 75.41,68.25 75.41,53.58 74.88,53.05 74.88,50.82 74.23,50.18 74.23,49.77 73.89,49.43 73.89,48.72 73.73,48.57 73.19,48.57 72.85,48.22 72.85,43.46 71.79,42.4 71.79,41.58 72.14,41.23 73.97,41.23 75.13,40.07 77.55,40.07 77.78,40.3 77.85,40.36 77.85,40.36 78.57,41.08 79.14,41.08 v1(79.34,40.88)
  IN4 w0.117: v3(43.8,109.42) 44.21,109.02 44.21,108.75 44.56,108.4 45.16,108.4 46.77,106.78 49.5,106.78 49.62,106.9 50.4,106.9 50.93,106.37 56.1,106.37 58.07,104.39 58.46,104.39 58.46,104.4 59.15,104.4 60.54,103.01 61.3,103.01 62.98,101.32 62.98,100.79 63.89,99.89 64.87,99.89 65.32,99.43 66.74,99.43 71.04,95.14 71.77,95.14 72.72,94.19 72.72,93.35 73.24,92.83 73.24,91.03 74.33,89.95 74.33,78.69 74.63,78.38
FDI_CTX_PRX_N1: length 132.4
  TOP w0.089: JCPU1.H19 81.9,48.35 v1(81.47,47.92)
  TOP w0.102: v6(37.76,110.38) 37.37,110.77 UH4.AY14
  IN4 w0.081: 85.58,39.69 85.57,39.69
  IN4 w0.089: v1(81.47,47.92) 81.5,47.92 81.64,48.06 81.64,48.15 82.01,48.52 85.59,48.52 86,48.11 86,40.12 85.58,39.69 ; 85.57,39.69 83.6,37.72 83.6,37.34 81.02,34.76 70.15,34.76 65.7,39.22 65.7,51.12 66.15,51.58 67.58,51.58 67.75,51.75 67.75,54.1 67.8,54.15 67.8,55.25 68.12,55.57 68.52,55.57 68.81,55.85 68.81,67.33 68.76,67.38 68.76,75.3 65.83,78.23 65.83,78.23
  IN4 w0.102: 38.73,108.03 38.73,108.04 38.73,108.05 38.73,108.12 38.74,108.13 38.74,108.61 38.18,109.17 38.18,110 37.81,110.38 v6(37.76,110.38)
  IN4 w0.117: 38.73,108.03 38.73,105.76 42.1,102.38 42.1,101.48 43.4,100.18 45.5,100.18 46.03,100.72 49.06,100.72 49.52,100.26 52.47,100.26 56.61,96.12 58.39,96.12 61.05,93.45 61.4,93.45 64.32,90.53 64.32,81.59 65.71,80.21 65.71,78.35 65.83,78.23
FDI_CTX_PRX_N2: length 113.8
  TOP w0.089: v3(81.44,44.94) 81.9,45.4 JCPU1.E19
  TOP w0.102: UH4.BE14 39.27,110.62 39.01,110.36 39.01,110.35 v1(39,110.34)
  IN4 w0.089: 73.56,78.55 73.56,78.4 74.49,77.46 74.56,77.4 74.58,77.4 74.78,77.2 74.78,77.15 74.78,77.15 74.78,76.83 74.78,76.83 74.78,76.06 74.78,76.06 74.78,75.73 74.78,75.73 74.78,75.13 74.79,75.12 74.79,74.8 74.78,74.79 74.78,74.11 74.79,74.1 74.79,73.78 74.78,73.78 74.78,73.11 74.79,73.11 74.79,72.79 74.78,72.78 74.78,72.1 74.78,72.1 74.78,71.78 74.78,71.78 74.78,71.1 74.79,71.09 74.79,70.77 74.78,70.77 74.78,69.07 74.78,69.07 74.78,68.75 74.78,68.74 74.78,68.13 74.8,68.11 74.8,67.86 74.88,67.78 74.88,53.72 73.43,52.27 73.43,51.7 72.93,51.21 72.93,49.76 72.72,49.54 72.7,49.54 72.21,49.54 71.92,49.25 71.92,48.69 71.73,48.5 71.73,43.16 71.08,42.51 71.08,41.46 73.32,39.23 78.55,39.23 78.81,39.48 79.07,39.74 79.07,39.88 79.34,40.16 79.52,40.16 80.1,40.73 80.16,40.79 80.16,41.41 80,41.56 80,42.2 79.84,42.37 79.84,42.6 79.96,42.73 79.96,43.22 80.07,43.33 80.2,43.33 80.2,43.33 80.61,43.33 81.02,43.74 81.02,45.04 81.12,45.14 81.23,45.14 v3(81.44,44.94)
  IN4 w0.102: 42.77,108.46 42.68,108.46 42.67,108.48 42.17,108.48 40.89,109.75 40.88,109.75 40.51,109.75 40.44,109.83 39.83,109.83 39.82,109.84 39.59,109.84 39.1,110.33 39.01,110.33 v1(39,110.34)
  IN4 w0.117: 73.56,78.55 73.56,82.07 73,82.64 73,84.02 73.49,84.5 73.49,89.07 71.5,91.05 71.5,92.48 71.05,92.94 71.05,93.52 67.09,97.47 66.46,97.47 65.93,98 65.93,98.39 65.62,98.7 64.99,98.7 64.54,99.15 63.23,99.15 60.4,101.98 58.63,101.98 56.18,104.43 56.18,105.2 55.89,105.5 54.52,105.5 54.19,105.17 53.58,105.17 53.14,105.61 48.62,105.61 48.21,106.03 46.36,106.03 44.72,107.66 44.25,107.66 43.44,108.46 42.77,108.46
FDI_CTX_PRX_N3: length 123.9
  TOP w0.089: JCPU1.F18 82.78,46.45 v1(82.26,45.93)
  TOP w0.102: v1(44.23,102.36) 44.23,102.68 44.19,102.72 43.9,102.72 43.78,102.85 43.78,103.4 44.55,104.18 44.55,105.04 44.72,105.21 44.72,107.71 43.32,109.11 43.32,109.98 42.87,110.43 41.43,110.43 41.29,110.58 41.21,110.58 UH4.BH13
  IN4 w0.089: v1(82.26,45.93) 82.1,45.93 81.9,46.13 81.9,46.37 82.05,46.51 82.53,46.51 82.65,46.39 82.65,45.6 82.89,45.36 83.57,45.36 83.79,45.13 83.79,40.48 80.85,37.54 80.85,37.01 80.31,36.46 72.42,36.46 68.01,40.87 68.01,50.1 68.25,50.34 68.68,50.34 68.98,50.65 68.98,52.19 69.2,52.4 69.84,52.4 70,52.56 70,55.1 70.29,55.39 70.67,55.39 70.98,55.7 70.98,76.51 69.6,77.88 68.76,77.88 68.09,78.55
  IN4 w0.117: v1(44.23,102.36) 44.21,102.36 44.02,102.18 44.02,102.04 44.16,101.9 44.58,101.9 45.21,102.53 50.18,102.53 50.61,102.09 53.2,102.09 55.11,100.18 55.71,100.18 56.25,99.63 57.03,99.63 57.52,99.15 58.16,99.15 59.49,97.83 60.02,97.83 63.24,94.6 64.65,94.6 66.42,92.83 66.42,92.25 66.99,91.68 66.99,87.58 67.24,87.33 67.24,85.51 67.91,84.84 67.91,78.73 68.09,78.55
FDI_CTX_PRX_N4: length 109.7
  TOP w0.089: JCPU1.B21 79.9,42.46 v1(80.37,42.93)
  TOP w0.102: UH4.BC12 38.64,109.69 38.9,109.43 v6(38.9,109.41)
  IN4 w0.089: 71.7,78.55 71.7,78.38 72.68,77.4 72.68,77.14 73.8,76.02 73.8,68.98 73.8,68.98 73.8,66.04 73.79,66.03 73.79,64.63 73.8,64.63 73.8,59.6 73.8,59.6 73.8,53.28 72.92,52.4 72.92,51.83 72.66,51.57 72.28,51.57 70.9,50.2 70.9,43.33 70.46,42.89 70.46,41.09 73.01,38.53 78.84,38.53 79.75,39.44 79.75,39.83 80.06,40.15 80.61,40.7 81.15,41.24 81.15,42.15 v1(80.37,42.93)
  IN4 w0.102: 40.71,108.61 40.05,108.61 39.86,108.8 39.39,108.8 39.08,109.1 39.08,109.23 v6(38.9,109.41)
  IN4 w0.117: 40.71,108.61 41.61,107.71 43.12,107.71 43.92,106.91 44.41,106.91 46.04,105.29 47.9,105.29 48.44,104.75 52.3,104.75 52.85,104.2 54.54,104.2 57.1,101.63 57.93,101.63 58.38,101.17 59.4,101.17 60.1,100.47 60.75,100.47 62.8,98.42 63.65,98.42 64.29,97.78 64.82,97.78 65.88,96.72 66.71,96.72 70.25,93.18 70.25,90.52 71.01,89.76 71.01,86.47 71.7,85.78 71.7,78.55
FDI_CTX_PRX_N5: length 111.6
  TOP w0.089: v1(81.42,43.95) 80.93,43.45 JCPU1.C20
  TOP w0.102: v1(43.75,105.79) 43.89,105.79 44,105.91 44,107.38 42.76,108.62 42.76,109.37 42.31,109.82 41.58,109.82 UH4.BJ12
  IN4 w0.089: 70.91,78.55 70.91,77.61 72.8,75.72 72.8,54.7 72.63,54.54 72.22,54.54 72.04,54.36 72.04,54.36 71.85,54.17 71.85,53.43 71.9,53.38 71.9,51.8 71.65,51.54 71.24,51.54 70.9,51.21 70.9,50.78 70.89,50.76 70.88,50.76 70.7,50.58 70.23,50.58 69.9,50.24 69.9,40.62 72.74,37.78 79.22,37.78 81.72,40.29 81.72,42.11 82.14,42.52 82.14,43.31 81.81,43.64 81.48,43.64 81.42,43.69 v1(81.42,43.95)
  IN4 w0.117: v1(43.75,105.79) 43.76,105.8 44.47,105.8 45.73,104.54 47.61,104.54 48.19,103.97 51.53,103.97 52.08,103.42 53.75,103.42 55.14,102.02 55.62,102.02 56.76,100.88 57.63,100.88 58.08,100.44 58.74,100.44 59.84,99.34 60.74,99.34 62.39,97.68 63.24,97.68 63.94,96.99 63.94,96.94 64.89,95.99 66.38,95.99 67.67,94.7 67.67,92.86 68.38,92.15 68.38,88.78 69.59,87.57 69.59,86.46 70.91,85.15 70.91,78.55
FDI_CTX_PRX_N6: length 116.1
  TOP w0.089: JCPU1.D18 82.78,44.45 v3(82.28,43.95)
  TOP w0.102: UH4.BG10 40.71,109.04 41.09,109.04 41.45,109.4 42.06,109.4 42.23,109.23 42.23,108.55 43.2,107.58 43.2,106.65 43.17,106.61 43.17,105.74 43.83,105.08 43.83,104.52 v1(43.86,104.48)
  IN4 w0.089: 69.86,78.42 69.86,78.35 71.99,76.22 71.99,55.63 71.71,55.35 71.26,55.35 71.02,55.11 71.02,53.37 71.07,53.31 71.07,51.74 70.72,51.38 70.33,51.38 70.09,51.14 70.09,50.7 69.76,50.37 69.32,50.37 69.3,50.35 69.27,50.35 69.03,50.1 69.03,40.82 72.67,37.18 79.46,37.18 82.7,40.42 82.7,44.25 82.52,44.43 82.32,44.43 82.23,44.53 81.98,44.53 81.85,44.4 81.85,44.07 81.98,43.95 v3(82.28,43.95)
  IN4 w0.117: v1(43.86,104.48) 43.69,104.31 43.69,103.95 44.14,103.51 45.88,103.51 46.09,103.3 50.46,103.3 50.89,102.87 53.56,102.87 55.3,101.13 55.81,101.13 56.55,100.38 57.39,100.38 57.87,99.9 58.52,99.9 59.69,98.73 60.25,98.73 63.64,95.34 66.28,95.34 67.15,94.47 67.15,92.63 67.88,91.91 67.88,88.57 68.65,87.8 68.65,85.6 69.86,84.39 69.86,78.42
FDI_CTX_PRX_N7: length 124
  TOP w0.089: JCPU1.E17 83.86,45.45 v3(83.33,45.97)
  TOP w0.102: v1(42.54,104.49) 42.54,106.65 42.77,106.88 42.77,107.43 41.66,108.53 41.38,108.53 41.16,108.75 40.85,108.75 40.53,108.43 UH4.BG9
  IN4 w0.089: 67.07,78.4 67.07,78.36 68.85,76.58 69.75,76.58 69.98,76.35 69.98,55.73 69.63,55.38 69.22,55.38 69,55.16 69,53.47 68.98,53.46 68.98,52.74 68.34,52.1 68.34,51.5 67.89,51.06 67.89,50.68 67.58,50.37 67.08,50.37 66.98,50.26 66.98,41.13 67,41.11 67,41.05 66.99,41.04 66.99,40.78 72.06,35.71 80.67,35.71 81.62,36.66 81.62,37.09 84.52,40 84.52,45.22 84.51,45.24 84.51,45.29 84.75,45.53 84.75,46.14 84.55,46.33 84.07,46.33 83.76,46.64 83.6,46.64 83.48,46.52 83.21,46.52 83.08,46.39 83.08,46.1 83.21,45.97 v3(83.33,45.97)
  IN4 w0.117: 67.07,78.4 66.7,78.77 66.7,84.19 65.5,85.39 65.5,87.46 65.51,87.46 65.51,90.87 65.16,91.22 65.16,92.94 64.24,93.87 62.9,93.87 59.85,96.92 59.34,96.92 59.1,97.16 57.14,97.16 56.91,97.39 56.91,98.52 56.56,98.87 55.95,98.87 55.66,99.16 54.99,99.16 52.83,101.32 50.28,101.32 49.9,101.7 45.49,101.7 44.95,101.17 43.85,101.17 43.1,101.91 43.1,102.77 42.14,103.73 42.14,104.14 42.23,104.23 42.23,104.23 42.48,104.49 v1(42.54,104.49)
FDI_CTX_PRX_P0: length 106.5
  TOP w0.089: v3(79.4,41.9) 78.95,41.45 JCPU1.A22
  TOP w0.102: UH4.BG14 40.74,111.05 41.18,111.05 41.38,111.24 43.32,111.24 44.65,109.91 44.65,109.16 v1(44.66,109.14)
  IN4 w0.089: 74.8,78.55 75.99,77.36 75.99,68.52 75.61,68.14 75.61,53.49 75.08,52.96 75.08,50.74 74.46,50.11 74.46,49.7 74.1,49.33 74.1,48.63 73.82,48.36 73.3,48.36 73.06,48.12 73.06,43.38 71.99,42.32 71.99,41.67 72.22,41.44 74.05,41.44 75.22,40.28 77.47,40.28 77.63,40.44 77.7,40.51 77.7,40.51 78.47,41.29 79.42,41.29 79.54,41.4 79.54,41.76 v3(79.4,41.9)
  IN4 w0.117: v1(44.66,109.14) 44.65,109.14 44.44,108.94 44.44,108.84 44.66,108.63 45.26,108.63 46.87,107.02 49.41,107.02 49.52,107.13 50.5,107.13 51.03,106.6 56.2,106.6 58.17,104.63 58.22,104.63 58.22,104.64 59.24,104.64 60.64,103.24 61.4,103.24 63.22,101.42 63.22,100.89 63.99,100.12 64.96,100.12 65.42,99.67 66.84,99.67 71.14,95.37 71.87,95.37 72.96,94.29 72.96,93.45 73.48,92.93 73.48,91.13 74.56,90.05 74.56,78.79 74.8,78.55
FDI_CTX_PRX_P1: length 132.5
  TOP w0.089: v1(82.33,47.92) 82.15,47.92 81.9,47.68 JCPU1.G19
  TOP w0.102: UH4.BB14 38,110.77 v1(38.39,110.38)
  IN4 w0.081: 85.43,39.84 85.28,39.69
  IN4 w0.089: 85.43,39.84 85.79,40.2 85.79,48.02 85.47,48.33 82.13,48.33 81.88,48.08 81.88,47.74 81.67,47.54 81.67,47.42 81.75,47.35 82.15,47.35 82.38,47.57 82.38,47.86 v1(82.33,47.92) ; 85.28,39.69 83.39,37.81 83.38,37.81 83.37,37.79 83.37,37.44 80.9,34.97 70.24,34.97 65.9,39.3 65.9,51.03 66.25,51.37 67.64,51.37 67.95,51.68 67.95,54.02 68,54.07 68,55.16 68.2,55.36 68.61,55.36 69,55.75 69,67.46 68.96,67.5 68.96,75.4 66.24,78.12 66.24,78.16
  IN4 w0.102: v1(38.39,110.38) 38.4,110.36 38.4,109.26 38.96,108.7 38.96,108.03
  IN4 w0.117: 66.24,78.16 65.94,78.45 65.94,80.31 64.56,81.69 64.56,90.63 61.5,93.69 61.15,93.69 58.49,96.36 56.7,96.36 52.56,100.5 49.62,100.5 49.16,100.95 45.93,100.95 45.4,100.42 43.5,100.42 42.34,101.58 42.34,102.48 38.96,105.86 38.96,108.03
FDI_CTX_PRX_P2: length 113.8
  TOP w0.089: v1(81.41,45.81) 81.05,45.45 JCPU1.E20
  TOP w0.102: UH4.BF14 39.91,110.61 39.7,110.4 v1(39.66,110.4)
  IN4 w0.089: 73.8,78.55 73.8,78.46 74.64,77.61 74.66,77.61 74.99,77.28 74.99,77.24 74.99,77.24 74.99,76.74 74.99,76.74 74.99,76.14 74.99,76.14 74.99,75.65 74.99,75.65 74.99,75.21 74.99,75.21 74.99,74.71 74.99,74.71 74.99,74.2 74.99,74.19 74.99,73.7 74.99,73.69 74.99,73.2 74.99,73.19 74.99,72.7 74.99,72.69 74.99,72.19 74.99,72.19 74.99,71.69 74.99,71.69 74.99,71.18 74.99,71.18 74.99,70.68 74.99,70.68 74.99,69.15 74.99,69.15 74.99,68.66 74.99,68.66 74.99,68.22 75.01,68.2 75.01,67.94 75.08,67.87 75.08,53.63 73.64,52.19 73.64,51.62 73.14,51.12 73.14,49.67 72.81,49.33 72.61,49.33 72.61,49.34 72.37,49.34 72.36,49.33 72.29,49.33 72.13,49.17 72.13,48.61 71.94,48.42 71.94,43.07 71.29,42.42 71.29,41.55 72.42,40.42 72.44,40.42 73.42,39.43 78.47,39.43 78.66,39.63 78.86,39.83 78.86,39.97 79.26,40.37 79.44,40.37 79.95,40.88 79.95,41.32 79.81,41.47 79.81,42.1 79.63,42.28 79.63,42.69 79.75,42.81 79.75,43.31 79.98,43.54 80.11,43.54 80.12,43.54 80.52,43.54 80.81,43.83 80.81,45.12 81.04,45.35 81.48,45.35 81.58,45.45 81.58,45.63 v1(81.41,45.81)
  IN4 w0.102: v1(39.66,110.4) 39.58,110.33 39.58,110.16 39.68,110.06 39.91,110.06 39.93,110.05 40.35,110.05 40.53,110.05 40.6,109.98 40.8,109.98 40.98,109.98 42.26,108.7 42.58,108.7 42.77,108.7
  IN4 w0.117: 73.8,78.55 73.8,82.17 73.23,82.73 73.23,83.92 73.72,84.4 73.72,89.17 71.74,91.15 71.74,92.58 71.28,93.03 71.28,93.62 67.19,97.71 66.56,97.71 66.17,98.1 66.17,98.49 65.72,98.93 65.09,98.93 64.64,99.39 63.33,99.39 60.5,102.22 58.73,102.22 56.42,104.53 56.42,105.3 55.99,105.74 54.43,105.74 54.1,105.41 53.67,105.41 53.24,105.84 48.72,105.84 48.3,106.26 46.46,106.26 44.82,107.89 44.34,107.89 43.54,108.7 42.77,108.7
FDI_CTX_PRX_P3: length 123.9
  TOP w0.089: JCPU1.G18 82.66,47.45 82.4,47.18 v3(82.4,46.94)
  TOP w0.102: UH4.BG13 40.43,110.22 40.71,110.22 40.84,110.1 41.18,110.1 41.3,110.22 42.78,110.22 43.1,109.89 43.1,109.02 44.5,107.62 44.5,105.3 44.33,105.13 44.33,104.27 43.56,103.49 43.56,102.76 43.57,102.74 v1(43.57,102.39)
  IN4 w0.089: 67.92,78.38 68.63,77.67 69.5,77.67 70.78,76.39 70.78,55.79 70.59,55.6 70.2,55.6 69.8,55.2 69.8,52.72 69.69,52.61 69.12,52.61 68.78,52.27 68.78,50.76 68.58,50.56 68.12,50.56 67.82,50.25 67.82,50.21 67.8,50.19 67.8,40.78 72.33,36.25 80.39,36.25 81.06,36.92 81.06,37.45 84,40.39 84,45.22 83.65,45.57 82.98,45.57 82.86,45.69 82.86,46.48 v3(82.4,46.94)
  IN4 w0.117: 67.92,78.38 67.68,78.63 67.68,84.74 67,85.42 67,87.23 66.75,87.48 66.75,91.58 66.18,92.16 66.18,92.73 64.55,94.37 63.15,94.37 59.92,97.59 59.39,97.59 58.07,98.91 57.42,98.91 56.94,99.4 56.16,99.4 55.61,99.94 55.01,99.94 53.1,101.85 50.52,101.85 50.08,102.29 45.3,102.29 44.68,101.66 44.06,101.66 43.79,101.94 43.79,102.17 v1(43.57,102.39)
FDI_CTX_PRX_P4: length 109.8
  TOP w0.089: v1(80.4,41.95) 80.9,42.45 JCPU1.B20
  TOP w0.102: v1(39.65,109.44) 39.65,109.49 39.27,109.86 UH4.BE12
  IN4 w0.089: v1(80.4,41.95) 80.28,42.08 80.28,42.37 80.34,42.44 80.57,42.44 80.94,42.06 80.94,41.32 80.52,40.91 79.91,40.29 79.54,39.92 79.54,39.53 78.76,38.74 73.09,38.74 70.67,41.17 70.67,42.8 71.11,43.25 71.11,50.11 71.35,50.35 71.81,50.35 72.12,50.66 72.12,51.13 72.36,51.37 72.75,51.37 73.13,51.75 73.13,52.32 74.01,53.2 74.01,59.68 74,59.69 74,64.71 74,64.72 74,65.95 74.01,65.96 74.01,68.98 74.01,69.07 74.01,69.07 74.01,69.24 74.01,69.25 74.01,75.93 74.01,75.93 74.01,76.1 72.88,77.23 72.88,77.6 71.93,78.55
  IN4 w0.102: v1(39.65,109.44) 39.4,109.44 39.3,109.34 39.3,109.2 39.48,109.02 39.95,109.02 40.14,108.83 40.61,108.83 40.62,108.83 40.81,108.83 40.86,108.79 40.87,108.79 40.88,108.77
  IN4 w0.117: 71.93,78.55 71.93,85.88 71.25,86.56 71.25,89.86 70.49,90.62 70.49,93.27 66.81,96.96 65.98,96.96 64.92,98.02 64.39,98.02 63.75,98.65 62.9,98.65 60.85,100.71 60.2,100.71 59.5,101.41 58.48,101.41 58.02,101.87 57.2,101.87 54.63,104.43 52.95,104.43 52.4,104.99 48.54,104.99 48,105.52 46.14,105.52 44.51,107.15 44.02,107.15 43.22,107.95 41.7,107.95 40.88,108.77
FDI_CTX_PRX_P5: length 111.7
  TOP w0.089: JCPU1.C19 81.85,43.45 81.42,43.02 v3(81.42,42.96)
  TOP w0.102: v1(43.57,106.44) 43.65,106.44 43.79,106.58 43.79,107.29 42.54,108.53 42.54,109.28 42.23,109.6 41.32,109.6 41.19,109.73 40.91,109.73 40.88,109.7 40.69,109.7 40.59,109.8 UH4.BG12
  IN4 w0.089: 71.14,78.55 71.14,77.73 72.99,75.88 72.99,54.6 72.72,54.33 72.31,54.33 72.04,54.07 72.04,53.6 72.1,53.55 72.1,51.72 71.73,51.35 71.32,51.35 71.09,51.13 71.09,50.67 70.79,50.37 70.32,50.37 70.09,50.14 70.09,40.73 72.83,37.99 79.13,37.99 81.52,40.37 81.52,42.2 81.93,42.61 81.93,43.23 81.72,43.43 81.34,43.43 81.21,43.31 81.21,43.16 v3(81.42,42.96)
  IN4 w0.117: 71.14,78.55 71.14,85.25 69.83,86.56 69.83,87.67 68.61,88.88 68.61,92.25 67.91,92.96 67.91,94.79 66.48,96.22 64.98,96.22 64.17,97.04 64.17,97.08 63.33,97.92 62.49,97.92 60.84,99.58 59.93,99.58 58.84,100.67 58.18,100.67 57.73,101.12 56.86,101.12 55.72,102.26 55.24,102.26 53.85,103.65 52.18,103.65 51.62,104.2 48.28,104.2 47.71,104.78 45.83,104.78 44.57,106.04 44.13,106.04 43.73,106.44 v1(43.57,106.44)
FDI_CTX_PRX_P6: length 116
  TOP w0.089: JCPU1.D19 82.1,44.45 82.28,44.63 v1(82.28,44.94)
  TOP w0.102: UH4.BJ10 41.48,109.13 41.54,109.18 41.97,109.18 42.02,109.14 42.02,108.98 41.95,108.92 41.87,108.92 41.81,108.85 41.81,108.67 42.99,107.49 42.99,106.74 42.95,106.7 42.95,105.65 43.56,105.04 43.56,104.97 43.51,104.92 43.38,104.92 43.24,105.05 43,105.05 42.9,104.95 42.9,104.67 43.06,104.51 v1(43.23,104.51)
  IN4 w0.089: v1(82.28,44.94) 82.28,44.77 82.39,44.66 82.59,44.66 82.61,44.65 82.85,44.41 82.91,44.34 82.91,40.33 79.55,36.97 72.58,36.97 68.82,40.73 68.82,50.19 69.19,50.56 69.66,50.56 69.89,50.79 69.89,51.27 70.19,51.57 70.64,51.57 70.88,51.82 70.88,53.19 70.81,53.27 70.81,55.19 71.17,55.56 71.62,55.56 71.79,55.72 71.79,76.09 69.63,78.25 69.63,78.47
  IN4 w0.117: v1(43.23,104.51) 43.45,104.29 43.45,103.86 44.04,103.27 45.79,103.27 45.99,103.06 50.36,103.06 50.79,102.63 53.47,102.63 55.21,100.89 55.71,100.89 56.45,100.15 57.29,100.15 57.77,99.66 58.42,99.66 59.6,98.49 60.15,98.49 63.54,95.1 66.18,95.1 66.92,94.37 66.92,92.54 67.64,91.81 67.64,88.48 68.42,87.7 68.42,85.5 69.63,84.29 69.63,78.47
FDI_CTX_PRX_P7: length 124
  TOP w0.089: v1(83.31,46.92) 83.31,46.9 83.76,46.45 JCPU1.F17
  TOP w0.102: UH4.BH9 40.96,108.43 40.79,108.26 40.79,108.16 40.99,107.96 41.09,107.96 41.44,108.32 41.57,108.32 42.55,107.34 42.55,106.97 42.32,106.74 42.32,105.01 42.21,104.9 41.84,104.9 41.76,104.81 41.76,104.62 41.89,104.49 v1(41.9,104.49)
  IN4 w0.089: v1(83.31,46.92) 83.31,46.91 83.37,46.85 83.85,46.85 84.16,46.54 84.64,46.54 84.95,46.23 84.95,45.44 84.95,45.44 84.95,45.35 84.73,45.14 84.73,39.92 81.82,37.01 81.82,36.58 80.75,35.5 80.69,35.5 71.97,35.5 66.78,40.7 66.78,41.12 66.79,41.13 66.79,50.37 66.98,50.56 67.47,50.56 67.7,50.79 67.7,51.14 67.93,51.37 67.93,51.37 68.15,51.58 68.15,52.19 68.79,52.83 68.79,53.59 68.81,53.61 68.81,55.29 69.1,55.58 69.55,55.58 69.79,55.82 69.79,76.19 69.62,76.37 68.77,76.37 66.9,78.23
  IN4 w0.117: 66.9,78.23 66.46,78.67 66.46,84.09 65.26,85.29 65.26,87.56 65.27,87.56 65.27,90.78 64.93,91.12 64.93,92.84 64.14,93.63 62.8,93.63 59.75,96.69 59.24,96.69 59,96.93 57.05,96.93 56.68,97.3 56.68,98.42 56.47,98.63 55.86,98.63 55.56,98.93 54.89,98.93 52.73,101.08 50.18,101.08 49.8,101.47 45.59,101.47 45.05,100.93 43.75,100.93 42.87,101.81 42.87,102.67 41.9,103.64 v1(41.9,104.49)
FDI_FSYNC0: length 143.8
  TOP w0.089: JCPU1.J18 82.9,49.46 v1(83.36,49.92)
  TOP w0.102: v1(36.65,109.73) 36.61,109.77 36.29,109.77 UH4.AV12
  IN4 w0.089: 88.4,39.75 88.4,39.92 88.82,40.33 88.82,41.07 88.73,41.15 88.73,50.07 88.47,50.33 86.09,50.33 85.9,50.52 83.96,50.52 v1(83.36,49.92) ; 63.73,49.26 64.65,50.19 64.65,54.17 65.06,54.58 65.61,54.58 65.77,54.74 65.77,55.2 66.13,55.56 66.47,55.56 66.73,55.81 66.73,70.67 65.23,72.17 65.23,72.58
  IN4 w0.109: 65.23,72.58 65.23,73.04 60.86,77.41 60.86,83.46 62.63,85.24 62.63,89.53 59.1,93.07 57.08,93.07 52.38,97.77 49.93,97.77 49.04,98.66 42.47,98.66 39.65,101.49 39.65,102.45 36.1,105.99 36.1,109.19 v1(36.65,109.73) ; 88.4,39.75 88.4,39.41 83.46,34.47 83.46,33.66 82.47,32.66 67.44,32.66 63.32,36.78 63.32,48.86 63.73,49.26
FDI_FSYNC1: length 139
  TOP w0.089: v3(84.43,49.99) 83.9,49.46 JCPU1.J17
  TOP w0.102: UH4.BC10 38.64,108.7 v1(38.33,108.4)
  IN4 w0.089: 63.89,48.68 64.84,49.63 64.84,54.08 65.14,54.38 65.69,54.38 65.97,54.66 65.97,55.14 66.21,55.37 66.55,55.37 66.91,55.73 66.91,70.76 65.58,72.09 65.58,72.94 ; 87.27,39.82 87.27,41.14 87.72,41.58 87.72,49.31 87.51,49.52 86.13,49.52 85.91,49.73 85.91,50.05 85.62,50.34 84.79,50.34 v3(84.43,49.99)
  IN4 w0.109: 63.89,48.68 63.89,37.11 67.74,33.26 82.24,33.26 82.93,33.95 82.93,34.65 87.27,38.99 87.27,39.82 ; v1(38.33,108.4) 38.33,108.6 37.97,108.95 37.5,108.95 37.21,108.66 37.21,106.97 37.12,106.88 37.12,105.82 40.55,102.39 40.55,101.58 42.95,99.17 51.69,99.17 57.2,93.66 59.22,93.66 63.23,89.65 63.23,81.66 62.66,81.09 62,81.09 61.63,80.72 61.63,77.56 65.58,73.61 65.58,72.94
FDI_INT: length 156.8
  TOP w0.089: v3(81.42,48.97) 81.13,48.97 80.9,48.74 JCPU1.H20
  TOP w0.102: UH4.AW16 36.73,111.69 36.41,111.37 36.41,110.47 36.51,110.36 v1(36.51,110.34)
  IN4 w0.089: 64.87,71.11 65.71,70.27 65.71,67.09 65.72,67.08 65.72,66.76 65.71,66.75 65.71,66.09 65.72,66.08 65.72,65.75 65.71,65.74 65.71,61.13 65.71,61.13 65.71,60.81 65.71,60.8 65.71,55.81 65.51,55.61 64.76,55.61 64.1,54.95 64.1,54.93 64.09,54.92 64.09,51.13 63.73,50.76
  IN4 w0.109: 63.73,50.76 62.2,49.24 62.2,35.78 66.44,31.53 83.01,31.53 84.78,33.31 84.78,34.35 89.96,39.53 89.96,49.89 89.5,50.35 89.19,50.35 88.83,50.7 86.26,50.7 86.07,50.89 83.02,50.89 81.84,49.71 81.84,49.29 81.52,48.97 v3(81.42,48.97) ; 64.87,71.11 64.2,71.78 64.2,72.26 59.79,76.67 59.79,83.97 61.62,85.8 61.62,88.96 58.61,91.97 56.74,91.97 52.1,96.61 48.8,96.61 47.77,97.65 41.92,97.65 40.33,99.24 39.44,99.24 36.51,102.17 36.51,102.92 34.02,105.41 34.02,108.4 34.17,108.55 34.17,109.22 35.03,110.07 35.03,110.43 35.34,110.74 36.1,110.74 v1(36.51,110.34)
FDI_LSYNC0: length 149.4
  TOP w0.089: JCPU1.J19 81.93,49.45 v1(82.4,48.98)
  TOP w0.102: v6(35.58,110.33) 36.07,110.82 UH4.AV14
  IN4 w0.089: v1(82.4,48.98) 82.03,49.35 82.03,49.62 83.11,50.7 85.97,50.7 86.17,50.51 88.55,50.51 88.93,50.13 88.93,41.34 89.08,41.19 89.08,39.85 ; 63.73,50.03 64.28,50.58 64.28,54.84 64.85,55.41 65.59,55.41 65.91,55.72 65.91,60.72 65.92,60.72 65.92,61.21 65.91,61.22 65.91,65.66 65.92,65.67 65.92,65.78 65.92,65.79 65.92,66.12 65.92,66.12 65.92,66.17 65.91,66.17 65.91,66.67 65.92,66.68 65.92,66.75 65.91,66.76 65.91,67.08 65.92,67.09 65.92,67.17 65.91,67.18 65.91,70.8 64.87,71.84
  IN4 w0.109: v6(35.58,110.33) 35.24,109.99 35.24,109.98 35.09,109.84 35.09,106.32 37.17,104.24 37.17,102.23 38.33,101.07 39.3,101.07 42.22,98.16 48.82,98.16 49.76,97.22 52.21,97.22 56.95,92.48 58.96,92.48 62.13,89.32 62.13,85.59 60.3,83.76 60.3,77.05 64.87,72.48 64.87,71.84 ; 89.08,39.85 89.08,39.37 84.05,34.33 84.05,33.52 82.61,32.08 67.23,32.08 62.72,36.59 62.72,49.02 63.73,50.03
FDI_LSYNC1: length 132.8
  TOP w0.089: JCPU1.H17 83.84,48.45 v1(83.37,48.92)
  TOP w0.102: UH4.BB10 38,108.77 v6(37.69,108.46)
  IN4 w0.089: 86.28,39.83 86.52,40.08 86.52,42.22 86.84,42.53 86.84,49.13 86.63,49.34 83.78,49.34 v1(83.37,48.92)
  IN4 w0.109: v6(37.69,108.46) 37.7,108.44 37.7,107.01 38.12,106.59 38.12,105.61 41.06,102.68 41.06,101.82 43.19,99.68 51.9,99.68 57.34,94.25 59.35,94.25 63.8,89.8 63.8,81.4 64.34,80.87 64.34,75.74 66.79,73.29 66.79,72.77 67.07,72.49 67.59,72.49 67.85,72.23 67.85,56 67.41,55.56 67.11,55.56 66.8,55.25 66.8,54.7 66.58,54.48 66.2,54.48 65.87,54.15 65.87,51.83 65.42,51.37 65.42,49.8 64.41,48.79 64.41,37.34 67.59,34.17 81.14,34.17 83.86,36.88 84.44,36.88 86.13,38.57 86.13,39.69 86.28,39.83
FFS_INT2: length 229.1
  TOP w0.305: v1(149.33,103.75) 149.34,103.75 150.07,103.01 150.07,96.2 150.09,96.18 150.09,95.99 151.52,94.55 153.91,94.55 154.94,93.52 v1(154.94,88.38) ; Q29.2 188.15,55.94 187.74,55.54 187.74,55.14 187.4,54.8 187.21,54.8 185.71,53.3 183.46,53.3 181.85,54.92 v1(181.85,56.06) ; UH4.V13 26.48,110.36 v1(26.69,110.36) ; U88.9 126.83,104.7 v1(127.1,104.97)
  IN2 w0.305: v1(26.69,110.36) 26.86,110.36 27.21,110.71 27.21,111.24 27.44,111.47 28.27,111.47 30.01,109.73 30.01,108.17 30.47,107.71 30.84,107.71 31.15,107.39 31.15,106.05 31.39,105.8 31.91,105.8 33.77,107.66 35.6,107.66 36.16,107.1 37.39,107.1 38.16,107.87 39.85,107.87 42.07,110.1 44.63,110.1 45.6,111.07 50.3,111.07 51.03,111.8 61.66,111.8 64.26,109.2 70.95,109.2 74.4,112.64 78.4,112.64 79.42,111.61 81.6,111.61 81.88,111.89 90.84,111.89 99.92,102.81 124.94,102.81 v1(127.1,104.97)
  IN3 w0.305: v1(181.85,56.06) 181.74,55.94 175.22,55.94 172.38,58.79 172.38,66.07 169.2,69.24 169.2,85.5 169.86,86.16 v1(170.13,86.16)
  IN4 w0.305: v1(170.13,86.16) 170.2,86.23 170.2,86.49 168.49,88.2 161.63,88.2 159.85,89.98 156.54,89.98 v1(154.94,88.38)
  BOTTOM w0.305: v1(149.33,103.75) 149.27,103.75 148.46,102.93 131.55,102.93 130.11,104.37 130.11,105.12 129.64,105.59 v2(129.3,105.59) 127.49,105.59 127.1,105.19 v1(127.1,104.97)
FFS_INT2_Q: length 168.7
  TOP w0.305: v1(197.57,63.02) 198.01,62.58 JSATA1.18 ; v1(189.7,55.14) 189.7,55.16 190.09,55.55 R506.2 189.92,55.88 189.2,56.59 Q29.3 ; JSATA2.18 90.67,29.38 90.65,29.36 90.65,25.22 96.73,19.14 96.73,12.57 v1(96.44,12.28)
  IN2 w0.305: v1(189.7,55.14) 189.23,54.67 182.03,54.67 176.19,48.83 172.37,48.83 165.58,42.05 165.58,33.69 164.77,32.88 164.77,25.73 166.47,24.03 166.47,21.17 163.99,18.69 159.22,18.69 159.13,18.61 156.7,18.61 155.16,17.07 152.91,17.07 150.55,14.71 132.99,14.71 132.46,15.24 130.52,15.24 129.93,15.82 127.65,15.82 127.65,15.83 125.02,15.83 125.02,15.82 122.71,15.82 122.21,16.33 120.05,16.33 118.81,17.57 118.35,17.57 118.12,17.79 113.24,17.79 111.67,16.23 107.82,16.23 105.87,14.28 104.93,14.28 104.45,13.79 104.44,13.79 103.41,12.77 103.41,12.76 102.38,11.73 97,11.73 v1(96.44,12.28)
  IN4 w0.305: v1(189.7,55.14) 189.74,55.18 189.79,55.18 190.94,56.34 191.95,56.34 196.54,60.94 196.54,60.94 196.59,60.99 196.59,62.04 v1(197.57,63.02)
  BOTTOM w0.127: v1(96.44,12.28) v2(96.44,11.33)
FFS_PCH_INT: length 4.8
  TOP w0.102: UH4.D44 19.43,125.47 19.64,125.26 v1(19.66,125.26)
  BOTTOM w0.102: v1(19.66,125.26) 19.62,125.3 19.62,125.31 19.28,125.65 18.82,125.65 18.73,125.57 v2(18.36,125.57) 18.13,125.57 17.16,126.54 17.16,127.57 RH334.2
FWP#: length 8.9
  TOP w0.102: U54.B65 164.22,151.47 164.57,151.13 164.57,150.44 164.81,150.2 v1(165.05,150.2)
  BOTTOM w0.102: v1(165.05,150.2) 164.93,150.2 164.58,150.56 164.58,151.09 164.1,151.58 v2(163.8,151.58) 163.49,151.58 161.64,153.42 R879.2 R872.2
GFX_CLK_REQ#: length 17.3
  TOP w0.102: RH80.1 26.15,97.41 27.01,98.27 v1(27.34,98.27) 27.41,98.27 v2(27.9,97.78) 28.05,97.63 28.05,96.53 QH2.1 ; v1(22.64,108.38) 22.77,108.38 23.04,108.65 UH4.M10
  IN1 w0.109: v1(27.34,98.27) 26.73,98.88 26.73,99.57 25.25,101.05 24.88,101.05 24.34,101.59 24.34,104.15 23.19,105.31 23.19,108 22.81,108.38 v1(22.64,108.38)
GP1_SNUB: length 3.5
  BOTTOM w0.102: PR770.2 v2(45.09,83.68)
  BOTTOM w0.508: PC772.1 42.41,83.88 42.61,83.68 PR770.2
GP1_SW: length 46.8
  TOP w0.254: PL705.2 v1(47.34,80.88)
  IN3 w0.254: v1(38.95,91.42) 38.78,91.25 36.68,91.25 35.66,92.27 26.77,92.27 26.26,92.77 24.61,92.77 24.01,92.17 24.01,89.76 22.71,88.46 22.07,88.46 v1(21.06,87.44)
  IN4 w0.254: v1(47.34,80.88) 47.34,81.33 47.55,81.54 47.55,82.42 44.35,85.61 43.51,85.61 41.78,87.34 41.78,89.58 40.59,90.77 39.39,90.77 38.95,91.21 v1(38.95,91.42)
  BOTTOM w0.127: v2(45.31,80.63) PR770.1
  BOTTOM w0.254: PR772.2 PR771.2 19.86,86.63 20.67,87.44 v1(21.06,87.44)
  BOTTOM w0.508: PR770.1 43.53,81.24 43.26,81.52 v1(42.77,81.52)
GP2_SNUB: length 3.4
  BOTTOM w0.102: PR765.2 v2(44.26,90.28)
  BOTTOM w0.508: PR765.2 41.71,90.28 41.58,90.16 PC765.1
GP2_SW: length 37.4
  TOP w0.254: PR767.1 22.27,86.63 22.96,87.31 v1(22.96,87.57) ; PL704.2 v1(47.34,88.25)
  IN1 w0.254: v1(22.96,87.57) 23.09,87.69 23.09,88.58 24.87,90.36 27.28,90.36 29.44,92.52 35.57,92.52 35.95,92.9 45.19,92.9 47.09,91 47.09,88.5 v1(47.34,88.25)
  BOTTOM w0.254: v1(22.96,87.57) 22.96,87.06 22.53,86.63 PR767.1
  BOTTOM w0.508: v1(43.03,88.89) 42.65,88.5 PR765.1
  vias: v2(43.34,90.53)
GPIO_PSID_SELECT: length 348.2
  IN1 w0.127: v1(238.08,65.95) 238.53,65.5 238.53,64.87 238.36,64.71 238.36,64.34 237.34,63.31 237.34,61.38 237.89,60.82 v1(237.89,60.76)
  IN2 w0.127: v1(1.6,74.18) 2.54,73.24 2.54,63.37 6.81,59.11 12.34,59.11 12.77,58.67 22.83,58.67 25.23,56.27 25.23,45.74 26.87,44.1 26.87,44.1 26.88,44.09 26.88,42.44 26.88,42.44 26.88,42.29 26.86,42.27 26.86,40.93 25.97,40.04 25.36,40.04 24.5,39.18 24.5,27.17 24.64,27.03 25.3,26.37 25.6,26.37 26.2,26.37 26.76,25.81 26.76,25.2 26.76,24.7 27.74,23.72 27.74,21.4 27.84,21.3 27.84,19.09 28.93,18 28.93,11.01 28.6,10.68 28.6,9.8 28.61,9.78 28.61,9.71 29.93,8.39 29.93,8.3 30.71,7.53 30.79,7.53 31.63,6.69 33.18,6.69 33.23,6.74 34.76,6.74 34.89,6.87 105.78,6.87 106.54,7.63 107.47,7.63 108.73,8.89 112.95,8.89 112.95,8.89 119.56,8.89 119.56,8.89 119.83,8.89 122.16,11.21 127.07,11.21 127.19,11.09 131.3,11.09 132.2,11.99 132.21,11.99 132.23,12.01 154.9,12.01 155.01,11.9 157.06,11.9 158.7,13.54 162.06,13.54 163.33,14.81 v1(163.7,14.81)
  IN3 w0.127: v1(163.7,14.81) 163.6,14.91 163.6,18.19 163.88,18.46 163.88,40.47 173.73,50.32 177.7,50.32 180.64,53.25 185.37,53.25 186.56,54.45 186.78,54.45 188.94,56.6 193.58,56.6 194.65,57.67 201.45,57.67 207.59,63.82 221.8,63.82 223.47,62.15 231.65,62.15 231.79,62.01 231.79,62.01 232.74,61.05 237.72,61.05 237.89,60.88 v1(237.89,60.76)
  BOTTOM w0.127: v1(238.08,65.95) U46.A6
  BOTTOM w0.254: v1(1.6,74.18) v2(1.6,74.82) 1.74,74.96 2.47,74.96 2.75,74.68 PU1.6
GPU_PWR_LEVEL: length 116
  IN2 w0.127: v1(243.03,74.81) 243.03,74.74 243.65,75.36 244.08,75.36 245.4,76.69 245.4,80.77 243.29,82.88 238.92,82.88 235.49,86.32 233.44,86.32 233.21,86.54 231.84,86.54 228.71,89.67 227.76,89.67 218.95,98.48 218.95,100.17 213.14,105.97 213.14,113.02 213.19,113.08 213.19,114.61 213.26,114.67 213.26,156.34 211.64,157.95 v1(211.61,157.95)
  BOTTOM w0.102: v1(211.61,157.95) 209.5,157.95 205.89,154.34 205.89,153.4 205.59,153.1 U17.2 ; R787.2 243.72,75.5 v2(243.59,75.38) v1(243.03,74.81) 242.67,74.45 U46.A52
GPU_SMBCLK: length 44.1
  TOP w0.102: v1(170.62,150.17) 170.66,150.13 U54.B49
  IN4 w0.109: v1(170.62,150.17) 170.71,150.17 170.87,150.33 171.17,150.33 172.21,151.37 175.08,151.37 176.88,149.57 181.99,149.57 182.36,149.94 185.14,149.94 188.5,146.57 194.48,146.57 195.95,148.04 199.87,148.04 202.33,150.51 202.65,150.51 v1(202.78,150.38)
  BOTTOM w0.102: v1(170.62,150.17) 170.71,150.17 v2(171.43,150.89) 172.08,151.54 175.04,151.54 175.64,150.94 R822.1 ; Q295.3 203.25,149.91 v1(202.78,150.38)
GPU_SMBCLK_R: length 14.9
  TOP w0.102: JMXM1.70 205,155.02 204.66,155.36 203.81,155.36 203.55,155.11 203.55,150.51 202.79,149.75 v1(202.6,149.75)
  BOTTOM w0.102: R1.2 201.67,148.53 201.78,148.63 v2(201.78,148.84) 201.78,149.16 201.59,149.35 Q295.4 201.6,149.92 202.43,149.92 v1(202.6,149.75) 202.84,149.5 203.95,149.5 204.68,150.24 R2182.1
GPU_SMBDAT: length 46.7
  TOP w0.102: v1(169.96,150.19) 170.52,149.63 U54.B48
  IN4 w0.109: v1(202.74,151.02) 202.51,150.79 202.25,150.79 199.77,148.3 195.85,148.3 194.37,146.83 188.61,146.83 185.24,150.19 182.26,150.19 181.89,149.82 177.06,149.82 175.26,151.63 172.11,151.63 171.09,150.61 170.34,150.61 169.96,150.23 v1(169.96,150.19)
  BOTTOM w0.102: R829.1 175.11,150.46 v2(173.4,150.46) 171.61,150.46 170.88,149.72 170.43,149.72 v1(169.96,150.19) ; Q295.6 202.55,151.21 v1(202.74,151.02)
GPU_SMBDAT_R: length 15.1
  TOP w0.102: JMXM1.68 204.93,155.52 204.84,155.6 203.76,155.6 203.33,155.17 203.33,151.94 v1(203.12,151.74) 202.7,151.74 201.56,150.6 201.56,147.71 v3(201.76,147.51)
  BOTTOM w0.102: R2.2 v3(201.76,147.51) ; R2183.1 203.5,151.19 Q295.1 203.49,151.51 203.26,151.74 v1(203.12,151.74)
GREEN_CRT: length 12.8
  IN3 w0.127: v1(53.84,159.03) 54.32,159.51 59.09,159.51 v1(59.51,159.93)
  BOTTOM w0.102: v1(53.84,159.03) R54.1 C23.1 52.17,159.6 52.08,159.69 L2.1 ; v1(59.51,159.93) v2(59.51,159.39) 59.51,158.32 59.79,158.04 59.79,157.38 60.17,157 U19.32
GREEN_CRT_L: length 16.5
  TOP w0.102: JCRT1.2 58.53,172.96 55.76,170.19 54.08,170.19 52.98,169.1 D10.3 52.98,167.09 52.71,166.82 C12.1 v2(52.71,162.7) 52.71,161.87 v1(53.27,161.3)
  BOTTOM w0.102: v1(53.27,161.3) 53.28,161.3 L2.2
GREEN_DOCK: length 64.1
  IN3 w0.127: v1(96.39,122.85) 95.25,123.99 93.97,123.99 91.36,126.59 90.89,126.59 87.13,130.35 86.63,130.35 84.36,132.63 81.51,132.63 79.48,134.66 79.48,136.43 75.27,140.64 74.45,140.64 73.79,141.31 73.79,141.39 71.98,143.19 69.92,143.19 69.21,143.91 67.49,143.91 67.49,143.9 65.21,143.9 64.69,144.42 64.69,145.64 64.29,146.05 61.54,146.05 60.12,147.47 60.12,150.38 59.78,150.72 57.89,150.72 v3(57.12,149.96)
  BOTTOM w0.102: JDOCK1.59 97.24,122 v1(96.39,122.85) ; v3(57.12,149.96) 57.12,150.86 56.78,151.21 56.78,152.18 57.58,152.99 U19.23
H_CATERR#: length 8.4
  TOP w0.089: JCPU1.AL33 67.87,71.45 67.36,70.94 v1(67.33,70.94)
  BOTTOM w0.102: RC15.2 v2(63.63,75.5) 63.63,75.32 65.67,73.28 65.67,72.03 65.91,71.79 65.91,71.78 66.15,71.54 66.16,71.54 66.75,70.94 v1(67.33,70.94)
