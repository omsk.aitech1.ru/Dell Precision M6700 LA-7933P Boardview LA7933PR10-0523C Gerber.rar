# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_LVDS_A0-: length 202.5
  TOP w0.102: U11.17 67.69,132.42 67.63,132.36 67.42,132.36 66.89,131.82 66.89,131.47 67.6,130.75 67.6,128.88 71.66,124.83 76.62,124.83 77.16,124.29 77.24,124.21 77.63,124.21 v1(77.8,124.05) ; JMXM1.228 205.07,113.52 204.94,113.39 204.21,113.39 203.73,113.86 203.73,114.17 203.82,114.26 204.01,114.26 v3(204.1,114.17)
  IN4 w0.117: v3(204.1,114.17) 203.95,114.03 203.95,113.75 203.65,113.44 202.31,113.44 200.99,114.77 196.9,114.77 196.62,114.5 196.62,112.83 196.33,112.54 195.62,112.54 195.33,112.82 195.33,114.61 195.2,114.73 194.87,114.73 194.75,114.61 194.75,112.82 194.46,112.54 193.88,112.54 193.59,112.82 193.59,114.37 193.48,114.49 193.13,114.49 193.01,114.37 193.01,112.82 192.73,112.54 192.14,112.54 191.86,112.82 191.86,114.12 191.73,114.25 191.4,114.25 191.27,114.12 191.27,112.82 190.99,112.54 185.67,112.54 185.38,112.83 185.38,118.69 184.85,119.22 180.52,119.22 178.05,121.68 169.24,121.68 167.19,123.73 162.89,123.73 152.8,133.82 148.64,133.82 146.63,135.82 133.92,135.82 133.8,135.71 133.8,135.1 133.51,134.81 132.94,134.81 132.65,135.1 132.65,135.7 132.52,135.83 132.13,135.83 132,135.7 132,134.88 131.71,134.58 129.62,134.58 129.33,134.87 129.33,135.85 129.21,135.98 128.88,135.98 128.75,135.85 128.75,134.87 128.47,134.58 127.88,134.58 127.6,134.87 127.6,135.85 127.47,135.98 127.14,135.98 127.01,135.85 127.01,134.87 126.73,134.58 126.14,134.58 125.86,134.87 125.86,135.85 125.73,135.98 125.4,135.98 125.27,135.85 125.27,134.87 124.99,134.58 124.18,134.58 123.9,134.87 123.9,135.86 123.78,135.98 123.43,135.98 123.31,135.86 123.31,134.87 123.03,134.58 122.44,134.58 122.16,134.87 122.16,135.8 122.03,135.93 121.7,135.93 121.58,135.8 121.58,134.87 121.29,134.58 120.71,134.58 120.42,134.87 120.42,135.78 120.3,135.9 119.97,135.9 119.84,135.78 119.84,135.07 119.54,134.78 118.94,134.78 118.65,135.07 118.65,135.63 118.47,135.81 117.95,135.81 115.8,137.96 103.77,137.96 103.4,137.59 98.96,137.59 96.01,134.64 91.19,134.64 89.8,136.04 87.61,136.04 87.29,135.72 85.3,135.72 84.88,136.14 82.49,136.14 82.25,135.9 82.25,134.4 81.27,133.41 81.27,126.92 79.75,125.41 79.52,125.41 78.34,124.23 77.98,124.23 v1(77.8,124.05)
MXM_LVDS_A1+: length 200.8
  TOP w0.102: v1(203.33,115.51) 203.49,115.34 203.49,115.1 203.84,114.75 204.26,114.75 204.49,114.52 JMXM1.224 ; U11.22 70.72,130.28 70.49,130.04 70.49,127.59 71.69,126.39 74.88,126.39 75.12,126.63 v3(75.12,126.78)
  IN4 w0.117: v1(203.33,115.51) 203.49,115.35 203.49,115.11 203.85,114.75 205.1,114.75 205.55,115.2 205.55,117.33 204.95,117.94 197.64,117.94 197.31,118.27 197.31,120.8 196.98,121.13 184.08,121.13 183.42,121.78 182.87,121.78 182.75,121.9 182.75,122.64 182.46,122.94 181.89,122.94 181.6,122.64 181.6,121.9 181.48,121.78 180.96,121.78 178.84,123.9 177.79,123.9 177.04,124.65 175.35,124.65 175.06,124.37 175.06,123.73 174.95,123.62 174.59,123.62 174.48,123.73 174.48,124.37 174.19,124.65 172.7,124.65 172.41,124.37 172.41,123.74 172.29,123.62 171.96,123.62 171.83,123.74 171.83,124.46 171.54,124.75 170.97,124.75 170.68,124.46 170.68,123.74 170.55,123.62 170.22,123.62 168.23,125.6 165.99,125.6 165.87,125.72 165.87,126.8 165.59,127.08 165,127.08 164.72,126.8 164.72,125.72 164.6,125.6 163.7,125.6 163.47,125.84 163.47,126.02 163.85,126.39 163.85,126.79 163.43,127.21 163.03,127.21 162.64,126.82 162.46,126.82 162.23,127.05 162.23,127.23 162.62,127.62 162.62,128.03 162.21,128.44 161.8,128.44 161.41,128.05 161.23,128.05 161,128.28 161,128.46 161.39,128.85 161.39,129.26 160.99,129.66 160.57,129.66 160.37,129.46 160.19,129.46 159.95,129.7 159.95,129.87 160.16,130.08 160.16,130.48 159.31,131.33 158.91,131.33 158.51,130.93 158.35,130.93 158.1,131.18 158.1,131.35 158.5,131.74 158.5,132.14 158.16,132.48 156.79,132.48 156.63,132.64 156.63,132.65 153.46,135.82 149.34,135.82 147.28,137.88 119.17,137.88 118.83,138.21 118.83,139.8 118.37,140.26 117.03,140.26 116.92,140.38 116.92,141.04 116.63,141.33 116.01,141.33 115.72,141.04 115.72,140.4 115.58,140.26 114.09,140.26 113.9,140.45 113.9,141.02 113.61,141.32 113.04,141.32 112.75,141.02 112.75,140.61 112.63,140.49 111.66,140.49 111.42,140.25 111.42,139.94 111.29,139.81 110.83,139.81 110.7,139.94 110.7,140.88 110.46,141.12 109.21,141.12 109.08,141.25 109.08,141.83 108.74,142.17 100.1,142.17 98.36,140.43 98.2,140.43 97.4,141.22 96.99,141.22 96.59,140.82 96.59,140.4 97.62,139.37 97.62,139.19 97.39,138.96 97.21,138.96 95.83,140.33 95.42,140.33 95.01,139.93 95.01,139.52 96.15,138.38 96.15,138.22 95.47,137.54 94.45,137.54 94.34,137.65 94.34,139.2 94.05,139.49 93.31,139.49 93.02,139.2 93.02,137.68 92.87,137.54 91.56,137.54 91.06,138.03 81.23,138.03 79.48,136.28 79.48,135.27 79.35,135.14 79.35,132.6 76.83,130.08 75.65,130.08 75.19,129.62 75.19,127.67 75.3,127.56 75.3,126.96 v3(75.12,126.78)
MXM_LVDS_A1-: length 200.7
  TOP w0.102: JMXM1.222 205.07,115.02 205,114.95 205,114.86 204.93,114.79 204.6,114.79 204.37,115.02 203.95,115.02 203.76,115.21 203.76,115.42 203.85,115.51 v3(204.12,115.51) ; U11.21 70.22,127.48 71.58,126.12 74.75,126.12 v1(74.98,125.89)
  IN4 w0.117: v1(74.98,125.89) 74.83,126.05 74.83,126.25 74.92,126.34 75.47,126.34 75.58,126.45 75.58,127.68 75.47,127.79 75.47,129.5 75.76,129.79 76.94,129.79 79.63,132.48 79.63,135.02 79.76,135.15 79.76,136.16 81.34,137.75 90.94,137.75 91.44,137.25 92.99,137.25 93.31,137.57 93.31,139.08 93.43,139.21 93.93,139.21 94.05,139.08 94.05,137.53 94.33,137.25 95.59,137.25 96.44,138.1 96.44,138.5 95.3,139.64 95.3,139.81 95.53,140.05 95.71,140.05 97.09,138.67 97.51,138.67 97.91,139.07 97.91,139.49 96.87,140.52 96.87,140.7 97.11,140.93 97.29,140.93 98.08,140.14 98.48,140.14 100.22,141.88 108.63,141.88 108.8,141.71 108.8,141.13 109.09,140.84 110.35,140.84 110.42,140.76 110.42,139.82 110.71,139.53 111.41,139.53 111.7,139.82 111.7,140.13 111.78,140.21 112.75,140.21 113.03,140.49 113.03,140.91 113.16,141.03 113.49,141.03 113.62,140.91 113.62,140.33 113.97,139.98 115.7,139.98 116,140.28 116,140.92 116.13,141.05 116.51,141.05 116.64,140.92 116.64,140.26 116.91,139.98 118.25,139.98 118.55,139.68 118.55,138.09 119.05,137.59 147.17,137.59 149.22,135.53 153.34,135.53 156.35,132.53 156.35,132.53 156.67,132.2 158.04,132.2 158.21,132.03 158.21,131.86 157.82,131.46 157.82,131.06 158.23,130.65 158.63,130.65 159.03,131.04 159.19,131.04 159.87,130.36 159.87,130.2 159.67,129.99 159.67,129.58 160.07,129.18 160.49,129.18 160.69,129.38 160.87,129.38 161.1,129.15 161.1,128.97 160.71,128.58 160.71,128.16 161.12,127.76 161.53,127.76 161.92,128.15 162.1,128.15 162.33,127.92 162.33,127.74 161.94,127.35 161.94,126.94 162.34,126.53 162.76,126.53 163.15,126.92 163.31,126.92 163.56,126.68 163.56,126.51 163.19,126.13 163.19,125.72 163.59,125.32 164.72,125.32 165,125.6 165,126.68 165.12,126.8 165.47,126.8 165.59,126.68 165.59,125.6 165.87,125.32 168.12,125.32 170.1,123.33 170.67,123.33 170.96,123.63 170.96,124.34 171.09,124.47 171.42,124.47 171.55,124.34 171.55,123.63 171.84,123.33 172.41,123.33 172.7,123.63 172.7,124.25 172.82,124.37 174.08,124.37 174.19,124.25 174.19,123.62 174.48,123.33 175.06,123.33 175.35,123.62 175.35,124.25 175.46,124.37 176.92,124.37 177.67,123.62 178.72,123.62 180.84,121.5 181.6,121.5 181.88,121.78 181.88,122.53 182.01,122.65 182.34,122.65 182.46,122.53 182.46,121.78 182.75,121.5 183.31,121.5 183.96,120.84 196.87,120.84 197.02,120.69 197.02,118.15 197.52,117.65 204.83,117.65 205.27,117.21 205.27,115.32 204.98,115.03 203.97,115.03 203.77,115.23 203.77,115.49 203.86,115.58 204.05,115.58 v3(204.12,115.51)
MXM_LVDS_A2+: length 207.1
  TOP w0.102: U11.26 72.72,130.33 72.67,130.28 72.54,130.28 72.49,130.22 72.49,129.91 73.6,128.8 75.79,128.8 76,129.01 v3(76,129.18) ; JMXM1.218 204.18,116.02 203.52,116.69 203.52,116.95 v1(203.34,117.13)
  IN4 w0.117: v3(76,129.18) 76,129.09 76.39,128.7 76.86,128.7 80.19,132.04 80.19,133.86 80.8,134.46 80.8,136.48 81.56,137.25 90.42,137.25 90.92,136.75 90.93,136.75 91.21,136.47 91.21,136.23 91.34,136.11 91.67,136.11 91.79,136.23 91.79,136.47 92.08,136.75 93.08,136.75 93.37,136.47 93.37,136.3 93.49,136.18 93.72,136.18 93.84,136.3 93.84,136.47 94.12,136.75 94.59,136.75 94.87,136.47 94.87,136.3 94.99,136.18 95.22,136.18 95.34,136.3 95.34,136.47 95.62,136.75 96.29,136.75 98.2,138.66 100.53,138.66 100.66,138.78 100.66,139.19 100.53,139.32 99.7,139.32 99.41,139.61 99.41,140.3 99.7,140.6 100.16,140.6 100.28,140.71 100.28,140.96 100.6,141.28 104.4,141.28 104.75,140.92 107.62,140.92 109.52,139.03 112.46,139.03 112.84,139.41 114.2,139.41 114.59,139.03 116.39,139.03 118.38,137.05 146.92,137.05 149.08,134.88 153.28,134.88 163.34,124.82 167.71,124.82 169.7,122.83 178.66,122.83 181.21,120.29 186.1,120.29 186.5,119.88 186.5,113.84 186.63,113.72 187.12,113.72 187.24,113.84 187.24,120.02 187.54,120.31 188.49,120.31 188.78,120.02 188.78,114.01 188.91,113.88 189.23,113.88 189.35,114.01 189.35,119.99 189.65,120.29 190.21,120.29 190.51,119.99 190.51,115.41 190.63,115.28 190.96,115.28 191.09,115.41 191.09,119.99 191.38,120.29 191.95,120.29 192.24,119.99 192.24,115.67 192.37,115.55 192.7,115.55 192.83,115.67 192.83,119.97 193.12,120.26 193.69,120.26 193.98,119.97 193.98,116.45 194.2,116.24 196.24,116.24 196.47,116.46 203.46,116.46 203.71,116.71 203.71,117.03 203.6,117.13 v1(203.34,117.13)
MXM_LVDS_A2-: length 207.1
  TOP w0.102: v3(204.14,117.13) 204.07,117.2 203.91,117.2 203.78,117.07 203.78,116.8 204.29,116.29 204.85,116.29 204.93,116.36 204.93,116.43 205.01,116.52 JMXM1.216 ; v1(76,128.42) 75.88,128.53 73.49,128.53 72.22,129.8 U11.25
  IN4 w0.117: v3(204.14,117.13) 203.99,116.99 203.99,116.59 203.57,116.18 196.59,116.18 196.36,115.95 194.08,115.95 193.7,116.33 193.7,119.85 193.57,119.98 193.24,119.98 193.11,119.85 193.11,115.55 192.82,115.26 192.25,115.26 191.96,115.55 191.96,119.88 191.83,120 191.5,120 191.37,119.88 191.37,115.29 191.08,114.99 190.51,114.99 190.22,115.29 190.22,119.88 190.09,120 189.76,120 189.64,119.88 189.64,113.89 189.34,113.6 188.79,113.6 188.5,113.89 188.5,119.9 188.37,120.03 187.65,120.03 187.53,119.9 187.53,113.73 187.23,113.43 186.51,113.43 186.22,113.73 186.22,119.77 185.98,120 181.09,120 178.54,122.55 169.58,122.55 167.59,124.54 163.22,124.54 153.16,134.6 148.96,134.6 146.8,136.76 118.26,136.76 116.28,138.74 114.47,138.74 114.08,139.13 112.96,139.13 112.57,138.74 109.4,138.74 107.5,140.64 104.63,140.64 104.28,140.99 100.71,140.99 100.56,140.84 100.56,140.6 100.28,140.31 99.82,140.31 99.69,140.19 99.69,139.73 99.82,139.6 100.65,139.6 100.94,139.31 100.94,138.67 100.65,138.37 98.31,138.37 96.41,136.47 95.74,136.47 95.62,136.35 95.62,136.18 95.34,135.9 94.87,135.9 94.59,136.18 94.59,136.35 94.47,136.47 94.24,136.47 94.12,136.35 94.12,136.18 93.84,135.9 93.37,135.9 93.08,136.18 93.08,136.35 92.97,136.47 92.2,136.47 92.08,136.35 92.08,136.12 91.79,135.82 91.22,135.82 90.93,136.12 90.93,136.35 90.81,136.47 90.8,136.47 90.3,136.96 81.68,136.96 81.08,136.37 81.08,134.35 80.48,133.74 80.48,131.92 76.98,128.42 v1(76,128.42)
MXM_LVDS_ACLK+: length 198.3
  TOP w0.102: JMXM1.206 205.01,119.02 204.96,119.07 204.96,119.19 204.9,119.25 203.87,119.25 203.55,118.94 203.55,118.62 203.68,118.49 203.9,118.49 v3(203.93,118.52) ; v1(77.77,133.48) 77.59,133.29 74.99,133.29 74.86,133.42 U11.31
  IN4 w0.117: v3(203.93,118.52) 203.78,118.67 203.78,119.05 203.35,119.47 202.01,119.47 201.88,119.6 201.88,120.06 201.59,120.35 200.89,120.35 200.59,120.06 200.59,118.9 200.48,118.78 200.13,118.78 200.01,118.9 200.01,120.08 199.72,120.38 199.15,120.38 198.86,120.08 198.86,118.89 198.73,118.76 198.31,118.76 198.19,118.89 198.19,121.42 196.91,122.7 194.05,122.7 193.72,122.36 193.72,122.07 193.59,121.95 193.25,121.95 193.13,122.07 193.13,122.93 192.83,123.22 192.2,123.22 191.91,122.93 191.91,122.04 191.79,121.92 191.44,121.92 191.32,122.04 191.32,122.85 191.03,123.14 190.46,123.14 190.17,122.85 190.17,122.04 190.05,121.92 189.7,121.92 189.58,122.04 189.58,122.91 189.29,123.21 188.73,123.21 188.43,122.91 188.43,122.04 188.31,121.92 187.96,121.92 187.85,122.04 187.85,122.93 187.55,123.22 186.84,123.22 186.54,122.93 186.54,122.09 186.41,121.95 184.55,121.95 182.61,123.89 180.7,123.89 180.5,124.09 180.5,125.94 180.2,126.23 179.5,126.23 179.2,125.94 179.2,124.85 179.08,124.73 178.64,124.73 178.51,124.85 178.51,126.12 178.23,126.41 177.64,126.41 177.36,126.12 177.36,125.77 177.24,125.65 176.89,125.65 176.77,125.77 176.77,126.12 176.49,126.41 175.9,126.41 175.62,126.12 175.62,125.77 175.5,125.65 175.15,125.65 175.04,125.77 175.04,126.12 174.75,126.41 174.17,126.41 173.88,126.12 173.88,125.58 173.76,125.45 173.43,125.45 173.3,125.58 173.3,126.12 173.02,126.41 172.43,126.41 172.15,126.12 172.15,125.67 172.02,125.54 171.69,125.54 171.56,125.67 171.56,126.1 171.27,126.4 170.52,126.4 170.22,126.1 170.22,125.37 170.1,125.25 169.71,125.25 169.58,125.37 169.58,127.61 169.29,127.91 168.58,127.91 168.29,127.61 168.29,127.19 168.15,127.05 167.84,127.05 167.71,127.19 167.71,127.56 167.4,127.86 163.89,127.86 159.28,132.47 159.28,133.03 158.7,133.62 157.88,133.62 155.96,135.54 154.85,135.54 152.96,137.43 152.18,137.43 152.04,137.57 152.04,138.17 151.75,138.46 151.12,138.46 150.82,138.17 150.82,136.75 150.71,136.63 150.35,136.63 150.24,136.75 150.24,138.36 149.94,138.65 149.3,138.65 149,138.36 149,137.95 148.88,137.82 148.49,137.82 148.36,137.95 148.36,138.29 147.97,138.68 139.13,138.68 139,138.8 139,139.61 138.63,139.98 136.38,139.98 136.09,139.69 136.09,139.15 135.98,139.04 129.04,139.04 128.66,139.43 119.84,139.43 119.64,139.62 119.64,143.06 119.35,143.35 118.66,143.35 118.37,143.06 118.37,142.56 118.24,142.43 117.91,142.43 117.78,142.56 117.78,143.17 117.5,143.45 116.91,143.45 116.63,143.17 116.63,142.24 116.5,142.11 116.17,142.11 116.05,142.24 116.05,143.27 115.75,143.57 114.81,143.57 114.52,143.27 114.52,142.19 114.39,142.06 114.06,142.06 113.93,142.19 113.93,143.25 113.65,143.54 113.06,143.54 112.78,143.25 112.78,142.6 112.65,142.47 112.32,142.47 112.19,142.6 112.19,143.05 111.9,143.35 109.27,143.35 108.89,142.97 99.69,142.97 98.72,142 93.97,142 91.93,139.96 89.7,139.96 88.61,138.88 79.86,138.88 79.58,138.59 79.58,137.57 79.45,137.44 79.12,137.44 79,137.57 79,137.95 78.7,138.25 77.48,138.25 77.18,137.95 77.18,134.88 77.48,134.59 78.18,134.59 78.37,134.4 78.37,133.55 78.23,133.41 77.84,133.41 v1(77.77,133.48)
MXM_LVDS_ACLK-: length 198.3
  TOP w0.102: v3(77.76,132.84) 77.58,133.03 74.97,133.03 74.87,132.92 U11.30 ; v1(203.12,118.52) 203.29,118.68 203.29,119.05 203.76,119.52 JMXM1.204
  IN4 w0.117: v3(77.76,132.84) 78.05,133.13 78.35,133.13 78.65,133.43 78.65,134.51 78.29,134.87 77.6,134.87 77.47,135 77.47,137.83 77.6,137.96 78.59,137.96 78.71,137.83 78.71,137.45 79.01,137.16 79.57,137.16 79.87,137.45 79.87,138.47 79.98,138.59 88.73,138.59 89.81,139.68 92.04,139.68 94.08,141.71 98.84,141.71 99.81,142.69 109.01,142.69 109.39,143.06 111.78,143.06 111.91,142.93 111.91,142.48 112.2,142.18 112.77,142.18 113.06,142.48 113.06,143.13 113.18,143.25 113.53,143.25 113.65,143.13 113.65,142.07 113.94,141.78 114.51,141.78 114.8,142.07 114.8,143.15 114.93,143.28 115.64,143.28 115.76,143.15 115.76,142.12 116.06,141.83 116.62,141.83 116.92,142.12 116.92,143.05 117.03,143.17 117.38,143.17 117.5,143.05 117.5,142.44 117.79,142.15 118.36,142.15 118.65,142.44 118.65,142.94 118.78,143.07 119.23,143.07 119.36,142.94 119.36,139.5 119.72,139.14 128.54,139.14 128.93,138.76 136.1,138.76 136.37,139.03 136.37,139.57 136.5,139.7 138.51,139.7 138.72,139.49 138.72,138.69 139.01,138.39 147.86,138.39 148.08,138.17 148.08,137.83 148.37,137.54 148.99,137.54 149.29,137.83 149.29,138.24 149.41,138.37 149.83,138.37 149.95,138.24 149.95,136.63 150.24,136.35 150.82,136.35 151.11,136.63 151.11,138.05 151.23,138.18 151.63,138.18 151.76,138.05 151.76,137.45 152.06,137.14 152.84,137.14 154.73,135.26 155.84,135.26 157.77,133.33 158.58,133.33 159,132.92 159,132.36 163.77,127.58 167.28,127.58 167.42,127.44 167.42,127.07 167.73,126.77 168.27,126.77 168.57,127.07 168.57,127.5 168.7,127.62 169.17,127.62 169.3,127.5 169.3,125.26 169.59,124.96 170.22,124.96 170.51,125.26 170.51,125.98 170.64,126.11 171.15,126.11 171.28,125.98 171.28,125.55 171.57,125.26 172.14,125.26 172.43,125.55 172.43,126 172.55,126.12 172.9,126.12 173.01,126 173.01,125.46 173.31,125.17 173.87,125.17 174.17,125.46 174.17,126 174.28,126.12 174.64,126.12 174.75,126 174.75,125.65 175.04,125.37 175.62,125.37 175.91,125.65 175.91,126 176.02,126.12 176.37,126.12 176.49,126 176.49,125.65 176.77,125.37 177.36,125.37 177.64,125.65 177.64,126 177.76,126.12 178.11,126.12 178.23,126 178.23,124.74 178.52,124.44 179.19,124.44 179.49,124.74 179.49,125.82 179.61,125.95 180.08,125.95 180.21,125.82 180.21,123.97 180.58,123.6 182.49,123.6 184.43,121.67 186.53,121.67 186.83,121.97 186.83,122.81 186.96,122.94 187.44,122.94 187.56,122.81 187.56,121.92 187.85,121.64 188.43,121.64 188.72,121.92 188.72,122.8 188.84,122.92 189.17,122.92 189.3,122.8 189.3,121.92 189.58,121.64 190.17,121.64 190.45,121.92 190.45,122.73 190.58,122.86 190.91,122.86 191.04,122.73 191.04,121.92 191.32,121.64 191.91,121.64 192.19,121.92 192.19,122.81 192.32,122.94 192.72,122.94 192.84,122.81 192.84,121.96 193.14,121.66 193.71,121.66 194,121.96 194,122.24 194.17,122.41 196.79,122.41 197.9,121.3 197.9,118.77 198.2,118.47 198.85,118.47 199.14,118.77 199.14,119.96 199.27,120.09 199.6,120.09 199.72,119.96 199.72,118.78 200.01,118.5 200.59,118.5 200.88,118.78 200.88,119.94 201,120.07 201.47,120.07 201.6,119.94 201.6,119.48 201.9,119.18 203.23,119.18 203.49,118.93 203.49,118.57 203.36,118.44 203.2,118.44 v1(203.12,118.52)
MXM_LVDS_B0+: length 196.6
  TOP w0.102: v3(54.38,132.8) 54.59,133.02 54.76,133.02 55,133.26 55.2,133.26 55.27,133.19 U13.18 ; JMXM1.225 195.21,114.77 194.89,115.09 194.89,115.34 v1(194.73,115.51)
  BOTTOM w0.102: v1(194.73,115.51) 194.79,115.44 195.02,115.44 195.11,115.53 195.11,115.88 192.63,118.35 190.54,118.35 190.14,118.75 190.14,122.77 190.02,122.9 189.65,122.9 189.52,122.77 189.52,122.47 189.24,122.19 188.76,122.19 188.48,122.47 188.48,122.74 188.31,122.91 186.29,122.91 184.74,124.46 184.44,124.46 183.39,125.52 182.69,125.52 181.61,126.6 169.87,126.6 169.3,127.17 155.69,127.17 152.76,130.1 144.23,130.1 143.98,130.35 137.19,130.35 136.9,130.07 136.9,121.36 131.29,115.75 131.29,115.15 130.35,114.22 130.35,113.97 118.56,102.17 104.54,102.17 102.6,100.23 82.93,100.23 81.18,101.98 78.93,101.98 78.1,102.81 78.1,104.15 75.64,106.61 75.64,107.02 68.82,113.85 68.82,115.21 64.08,119.94 64.08,129.6 64.16,129.68 64.16,130.01 64.07,130.1 56.01,130.1 55.42,130.69 55.42,132.44 54.78,133.08 54.63,133.08 54.38,132.83 v3(54.38,132.8)
MXM_LVDS_B0-: length 196.6
  TOP w0.102: v1(195.54,115.51) 195.5,115.55 195.25,115.55 195.16,115.46 195.16,115.2 195.32,115.04 196.73,115.04 196.81,115.11 196.81,115.18 196.9,115.27 JMXM1.223 ; U13.17 55.36,133.69 55.19,133.53 54.89,133.53 54.65,133.28 54.54,133.28 v3(54.38,133.44)
  BOTTOM w0.102: v1(195.54,115.51) 195.38,115.67 195.38,115.99 192.74,118.62 190.65,118.62 190.41,118.86 190.41,122.88 190.13,123.17 189.54,123.17 189.25,122.88 189.25,122.58 189.13,122.45 188.87,122.45 188.75,122.58 188.75,122.85 188.42,123.18 186.4,123.18 184.85,124.73 184.55,124.73 183.5,125.79 182.8,125.79 181.72,126.87 169.98,126.87 169.41,127.44 155.8,127.44 152.87,130.37 144.34,130.37 144.09,130.62 137.07,130.62 136.63,130.18 136.63,121.47 131.02,115.86 131.02,115.26 130.09,114.33 130.09,114.08 118.45,102.44 104.43,102.44 102.49,100.5 83.04,100.5 81.29,102.25 79.04,102.25 78.37,102.92 78.37,104.26 75.91,106.72 75.91,107.13 69.08,113.96 69.08,115.32 64.35,120.05 64.35,129.49 64.43,129.57 64.43,130.12 64.18,130.37 56.12,130.37 55.69,130.8 55.69,132.55 54.89,133.35 54.47,133.35 v3(54.38,133.44)
MXM_LVDS_B1+: length 197.9
  TOP w0.102: U13.22 58.27,131.73 58.04,131.5 58.04,131.21 v3(58.27,130.99) ; v1(195.07,117.4) 195.26,117.21 195.26,116.9 195.89,116.27 JMXM1.219
  BOTTOM w0.102: v3(58.27,130.99) 58.05,130.99 57.97,131.06 57.97,131.19 57.81,131.35 57.81,131.72 58.53,132.44 59.38,132.44 62.27,135.32 63.22,135.32 63.64,134.9 63.64,133.97 66.78,130.84 66.78,123.48 68.21,122.04 68.21,119.82 74.33,113.7 74.33,112.02 78.65,107.7 78.65,107.16 81.2,104.61 81.85,104.61 83.58,102.88 101.64,102.88 103.68,104.93 118.11,104.93 127.98,114.8 127.98,115.66 134.62,122.3 134.62,131.36 136.35,133.1 153.01,133.1 155.31,130.8 159.44,130.8 160.5,129.74 170.22,129.74 171.11,128.85 175.67,128.85 176,129.17 183.07,129.17 184.48,130.58 185.05,130.58 185.64,130 187.73,130 194.28,123.44 195.81,123.44 197.04,122.22 197.04,119.26 196.52,118.75 196.3,118.75 195.5,117.94 195.5,117.32 195.4,117.22 195.25,117.22 v1(195.07,117.4)
MXM_LVDS_B1-: length 197.8
  TOP w0.102: v1(195.93,117.4) 195.62,117.4 195.53,117.31 195.53,117.01 196.01,116.54 196.67,116.54 196.73,116.59 196.73,116.71 196.79,116.77 JMXM1.217 ; v3(57.54,130.99) 57.77,131.22 U13.21
  BOTTOM w0.102: v3(57.54,130.99) 57.54,131.83 58.42,132.7 59.27,132.7 62.16,135.59 63.33,135.59 63.9,135.01 63.9,134.08 67.04,130.95 67.04,123.59 68.48,122.15 68.48,119.93 74.6,113.81 74.6,112.13 78.92,107.81 78.92,107.27 81.31,104.88 81.96,104.88 83.69,103.15 101.53,103.15 103.57,105.19 118,105.19 127.71,114.91 127.71,115.77 134.35,122.41 134.35,131.47 136.24,133.36 153.12,133.36 155.42,131.06 159.55,131.06 160.61,130.01 170.33,130.01 171.22,129.12 175.56,129.12 175.89,129.44 182.96,129.44 184.37,130.85 185.16,130.85 185.75,130.26 187.84,130.26 194.39,123.71 195.92,123.71 197.31,122.33 197.31,119.15 196.63,118.48 196.41,118.48 195.77,117.83 195.77,117.56 v1(195.93,117.4)
MXM_LVDS_B2+: length 199.8
  TOP w0.102: U13.26 60.27,131.5 v1(60.72,131.05) ; JMXM1.213 196.9,117.77 196.84,117.83 196.47,117.83 195.3,119 195.3,119.34 v3(195.13,119.51)
  BOTTOM w0.102: v1(60.72,131.05) 60.55,130.87 60.39,130.87 60.29,130.97 60.29,131.25 60.55,131.51 61.54,131.51 62.03,131.03 64.23,131.03 65.25,130 65.25,119.91 70.36,114.81 70.36,113.54 71.67,112.23 71.94,112.23 77.11,107.05 77.11,106.54 80.78,102.87 81.47,102.87 83.36,100.98 102.27,100.98 104.42,103.12 118.45,103.12 129.55,114.23 129.55,115.08 136.15,121.68 136.15,130.71 136.77,131.33 144.22,131.33 144.7,130.85 153.1,130.85 155.09,128.85 157.93,128.85 158.64,128.14 169.59,128.14 170.39,127.35 176.29,127.35 176.55,127.61 182.52,127.61 182.62,127.51 182.62,126.65 182.9,126.37 183.38,126.37 183.66,126.65 183.66,127.51 183.76,127.61 184.03,127.61 184.16,127.48 184.16,126.6 184.44,126.31 185.32,126.31 185.57,126.57 185.57,126.91 185.7,127.04 185.95,127.04 186.08,126.91 186.08,124.37 186.78,123.67 190.71,123.67 190.9,123.47 190.9,119.59 191.19,119.3 191.88,119.3 192.16,119.59 192.16,121.96 192.29,122.09 192.75,122.09 192.88,121.96 192.88,119.54 193.16,119.25 193.77,119.25 194.05,119.54 194.05,120.87 194.18,120.99 195.38,120.99 195.5,120.87 195.5,119.55 195.38,119.42 195.22,119.42 v3(195.13,119.51)
MXM_LVDS_B2-: length 199.8
  TOP w0.102: U13.25 59.77,131.66 59.86,131.58 59.94,131.58 60.01,131.51 60.01,131.2 v3(59.86,131.05) ; JMXM1.211 196.89,118.27 196.82,118.21 196.82,118.15 196.77,118.1 196.58,118.1 195.57,119.11 195.57,119.51 195.65,119.6 195.84,119.6 v1(195.93,119.51)
  BOTTOM w0.102: v1(195.93,119.51) 195.77,119.67 195.77,120.98 195.49,121.26 194.07,121.26 193.79,120.98 193.79,119.65 193.66,119.52 193.28,119.52 193.15,119.65 193.15,122.07 192.87,122.35 192.18,122.35 191.9,122.07 191.9,119.7 191.77,119.57 191.3,119.57 191.17,119.7 191.17,123.58 190.82,123.94 186.89,123.94 186.35,124.48 186.35,127.02 186.07,127.31 185.59,127.31 185.31,127.02 185.31,126.68 185.21,126.58 184.56,126.58 184.43,126.71 184.43,127.59 184.15,127.87 183.65,127.87 183.4,127.62 183.4,126.76 183.27,126.64 183.01,126.64 182.89,126.76 182.89,127.62 182.63,127.87 176.44,127.87 176.18,127.62 170.5,127.62 169.7,128.41 158.75,128.41 158.04,129.12 155.21,129.12 153.21,131.11 144.81,131.11 144.33,131.6 136.66,131.6 135.89,130.82 135.89,121.79 129.28,115.19 129.28,114.34 118.34,103.39 104.31,103.39 102.16,101.24 83.47,101.24 81.58,103.14 80.89,103.14 77.38,106.65 77.38,107.16 72.05,112.5 71.78,112.5 70.62,113.65 70.62,114.92 65.52,120.02 65.52,130.11 64.34,131.29 62.14,131.29 61.65,131.78 60.44,131.78 60.02,131.36 60.02,131.21 v3(59.86,131.05)
MXM_LVDS_BCLK+: length 198.3
  TOP w0.102: v1(195.11,121.86) 195.27,121.69 195.27,121.44 195.79,120.93 196.75,120.93 196.91,120.77 JMXM1.201 ; U13.31 62.42,134.69 62.52,134.6 62.79,134.6 v3(62.98,134.78)
  BOTTOM w0.102: v3(62.98,134.78) 62.77,134.57 62.28,134.57 61.94,134.23 61.94,133.24 62.65,132.53 63.88,132.53 66,130.4 66,122.83 67.38,121.45 67.38,119.24 71.83,114.8 71.83,113.4 77.89,107.34 77.89,106.86 81,103.75 81.65,103.75 83.26,102.13 102.32,102.13 104.16,103.98 118.24,103.98 128.73,114.46 128.73,115.35 135.4,122.02 135.4,131.05 136.6,132.25 152.79,132.25 155.33,129.7 158.16,129.7 158.96,128.91 169.98,128.91 170.79,128.1 175.98,128.1 176.31,128.42 185.81,128.42 186.09,128.7 186.09,129.11 186.22,129.24 186.74,129.24 186.87,129.11 186.87,124.82 187.15,124.54 187.73,124.54 188.02,124.82 188.02,128.08 188.14,128.21 188.4,128.21 188.52,128.08 188.52,124.87 188.81,124.59 189.34,124.59 189.62,124.87 189.62,126.48 189.75,126.61 190,126.61 190.13,126.48 190.13,124.72 190.41,124.44 190.89,124.44 191.17,124.72 191.17,124.97 191.3,125.1 191.55,125.1 191.68,124.97 191.68,124.22 193.22,122.68 195.13,122.68 195.27,122.54 195.27,122.02 v1(195.11,121.86)
MXM_LVDS_BCLK-: length 198.3
  TOP w0.102: v1(195.97,121.86) 195.84,121.98 195.63,121.98 195.54,121.89 195.54,121.55 195.9,121.2 196.81,121.2 196.88,121.27 JMXM1.199 ; v3(62.98,134.15) 62.8,134.33 62.56,134.33 62.42,134.19 U13.30
  BOTTOM w0.102: v1(195.97,121.86) 195.87,121.76 195.63,121.76 195.54,121.85 195.54,122.65 195.24,122.95 193.33,122.95 191.95,124.33 191.95,125.08 191.66,125.36 191.19,125.36 190.9,125.08 190.9,124.83 190.78,124.7 190.52,124.7 190.4,124.83 190.4,126.59 190.11,126.87 189.64,126.87 189.35,126.59 189.35,124.98 189.23,124.85 188.92,124.85 188.79,124.98 188.79,128.19 188.51,128.47 188.03,128.47 187.75,128.19 187.75,124.93 187.62,124.8 187.26,124.8 187.13,124.93 187.13,129.22 186.85,129.5 186.11,129.5 185.82,129.22 185.82,128.81 185.7,128.69 176.2,128.69 175.87,128.37 170.9,128.37 170.09,129.17 159.07,129.17 158.27,129.97 155.44,129.97 152.9,132.51 136.49,132.51 135.14,131.16 135.14,122.13 128.46,115.46 128.46,114.57 118.13,104.24 104.05,104.24 102.21,102.4 83.37,102.4 81.76,104.01 81.11,104.01 78.15,106.97 78.15,107.46 72.1,113.51 72.1,114.91 67.65,119.36 67.65,121.56 66.27,122.95 66.27,130.51 63.99,132.79 62.76,132.79 62.2,133.35 62.2,134.12 62.39,134.3 62.83,134.3 v3(62.98,134.15)
MXM_LVDS_DDC_CLK: length 224.5
  TOP w0.102: v3(201.38,154.28) 200.89,154.77 JMXM1.71 ; v1(70.89,138.58) 70.89,138.65 71.16,138.91 71.16,139.7 71.22,139.76 71.65,139.76 71.73,139.69 R1122.2 71.73,139.23 72.01,138.95 72.01,138.88 71.93,138.8 71.52,138.8 71.33,138.61 71.33,138.24 71.03,137.94 71.03,137.64 71.22,137.45 U11.5
  IN3 w0.127: v3(201.38,154.28) 201.5,154.28 201.94,153.84 201.94,153.59 201.81,153.47 196.78,153.47 196.52,153.21 196.52,152.55 196.76,152.3 202.32,152.3 202.45,152.17 202.45,151.69 202.32,151.56 197.28,151.56 197.15,151.44 197.15,150.73 197.41,150.47 201.81,150.47 201.89,150.39 201.89,148.63 202.21,148.31 202.21,143.24 201.62,142.66 200.01,142.66 197.69,140.34 196.4,140.34 186.96,130.89 182.41,130.89 180.62,129.1 162.57,129.1 160.54,131.13 155.68,131.13 153.09,133.72 137.74,133.72 137.44,133.43 133.37,133.43 127.1,127.15 127.1,124.04 126.06,123 126.06,120.2 125.77,119.91 125.77,118.01 125.35,117.6 116.63,117.6 114.75,115.72 110.86,115.72 109.79,114.66 96.52,114.66 96.23,114.95 92.45,114.95 91.22,116.18 89.15,116.18 87.11,118.22 81.45,118.22 80.18,116.95 76.16,116.95 73.43,119.69 73.43,130.56 71.96,132.03 71.96,134.19 71.5,134.65 70.88,134.65 70.59,134.94 70.59,135.78 68.56,137.8 68.56,138.01 68.71,138.15 69.08,138.15 69.21,138.02 69.21,137.85 69.33,137.72 69.59,137.72 69.71,137.85 69.71,138.02 69.84,138.15 70.18,138.15 70.31,138.02 70.31,137.03 70.43,136.91 72.03,136.91 72.16,136.78 72.16,136.5 72.29,136.37 72.64,136.37 72.77,136.5 72.77,137.49 72.64,137.62 71.09,137.62 70.89,137.82 v1(70.89,138.58)
MXM_LVDS_DDC_DAT: length 224.4
  TOP w0.102: U11.13 65.99,134.42 R1121.2 65.98,134.88 66.37,135.27 66.37,136.79 v3(66.8,137.22) ; v1(195.17,154.24) 195.17,154.09 195.29,153.98 195.6,153.98 195.72,154.09 195.72,155.16 195.83,155.27 JMXM1.69
  IN3 w0.127: v3(66.8,137.22) 66.51,137.52 66.51,137.85 66.78,138.11 67.93,138.11 70.33,135.71 70.33,134.85 70.79,134.39 71.42,134.39 71.72,134.1 71.72,131.95 73.2,130.46 73.2,119.58 76.06,116.73 80.28,116.73 81.55,118 87.01,118 89.06,115.95 91.04,115.95 92.28,114.72 96.13,114.72 96.42,114.43 109.92,114.43 110.98,115.49 114.84,115.49 116.72,117.37 125.45,117.37 126,117.92 126,119.81 126.39,120.21 126.39,122.8 127.33,123.74 127.33,127.04 133.49,133.2 137.54,133.2 137.76,133.41 152.96,133.41 155.52,130.86 160.39,130.86 162.38,128.87 180.78,128.87 182.57,130.66 187.05,130.66 196.5,140.11 197.78,140.11 200.11,142.43 201.74,142.43 202.44,143.12 202.44,148.41 202.12,148.72 202.12,150.49 201.91,150.7 197.51,150.7 197.38,150.83 197.38,151.21 197.51,151.33 202.42,151.33 202.68,151.59 202.68,152.27 202.42,152.53 196.87,152.53 196.75,152.65 196.75,153.11 196.87,153.24 201.91,153.24 202.17,153.5 202.17,154.12 201.57,154.72 195.66,154.72 v1(195.17,154.24)
MXM_MB_DP_AUX: length 130
  TOP w0.102: JMXM1.309 198.45,93.77 198.5,93.82 198.5,93.96 198.54,93.99 198.91,93.99 199.22,93.68 199.22,93.42 199.78,92.86 199.78,92.53 199.44,92.2 v1(199.36,92.2)
  IN3 w0.127: v1(199.36,92.2) 199.43,92.2 199.75,91.87 199.75,91.17 200.75,90.18 203.56,90.18 203.95,90.56 204.11,90.56 205.12,89.56 212.28,89.56 213.13,90.41 216.09,90.41 218.81,87.69 229.6,87.69 229.94,87.35 232.54,87.35 234.01,85.88 235.63,85.88 236.26,85.26 237.17,85.26 238.16,84.26 240.05,84.26 241.21,83.11 244.51,83.11 245.78,81.84 250.26,81.84 251.15,80.95 251.15,71.43 251.7,70.88 272.3,70.88 272.78,70.4 274.69,70.4 275.39,69.7 284.03,69.7 286.57,72.24 289.71,72.24 289.99,72.52 290.68,72.52 290.88,72.31 290.88,72.15 v3(290.55,71.82)
  IN4 w0.117: v1(293.2,64.07) 293.76,64.63 293.76,67.44 290.72,70.48 290.72,71.65 v3(290.55,71.82)
  BOTTOM w0.102: U22.33 287.92,73.04 288.04,72.93 288.68,72.93 289.04,72.57 289.55,72.06 289.55,71.8 290.22,71.13 290.67,71.13 290.92,71.38 290.92,71.45 290.68,71.69 290.68,71.69 v3(290.55,71.82) 290.57,71.82 290.8,72.05 290.8,72.35 290.67,72.49 C397.1 ; Q340.1 v1(293.2,64.07)
MXM_MB_DP_AUX#: length 130.1
  TOP w0.102: v1(200.06,92.2) 200.05,92.2 200.05,92.97 199.49,93.53 199.49,93.79 199.01,94.27 JMXM1.307
  IN3 w0.127: v1(291.18,71.82) 291.18,72.44 290.8,72.82 289.86,72.82 289.58,72.54 286.45,72.54 283.91,70 275.51,70 274.81,70.7 272.91,70.7 272.43,71.18 251.83,71.18 251.46,71.55 251.46,81.08 250.39,82.14 245.9,82.14 244.63,83.41 241.34,83.41 240.18,84.57 238.29,84.57 237.3,85.56 236.38,85.56 235.76,86.18 234.14,86.18 232.66,87.66 230.07,87.66 229.73,88 218.93,88 216.22,90.72 213,90.72 212.15,89.87 205.24,89.87 204.24,90.87 203.82,90.87 203.43,90.48 200.87,90.48 200.06,91.3 v1(200.06,92.2)
  IN4 w0.117: v1(291.18,71.82) 291.01,71.64 291.01,70.6 294.04,67.56 294.04,64.26 v1(294.5,63.81)
  BOTTOM w0.102: U22.34 287.92,72.54 288.04,72.66 288.57,72.66 v1(288.85,72.38) 289.28,71.95 289.28,71.69 290.1,70.87 290.78,70.87 291.18,71.27 v1(291.18,71.82) 291.04,71.96 291.04,72.26 291.27,72.49 C398.1 ; Q340.4 v1(294.5,63.81)
MXM_MB_DP_AUX#_C: length 5.4
  BOTTOM w0.102: U22.29 v1(288.83,75.04) 290.83,75.04 291.31,74.56 v1(291.31,74.11) 291.31,73.56 C398.2
MXM_MB_DP_AUX_C: length 6
  BOTTOM w0.102: U22.30 287.92,74.54 288.15,74.78 v1(290.37,74.78) 290.72,74.78 290.98,74.51 290.98,74.41 v1(290.68,74.11) 291.01,73.77 291.01,73.44 290.83,73.27 290.59,73.27 C397.2
MXM_MB_DP_HPD: length 111.4
  TOP w0.102: v1(194.71,89.31) 194.91,89.12 194.91,86.98 194.63,86.7 U27.2 193.39,86.7 192.87,87.22 192.87,88.15 192.66,88.37 192.66,88.46 192.12,88.99 D8.2
  IN1 w0.109: v1(206.75,86.87) 205.45,85.56 203.4,85.56 200.94,88.02 197.78,88.02 196.94,88.86 195.2,88.86 194.75,89.31 v1(194.71,89.31)
  IN3 w0.127: v1(206.75,86.87) 207.61,86.02 215.48,86.02 217.07,84.43 220.32,84.43 221.48,85.59 230.52,85.59 231.18,84.94 233.04,84.94 233.74,84.24 236.66,84.24 237.76,83.14 238.02,83.14 238.34,82.82 238.34,82.22 239.08,81.48 243.01,81.48 243.36,81.84 244.34,81.84 247.27,78.91 247.27,77.6 249.82,75.04 249.82,71.06 251.8,69.08 272.96,69.08 v3(273.54,68.49)
  BOTTOM w0.102: U22.9 279.79,75.54 279.5,75.25 278.98,75.25 278.85,75.12 278.42,75.12 277.43,74.13 276.43,74.13 276.25,73.95 276.25,72.77 274,70.52 274,68.94 273.56,68.49 v3(273.54,68.49)
MXM_MB_DP_HPD_GATE: length 18.8
  TOP w0.102: v2(197.5,85.22) 197.45,85.27 R60.1 ; R60.1 197.58,86.47 197.89,86.78 197.89,87.12 198.23,87.47 204.34,87.47 204.57,87.69 204.57,92.27 204.96,92.66 204.96,94.4 205.08,94.52 JMXM1.304 ; R60.1 196.98,86.47 196.57,86.05 U27.4
MXM_MB_DP_N0: length 113
  TOP w0.102: v1(199.49,100.88) 199.55,100.94 199.61,100.94 199.75,100.8 199.75,100.23 199.57,100.04 198.73,100.04 198.69,100.08 198.69,100.22 198.64,100.27 JMXM1.283
  IN4 w0.117: v3(288.58,66.58) 288.69,66.69 288.69,67.34 288.07,67.97 285.86,67.97 280.75,73.08 280.75,80.48 279.79,81.44 272.63,81.44 272.39,81.2 246.95,81.2 246.82,81.33 238.16,81.33 236.22,83.27 235.32,83.27 234.56,84.03 233.94,84.03 232.94,85.02 231.2,85.02 228.43,87.79 227.54,87.79 221.49,93.83 211,93.83 204.84,100 200.06,100 199.68,100.38 199.68,100.68 v1(199.49,100.88)
  BOTTOM w0.102: C284.1 288.76,67.17 288.76,66.75 v3(288.58,66.58)
MXM_MB_DP_N0_C: length 5.2
  BOTTOM w0.102: C284.2 288.53,68.48 288.82,68.77 288.82,68.89 288.27,69.44 v1(286.74,69.44) 286.11,69.44 285.64,69.91 285.64,70.24 285.53,70.36 U22.39
MXM_MB_DP_N1: length 121.2
  TOP w0.102: v1(195.29,99.71) 195.24,99.76 194.98,99.76 194.85,99.63 194.85,98.81 195.12,98.54 196.56,98.54 196.79,98.77 JMXM1.289
  IN4 w0.117: v3(284.52,66.58) 284.71,66.77 284.71,67.3 282.63,69.38 279.53,69.38 278.61,70.3 278.61,74.56 279.96,75.91 279.96,80.02 279.33,80.65 276.25,80.65 275.33,79.73 252.78,79.73 252.1,80.42 247.42,80.42 246.94,79.93 243.35,79.93 242.77,80.51 237.13,80.51 236.39,81.26 235.24,81.26 234.85,81.65 234.85,82.62 234.26,83.22 233.64,83.22 232.66,84.2 230.91,84.2 228.59,86.51 227.65,86.51 221.11,93.05 210.39,93.05 204.91,98.53 203.3,98.53 202.67,99.16 198.7,99.16 196.79,101.06 196.31,101.06 195.62,100.37 195.23,100.37 194.85,99.99 194.85,99.53 194.97,99.4 195.16,99.4 195.29,99.53 v1(195.29,99.71)
  BOTTOM w0.102: C283.1 284.7,67.16 284.7,66.77 v3(284.52,66.58)
MXM_MB_DP_N1_C: length 2.9
  BOTTOM w0.102: C283.2 284.51,68.48 284.71,68.68 284.71,68.89 284.6,68.99 284.54,68.99 284.14,69.39 v1(284.14,69.6) 284.14,70.14 284.03,70.26 U22.42
MXM_MB_DP_N2: length 109
  TOP w0.102: v1(200.91,97.18) 201,97.18 201.13,97.05 201.13,96.98 201.26,96.85 201.26,96.75 201.22,96.71 199.5,96.71 199.17,97.04 198.72,97.04 198.63,97.13 198.63,97.23 198.59,97.27 JMXM1.295
  IN4 w0.117: v1(200.91,97.18) 201.11,96.98 201.11,96.73 201.4,96.44 201.94,96.44 202.47,96.97 204.86,96.97 209.56,92.27 220.79,92.27 227.33,85.73 228.24,85.73 230.62,83.35 231.61,83.35 232.76,82.19 232.76,81.83 233.23,81.37 234.02,81.37 234.92,80.47 236.06,80.47 236.81,79.73 237.68,79.73 238.52,78.88 239.38,78.88 240.02,79.52 240.8,79.52 241.57,78.74 245.36,78.74 245.6,78.98 247.28,78.98 247.47,79.17 252.24,79.17 252.46,78.95 276.28,78.95 276.45,79.12 277.36,79.12 278.04,78.43 278.71,78.43 279.17,77.97 279.17,76.45 277.83,75.11 277.83,69.97 279.31,68.49 281.54,68.49 282.64,67.39 282.64,66.74 v3(282.48,66.58)
  BOTTOM w0.102: C286.1 282.66,67.17 282.66,66.76 v3(282.48,66.58)
MXM_MB_DP_N2_C: length 2.5
  BOTTOM w0.102: U22.45 282.53,70.31 282.67,70.17 v1(282.67,69.51) 282.67,68.86 C286.2
MXM_MB_DP_N3: length 107.9
  TOP w0.102: JMXM1.301 198.41,95.77 198.59,95.59 198.78,95.59 198.96,95.42 200.52,95.42 200.73,95.2 200.73,94.53 v1(200.72,94.51)
  IN4 w0.117: v3(280.21,66.57) 280.21,66.56 280.41,66.36 280.58,66.36 280.66,66.43 280.66,66.79 280.8,66.94 280.8,67.57 280.67,67.7 278.99,67.7 277.05,69.65 277.05,75.5 277.66,76.11 277.66,77.59 277.08,78.17 250.16,78.17 249.73,77.74 244.04,77.74 243.86,77.56 242.57,77.56 242.51,77.62 234.76,77.62 234.25,78.12 234.25,79.32 232.97,80.59 232.71,80.59 230.74,82.57 228.99,82.57 228.29,83.27 228.29,83.61 224.03,87.87 218.51,87.87 215.95,90.42 208.46,90.42 207.1,91.78 207.1,93.18 204.63,95.65 200.9,95.65 200.37,95.12 200.37,94.85 200.71,94.51 v1(200.72,94.51)
  BOTTOM w0.102: C282.1 280.58,67.22 280.58,66.7 280.45,66.57 v3(280.21,66.57)
MXM_MB_DP_N3_C: length 2.7
  BOTTOM w0.102: C282.2 280.63,68.85 280.63,69.42 v1(280.83,69.62) 281.14,69.93 281.14,70.03 281.03,70.15 U22.48
MXM_MB_DP_P0: length 113.1
  TOP w0.102: JMXM1.285 198.59,99.77 198.59,99.77 199.68,99.77 200.02,100.11 200.02,100.72 v1(200.18,100.88)
  IN4 w0.117: v1(200.18,100.88) 200,100.7 200,100.46 200.18,100.28 204.95,100.28 211.12,94.12 221.61,94.12 227.65,88.08 228.55,88.08 231.31,85.31 233.06,85.31 234.06,84.32 234.68,84.32 235.44,83.55 236.34,83.55 238.28,81.62 246.94,81.62 247.06,81.49 272.28,81.49 272.51,81.73 279.91,81.73 281.04,80.6 281.04,73.2 285.98,68.26 288.18,68.26 288.98,67.46 288.98,66.81 v3(289.22,66.58)
  BOTTOM w0.102: C285.1 289.03,67.15 289.03,66.77 v3(289.22,66.58)
MXM_MB_DP_P0_C: length 5.1
  BOTTOM w0.102: C285.2 289.09,68.8 289.09,69 288.38,69.71 v1(288.03,69.71) 286.22,69.71 285.91,70.02 285.91,70.18 286.03,70.3 U22.38
MXM_MB_DP_P1: length 121.3
  TOP w0.102: v1(194.4,99.71) 194.61,99.5 194.61,98.67 195.01,98.27 JMXM1.291
  IN4 w0.117: v3(285.15,66.58) 284.99,66.74 284.99,67.42 282.75,69.66 279.65,69.66 278.9,70.41 278.9,74.44 280.25,75.79 280.25,80.14 279.45,80.94 276.13,80.94 275.21,80.02 252.9,80.02 252.22,80.7 247.31,80.7 246.82,80.22 243.47,80.22 242.89,80.8 237.25,80.8 236.51,81.54 235.36,81.54 235.14,81.76 235.14,82.74 234.38,83.5 233.75,83.5 232.78,84.48 231.03,84.48 228.71,86.8 227.77,86.8 221.23,93.34 210.51,93.34 205.03,98.82 203.41,98.82 202.79,99.44 198.82,99.44 196.91,101.35 196.19,101.35 195.51,100.66 195.11,100.66 194.56,100.11 194.56,99.87 v1(194.4,99.71)
  BOTTOM w0.102: v3(285.15,66.58) 284.97,66.77 284.97,67.16 C280.1
MXM_MB_DP_P1_C: length 2.9
  BOTTOM w0.102: U22.41 284.53,70.28 284.41,70.17 284.41,69.5 284.65,69.26 284.72,69.26 284.97,69 284.97,68.67 285.16,68.48 C280.2
MXM_MB_DP_P2: length 109.1
  TOP w0.102: JMXM1.297 198.6,96.77 198.6,96.77 199.06,96.77 199.39,96.44 201.33,96.44 201.52,96.64 201.52,97.16 v1(201.54,97.18)
  IN4 w0.117: v3(283.12,66.58) 282.92,66.78 282.92,67.51 281.66,68.77 279.43,68.77 278.11,70.09 278.11,74.99 279.45,76.33 279.45,78.08 278.82,78.72 278.16,78.72 277.48,79.4 276.33,79.4 276.17,79.23 252.58,79.23 252.36,79.45 247.35,79.45 247.16,79.26 245.48,79.26 245.24,79.02 241.69,79.02 240.92,79.8 239.9,79.8 239.26,79.16 238.64,79.16 237.79,80.01 236.93,80.01 236.18,80.76 235.04,80.76 234.14,81.65 233.34,81.65 233.05,81.95 233.05,82.31 231.72,83.64 230.74,83.64 228.36,86.02 227.44,86.02 220.91,92.55 209.68,92.55 204.98,97.26 202.35,97.26 201.82,96.72 201.52,96.72 201.43,96.82 201.43,97.06 201.42,97.06 v1(201.54,97.18)
  BOTTOM w0.102: C281.1 282.93,67.15 282.93,66.77 v3(283.12,66.58)
MXM_MB_DP_P2_C: length 2.5
  BOTTOM w0.102: C281.2 282.94,68.86 282.94,70.17 283.03,70.26 U22.44
MXM_MB_DP_P3: length 107.9
  TOP w0.102: v1(200.09,94.51) 200.04,94.56 200.04,94.82 200.09,94.87 200.42,94.87 200.47,94.92 200.47,95.09 200.41,95.15 198.85,95.15 198.67,95.33 198.55,95.33 198.49,95.27 JMXM1.303
  IN4 w0.117: v3(281.1,66.57) 281.09,66.59 281.09,67.69 280.79,67.99 279.11,67.99 277.33,69.76 277.33,75.38 277.94,75.99 277.94,77.71 277.2,78.45 250.04,78.45 249.61,78.02 243.92,78.02 243.74,77.84 242.69,77.84 242.63,77.9 234.87,77.9 234.53,78.24 234.53,79.43 233.09,80.88 232.83,80.88 230.86,82.86 229.11,82.86 228.57,83.39 228.57,83.73 224.15,88.15 218.63,88.15 216.07,90.71 208.58,90.71 207.39,91.9 207.39,93.29 204.75,95.94 200.79,95.94 200.09,95.24 v1(200.09,94.51)
  BOTTOM w0.102: C279.1 281.11,67.53 280.85,67.27 280.85,66.7 280.97,66.57 v3(281.1,66.57)
MXM_MB_DP_P3_C: length 2.8
  BOTTOM w0.102: U22.47 281.53,70.15 281.41,70.03 281.41,69.82 280.9,69.31 280.9,68.86 C279.2
MXM_OVERT#: length 5
  TOP w0.102: JMXM1.56 206.71,158.52 v2(207.97,157.25) R10.2 208.92,156.84 208.75,156.67 Q4.3
MXM_PANEL_BKEN: length 141.9
  TOP w0.102: v1(85.79,140.08) 85.72,140.02 D64.2 ; v1(196.53,157.32) 196.58,157.27 JMXM1.61 ; v1(150.56,153.57) 150.56,153.42 149.54,152.4 149.54,147.99 150.79,146.74 150.79,138.11 152.22,136.68 v1(152.47,136.68)
  IN2 w0.127: v1(152.47,136.68) 151.7,136.68 151.15,136.13 114.07,136.13 113.05,137.15 106.13,137.15 105.43,137.85 104.65,137.85 104.29,137.49 88.16,137.49 85.79,139.86 v1(85.79,140.08) ; v1(150.56,153.57) 150.63,153.65 152.19,153.65 156.88,158.33 157.97,158.33 160.67,161.04 164.87,161.04 167.78,158.13 179.06,158.13 179.34,157.85 184.58,157.85 184.86,158.13 189.88,158.13 191.3,156.71 195.96,156.71 196.53,157.28 v1(196.53,157.32)
  BOTTOM w0.102: v1(85.79,140.08) 85.79,139.61 v2(85.53,139.36)
MXM_PIN80: length 131.7
  TOP w0.102: R1161.1 100.4,157.41 100.04,157.05 99.12,157.05 98.77,157.4 98.77,157.67 v2(98.25,158.19) 97.36,159.08 v1(97.36,159.12) 97.36,159.73 97.66,160.03 100.56,160.03 Q85.3 ; v1(207.1,154.94) 207.46,154.58 R1976.1
  IN2 w0.127: v1(207.1,154.94) 205.32,156.72 200.22,156.72 196.9,160.05 196.33,160.05 195.86,159.58 193.13,159.58 191.74,160.96 186.16,160.96 185.58,161.53 183.44,161.53 182.31,160.4 176.12,160.4 174.13,162.4 172.8,162.4 172.02,163.18 158.56,163.18 152.73,157.35 151.47,157.35 150.45,158.37 148.36,158.37 147.61,159.12 144.21,159.12 143.14,158.05 131.93,158.05 131.65,157.77 131.65,157.49 130.85,156.69 128.73,156.69 125.44,153.4 121.66,153.4 120.69,154.38 117.32,154.38 116.46,155.25 112.08,155.25 108.81,158.51 97.97,158.51 v1(97.36,159.12)
MXM_PIN80_R: length 7.2
  TOP w0.102: R1161.2 99.45,159.01 99.13,159.32 Q85.1 98.12,159.32 v1(97.85,159.59)
  BOTTOM w0.102: JMINI1.37 97.84,157.84 97.6,158.09 v2(97.6,158.52) 97.85,158.78 v1(97.85,159.59)
MXM_PRESENTL#: length 326.1
  TOP w0.102: v1(14.9,123.01) 14.9,123.32 v2(15.37,123.79) ; v1(20.24,122.28) 20.07,122.45 UH4.E38 ; JMXM1.310 198.55,93.27 198.84,92.98 v1(198.84,92.91)
  IN1 w0.109: v1(198.84,92.91) 197.21,92.91 191.84,98.28 191.84,107.74 192.63,108.54 192.63,115.66 194.81,117.83 197.37,117.83 198.98,119.44 198.98,125.57 198.13,126.42 198.13,128.54 197.45,129.22 197.45,151.27 190.9,157.81 190.9,161.94 189.72,163.13 181.92,163.13 180.33,164.72 158.5,164.72 152.12,158.34 148.73,158.34 148,157.61 144.79,157.61 144.61,157.79 137.01,157.79 136.75,158.04 134.48,158.04 132.89,159.63 129.88,159.63 128.32,161.19 128.32,168.72 127.54,169.5 112.86,169.5 108.23,164.87 108.23,162.2 103.9,157.87 101.8,157.87 100.86,156.94 100.86,154.72 93.75,147.61 80.3,147.61 79.94,147.97 75.67,147.97 75.42,148.21 70.31,148.21 68.25,150.27 68.25,150.41 66.31,152.35 59.21,152.35 58.93,152.63 49.83,152.63 48.13,150.93 48.13,150.43 44.66,146.95 40.45,146.95 37.84,149.56 35.49,149.56 35.04,150.01 34.4,150.01 33.24,148.85 24.55,148.85 21.61,145.92 21.61,143.87 18.77,141.02 18.04,141.02 14.99,137.97 14.55,137.97 12.89,136.31 12.43,136.31 11.42,135.3 11.42,134.05 10.34,132.97 10.34,129.03 9.12,127.81 9.12,127.13 10.1,126.15 10.46,126.15 11.57,125.04 11.57,124.43 11.83,124.17 12.43,124.17 12.44,124.18 13.32,124.18 14.47,123.03 14.9,123.03 ; 14.9,123.03 v1(14.9,123.01) ; 14.9,123.03 14.9,123.37 15.29,123.76 15.94,123.76 16.1,123.6 17.47,123.6 18.21,122.86 19.68,122.86 20.24,122.3 v1(20.24,122.28)
  BOTTOM w0.102: v1(14.9,123.01) 14.88,123.01 14.31,123.58 RH178.1
MXM_PRESENTR#: length 299.4
  TOP w0.102: v1(204.58,161.76) 204.58,162.43 205.17,163.02 JMXM1.38 ; RH179.1 15.09,125.54 v1(15.95,124.68) 16.05,124.57 16.5,124.57 17.09,123.98 17.6,123.98 17.73,124.1 17.98,124.1 18.15,123.94 18.43,123.94 18.76,124.27 UH4.C41
  IN2 w0.127: v1(15.95,124.68) 15.95,125.51 17.16,126.72 17.16,129.6 17.7,130.15 17.7,131.59 17.97,131.85 22.06,131.85 22.45,132.25 28.14,132.25 29.16,133.26 37.88,133.26 38.49,133.87 45.85,133.87 47.79,135.81 48.23,135.81 48.46,136.04 48.46,136.49 49.13,137.16 55.25,137.16 55.35,137.26 61.47,137.26 62.03,137.82 64.21,137.82 65.27,136.75 66.2,136.75 66.55,136.41 67.47,136.41 70.06,133.82 70.24,133.82 70.97,133.1 73.14,133.1 75.76,130.47 79.91,130.47 81.09,129.3 81.09,128 82.29,126.8 92.67,126.8 93.88,128 94.93,128 97.09,125.84 101.77,125.84 102.99,124.63 105.46,124.63 105.73,124.36 107.47,124.36 109.26,122.57 109.26,120.26 110.12,119.39 115.38,119.39 117.46,117.31 119.23,117.31 121.62,114.92 128.8,114.92 129.83,115.95 130.72,115.95 130.99,115.68 130.99,113.55 131.81,112.73 156.82,112.73 157.08,112.98 168.73,112.98 168.9,112.81 177.19,112.81 179.79,110.22 179.79,106.98 180.47,106.3 180.47,104.98 181.47,103.98 181.47,102.55 182.87,101.16 183.39,101.16 184.02,100.52 v1(184.02,100.39)
  IN3 w0.127: v1(200.67,105.98) 201.31,106.62 202.34,106.62 203.65,107.93 204.86,107.93 207.11,110.17 v1(207.82,110.17)
  BOTTOM w0.102: v1(207.82,110.17) 207.82,111.13 207.28,111.67 207.28,112.44 208.84,114 208.84,115.28 209.26,115.7 210.07,115.7 210.87,116.5 210.87,135.84 213.27,138.24 213.27,157.47 211.95,158.79 207.53,158.79 206.51,159.8 206.51,161.42 206.17,161.76 v1(204.58,161.76) ; v1(184.02,100.39) 184.02,101.04 187.32,104.34 195.2,104.34 195.98,105.13 v2(197.84,105.13) 199.82,105.13 v1(200.67,105.98)
MXM_PWR_LEVEL: length 15.9
  TOP w0.102: JMXM1.54 206.8,159.02 207.92,157.9 v1(208.13,157.9)
  BOTTOM w0.102: v1(208.13,157.9) 208.13,156.87 206.85,155.59 v2(205.7,155.59) 204.35,155.59 203.91,155.15 203.91,152.72 203.64,152.45 U17.4 202.28,152.45 202.17,152.34 R37.2 201.49,151.94 200.47,150.91 D19.2
MXM_RSVD1: length 3.2
  TOP w0.102: JMXM1.268 206.63,103.52 v3(207.48,104.37)
  BOTTOM w0.102: v3(207.48,104.37) 208.35,103.49 R6.2
MXM_RSVD2: length 3.7
  TOP w0.102: JMXM1.270 206.76,103.02 v1(207.48,103.73)
  BOTTOM w0.102: R9.2 207.97,102.53 v2(207.48,103.02) v1(207.48,103.73)
NB_LAN_TX0+: length 2.5
  BOTTOM w0.089: T156.24 94.21,158.07 94.12,158.16 93.83,158.16 93.74,158.24 93.74,158.51 R575.1
NB_LAN_TX0+_R: length 12.9
  BOTTOM w0.089: JLOM1.1 84.87,162.27 85.06,162.46 85.06,163.13 85.74,163.81 v1(88.99,163.81) 90.74,163.81 93.89,160.66 93.89,159.99 R575.2
NB_LAN_TX0-: length 2.5
  BOTTOM w0.089: R576.1 93.4,158.51 93.4,158.24 93.31,158.16 93.03,158.16 92.94,158.07 T156.23
NB_LAN_TX0-_R: length 12.9
  BOTTOM w0.089: JLOM1.2 85.09,161.32 85.09,162 85.41,162.32 85.41,162.99 85.88,163.46 90.6,163.46 v1(93.17,160.89) 93.55,160.51 93.55,159.8 93.43,159.69 93.17,159.69 R576.2
NB_LAN_TX1+: length 3.3
  BOTTOM w0.089: T156.20 89.13,158.07 89.04,158.16 88.75,158.16 88.64,158.26 88.64,159.14 88.76,159.26 88.97,159.26 R577.1
NB_LAN_TX1+_R: length 8.6
  IN1 w0.102: v3(91.35,159.16) 91.25,159.26 87.77,159.26 87.35,159.68 87.35,159.87 86.26,160.96 JLOM1.3
  BOTTOM w0.089: v3(91.35,159.16) 91.2,159.31 90.45,159.31 R577.2
NB_LAN_TX1-: length 3.9
  BOTTOM w0.089: T156.19 87.86,158.07 87.95,158.16 88.23,158.16 88.3,158.23 88.3,159.28 88.62,159.6 88.84,159.6 R578.1
NB_LAN_TX1-_R: length 7.8
  IN1 w0.102: v3(91.35,159.8) 91.16,159.61 87.92,159.61 87.7,159.83 87.7,160.43 88.62,161.34 89.15,161.34 JLOM1.6
  BOTTOM w0.089: R578.2 90.48,159.65 91.2,159.65 v3(91.35,159.8)
NB_LAN_TX2+: length 9.1
  IN3 w0.114: v3(86.45,158.97) 86.32,159.11 86.18,159.11 86.03,158.96 86.03,158.62 86.28,158.37 86.74,158.37 87.08,158.71 87.08,159.58 87.93,160.43 87.93,160.95 87.71,161.17 JLOM1.4
  BOTTOM w0.089: v3(86.45,158.97) 86.45,159.27 86.32,159.4 86.15,159.4 86.02,159.27 86.02,158.35 86.15,158.22 86.41,158.22 86.59,158.04 86.59,156.89
NB_LAN_TX2-: length 9.1
  IN3 w0.114: v3(85.6,158.97) 85.67,158.9 85.67,158.46 86.13,158 86.89,158 87.45,158.56 87.45,159.42 88.3,160.27 JLOM1.5
  BOTTOM w0.089: T156.17 85.32,157.9 85.68,158.26 85.68,158.89 v3(85.6,158.97)
NB_LAN_TX3+: length 15.6
  IN4 w0.102: v3(83.25,160.03) 83.09,159.87 83.09,159.61 83.29,159.42 84.42,159.42 84.85,159.86 90.34,159.86 90.52,160.04 90.52,160.22 90.34,160.4 JLOM1.7
  BOTTOM w0.089: v3(83.25,160.03) 83.25,160.03 83.24,160.03 83.09,159.88 83.09,159.42 82.72,159.04 81.31,159.04 81.04,158.77 81.04,158.34 81.51,157.87 T156.14
NB_LAN_TX3-: length 15.8
  IN4 w0.102: JLOM1.8 90.88,160.69 90.88,160.36 90.88,159.89 90.49,159.5 84.99,159.5 84.56,159.07 83.14,159.07 82.74,159.47 82.74,159.91 v1(82.62,160.03)
  BOTTOM w0.089: v1(82.62,160.03) 82.75,159.9 82.75,159.56 82.57,159.39 v2(81.38,159.39) 81.16,159.39 80.69,158.92 80.69,158.29 80.24,157.84 T156.13
NB_PSID: length 8.6
  TOP w0.254: PJPDC1.2 5.2,73.37 4.71,72.89 v1(4.71,71.6)
  BOTTOM w0.102: v2(2.67,70.7) 3.39,70.7 4,71.31 PL3.2
  BOTTOM w0.254: v1(4.71,71.6) 4.7,71.6 4.35,71.95 PL3.2
NB_PSID_TS5A63157: length 5.5
  BOTTOM w0.254: PU1.3 4.05,76.8 4.3,77.05 v2(4.84,77.05) 5.19,77.05 PR8.1 PR9.2 5.72,74.96 PD7.1
NC_1: length 1.3
  TOP w0.102: UH4.P37 24.22,121.59 v1(24.13,121.5)
  BOTTOM w0.102: v1(24.13,121.5) 24.52,121.11 T108.1
NC_P: length 3.9
  TOP w0.102: C554.1 176.12,95.89 175.55,96.46 175.55,96.52 v2(175.36,96.71) 175.18,96.71 174.76,97.13 U37.14 U39.14
Net_85:
  vias: v1(282.64,9.23) v1(282.64,8.6) v1(282.61,6.07) v1(282.62,5.4)
NTC: length 49.9
  TOP w0.203: PU702.10 24.13,76.99 23.8,76.66 23.8,76.02 v2(23.38,75.6) 23.01,75.6 22.68,75.27 22.68,74.49 PR735.1
  TOP w0.254: PH703.1 v1(39.6,54.72) ; PR735.1 22.11,73.98 21.6,74.49 20.67,74.49 v1(20.55,74.36)
  IN4 w0.254: v1(39.6,54.72) 36.65,54.72 35.72,53.8 34.12,53.8 32.88,55.04 32.88,59 29.69,62.19 29.69,72.57 31.33,74.21 31.33,75.01 30.81,75.53 29.29,75.53 28.29,76.53 24.34,76.53 23.79,77.08 22.58,77.08 21.46,75.96 21.46,75.07 20.75,74.36 v1(20.55,74.36)
NTCG: length 39.7
  TOP w0.203: PR717.1 22.18,80.07 22.88,79.38 v1(22.96,79.38) 23.07,79.26 23.92,79.26 24.05,79.39 PU702.4
  TOP w0.254: PH702.1 41.75,91.83 42.15,92.23 43.7,92.23 44.11,91.82 v1(44.11,91.73)
  IN3 w0.254: v1(44.11,91.73) 43.94,91.57 43.94,85.13 v1(44.04,85.03)
  IN4 w0.254: v1(44.04,85.03) 43.48,84.47 33.31,84.47 32.97,84.8 31.32,84.8 30.81,85.3 25.56,85.3 23.3,83.04 23.3,80.33 22.96,79.99 v1(22.96,79.38)
  BOTTOM w0.102: v2(24.04,79.44) 23.91,79.31 23.02,79.31 v1(22.96,79.38)
