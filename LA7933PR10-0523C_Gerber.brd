# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D4: length 95
  TOP w0.089: v3(92.4,40.92) 91.9,41.42 JCPU1.A9
  TOP w0.14: v1(152.27,20.84) 152.27,21.13 151.81,21.6 150.5,21.6 150.1,22 JDIMM3.6
  IN3 w0.089: v3(92.4,40.92) 92.8,41.32 93.57,41.32 93.8,41.09 93.8,40.11 93.75,40.06
  IN3 w0.127: v1(152.27,20.84) 152.21,20.84 151.15,19.78 151.15,19.31 148.19,16.36 147.81,16.36 146.87,17.3 145.44,17.3 145.31,17.17 145.31,17.08 145.18,16.96 144.95,16.96 144.83,17.08 144.83,17.83 144.7,17.96 144.45,17.96 144.32,17.83 144.32,16.49 144.19,16.36 143.94,16.36 143.81,16.49 143.81,17.96 143.68,18.09 143.43,18.09 143.3,17.96 143.3,16.49 143.18,16.36 142.92,16.36 142.79,16.49 142.79,17.13 142.67,17.26 142.41,17.26 142.29,17.13 142.29,16.49 142.16,16.36 141.51,16.36 141.02,15.86 137.34,15.86 136.05,17.15 132.74,17.15 132.23,17.66 131.52,17.66 131.05,18.12 125.43,18.12 125.39,18.17 120.47,18.17 119.84,18.81 118.73,18.81 118.58,18.96 111.15,18.96 107.02,23.09 103.46,23.09 102.78,23.76 100.9,23.76 94.89,29.77 94.89,38.37 93.75,39.51 93.75,40.06
  BOTTOM w0.14: v1(152.27,20.84) 152.27,21.01 150.98,22.3 JDIMM4.7
DDR_B_D5: length 93
  TOP w0.089: JCPU1.A8 92.9,41.42 v1(93.4,40.92)
  TOP w0.14: v1(155.32,20.85) 155.32,21.01 156.01,21.7 JDIMM3.5
  IN3 w0.089: 93.4,40.32 v1(93.4,40.92)
  IN3 w0.127: v1(155.32,20.85) 155.24,20.77 155.24,20.32 155.34,20.22 156.54,20.22 156.67,20.09 156.67,19.58 156.54,19.46 154.24,19.46 154.11,19.58 154.11,20.01 153.99,20.13 152.44,20.13 148.33,16.03 147.51,16.03 147.38,16.15 147.38,16.32 147.25,16.45 146.91,16.45 146.79,16.32 146.79,16.15 146.66,16.03 146.33,16.03 146.2,16.15 146.2,16.84 146.07,16.97 145.78,16.97 145.65,16.84 145.65,16.15 145.53,16.03 145.26,16.03 145.13,16.15 145.13,16.29 145.01,16.42 144.73,16.42 144.6,16.29 144.6,16.15 144.47,16.03 141.65,16.03 141.16,15.53 137.2,15.53 135.92,16.82 132.59,16.82 132.08,17.32 131.38,17.32 130.91,17.79 125.31,17.79 125.26,17.84 120.34,17.84 119.7,18.48 118.59,18.48 118.44,18.63 111.01,18.63 106.89,22.76 103.32,22.76 102.65,23.43 100.77,23.43 94.56,29.63 94.56,38.18 93.4,39.34 93.4,40.32
  BOTTOM w0.14: v1(155.32,20.85) 155.26,20.91 155.26,21.17 155.48,21.4 JDIMM4.4
DDR_B_D6: length 96.9
  TOP w0.089: v1(91.4,43.95) 91.4,43.92 91.9,44.42 JCPU1.D9
  TOP w0.14: JDIMM3.18 151.44,25.6 152.43,24.61 v1(152.43,24.59)
  IN3 w0.089: v1(91.4,43.95) 91.98,44.53 91.98,45.08 92.24,45.34 94.57,45.34 94.8,45.1 94.8,42.99 95.25,42.55 95.64,42.55 95.99,42.19 95.99,41.76 98.07,39.69
  IN3 w0.127: v1(152.43,24.59) 151.97,24.13 150.15,24.13 147.71,21.69 144.7,21.69 144.58,21.57 144.58,21.21 144.45,21.08 144.19,21.08 144.07,21.21 144.07,21.57 143.94,21.69 143.63,21.69 143.5,21.57 143.5,21.16 143.37,21.03 143.12,21.03 142.99,21.16 142.99,21.57 142.87,21.69 142.61,21.69 142.49,21.57 142.49,21.15 142.36,21.02 142.1,21.02 141.98,21.15 141.98,21.57 141.85,21.69 141.51,21.69 141.39,21.57 141.39,21.22 141.26,21.1 136.61,21.1 136.55,21.03 136.55,19.7 136.42,19.57 136.08,19.57 135.95,19.7 135.95,20.89 135.82,21.02 135.52,21.02 135.39,20.89 135.39,19.7 135.27,19.57 135.01,19.57 134.89,19.7 134.89,20.18 134.76,20.31 134.5,20.31 134.38,20.18 134.38,19.7 134.25,19.57 134,19.57 133.87,19.7 133.87,19.94 133.73,20.08 132.59,20.08 132.12,20.55 128.61,20.55 128.31,20.85 126.09,20.85 125.7,21.25 119.77,21.25 119.63,21.39 113.33,21.39 110.32,24.4 110.32,25.3 108.51,27.12 103.8,27.12 99.93,30.98 99.93,37.82 98.07,39.69
  BOTTOM w0.14: JDIMM4.17 151.88,25.3 152.43,24.75 v1(152.43,24.59)
DDR_B_D7: length 94.1
  TOP w0.089: v3(92.4,43.95) 92.4,43.92 92.9,44.42 JCPU1.D8
  TOP w0.14: JDIMM3.15 156.27,24.7 155.85,24.28 155.6,24.28 155.48,24.4 v1(155.48,24.59)
  IN3 w0.089: v3(92.4,43.95) 92.8,44.35 93.57,44.35 93.8,44.11 93.8,42.74 94.17,42.38 94.55,42.38 95,41.93 95,41.8 97.12,39.69
  IN3 w0.127: 97.12,39.69 97.26,39.54 97.26,29.89 100.7,26.45 108.01,26.45 109.66,24.81 109.66,24.12 112.93,20.86 112.93,20.85 113.05,20.73 119.34,20.73 119.49,20.57 125.44,20.57 126.13,19.89 131.82,19.89 132.28,19.42 132.96,19.42 133.47,18.91 137.02,18.91 137.15,19.04 137.15,19.36 137.27,19.48 137.62,19.48 137.74,19.36 137.74,18.12 138.24,17.63 139.45,17.63 140.12,18.3 140.12,19.72 140.24,19.85 146.81,19.85 150.43,23.47 153.3,23.47 153.65,23.82 153.84,24 154.84,24 154.96,23.88 154.96,23.01 155.09,22.89 155.45,22.89 155.57,23.01 155.57,24.49 v1(155.48,24.59)
  BOTTOM w0.14: JDIMM4.16 155.53,25 155.41,24.88 155.41,24.66 v1(155.48,24.59)
DDR_B_D8: length 84.6
  TOP w0.089: JCPU1.G4 96.9,47.42 96.4,46.92 v1(96.4,46.94)
  TOP w0.14: v1(151.08,27.35) 150.66,27.35 150.1,26.8 JDIMM3.22
  IN3 w0.089: v1(96.4,46.94) 96.81,46.94 97.42,46.34 97.42,45.22 98,44.63 98,42.79 98.25,42.55 98.99,42.55 100.52,41.02 101.81,41.02 102.28,40.55
  IN3 w0.127: v1(151.08,27.35) 151.21,27.35 151.53,27.03 151.53,26.73 151.22,26.42 151.04,26.42 150.51,26.96 150.51,27.27 150.42,27.36 149.97,27.36 149.73,27.12 149.73,26.94 150.01,26.66 150.01,26.48 149.83,26.3 149.65,26.3 149.37,26.58 149.19,26.58 149.01,26.4 149.01,26.22 149.3,25.94 149.3,25.76 149.12,25.58 148.94,25.58 148.65,25.86 148.47,25.86 148.24,25.63 148.24,25.45 148.52,25.17 148.52,24.99 148.34,24.81 148.16,24.81 147.46,25.51 147.2,25.51 145.66,23.97 145.22,23.97 145.1,23.84 145.1,23.63 144.97,23.5 144.34,23.5 144.21,23.63 144.21,23.84 144.08,23.97 143.76,23.97 143.64,23.84 143.64,23.63 143.51,23.5 143.2,23.5 143.07,23.63 143.07,23.84 142.95,23.97 142.69,23.97 142.56,23.84 142.56,23.63 142.44,23.5 134.37,23.5 133.83,22.96 128.1,22.96 127.75,22.61 126.82,22.61 126.43,23 120.55,23 120.41,23.14 114.31,23.14 112.21,25.24 112.21,25.89 108.6,29.51 108.6,35.72 103.77,40.55 102.28,40.55
  BOTTOM w0.14: JDIMM4.21 150.23,26.5 v1(151.08,27.35)
DDR_B_D9: length 83.9
  TOP w0.089: JCPU1.F4 96.9,46.42 96.4,45.92 v3(96.4,45.92)
  TOP w0.14: JDIMM3.23 155.91,27.1 v1(155.65,27.35)
  IN3 w0.089: v3(96.4,45.92) 96.4,45.93 96.81,45.52 96.81,42.67 99.22,40.27 99.22,39.98 99.51,39.69
  IN3 w0.127: 99.51,39.69 100.7,38.5 100.7,31.68 104.5,27.88 108.82,27.88 111.09,25.62 111.09,24.71 113.65,22.15 119.98,22.15 120.12,22.01 126.02,22.01 126.41,21.62 128.17,21.62 128.46,21.91 134.21,21.91 134.81,22.51 136.66,22.51 136.74,22.43 136.74,22.25 136.8,22.19 137.21,22.19 137.54,21.86 140.59,21.86 141.19,22.45 145.56,22.45 145.89,22.78 146.42,22.78 146.75,22.45 147.1,22.45 148.29,23.64 148.58,23.64 150.37,25.43 154.85,25.43 155.65,26.23 v1(155.65,27.35)
  BOTTOM w0.14: v1(155.65,27.35) 155.81,27.51 156.13,27.51 156.24,27.4 JDIMM4.24
DDR_B_D10: length 81
  TOP w0.089: JCPU1.F1 99.9,46.42 100.4,45.92 v1(100.4,45.93)
  TOP w0.14: v1(151.08,30.52) 151.08,30.52 150.82,30.26 150.35,30.26 150.21,30.4 JDIMM3.34
  IN3 w0.127: v1(100.4,45.93) 100.4,45.96 100.53,46.09 100.77,46.09 100.9,45.96 100.9,44.92 101.03,44.79 101.33,44.79 101.57,45.03 101.78,45.03 110.36,36.45 110.36,30.24 113.97,26.62 113.97,26.15 114.1,26.03 114.44,26.03 114.51,25.95 114.51,25.95 114.91,25.95 115.04,25.82 115.04,25.59 114.91,25.46 114.82,25.46 114.7,25.34 114.7,25.24 115.02,24.92 115.78,24.92 115.91,25.04 115.91,25.44 116.04,25.57 116.27,25.57 116.39,25.44 116.39,25.04 116.52,24.92 117.25,24.92 117.38,25.04 117.38,25.24 117.51,25.36 117.76,25.36 117.89,25.24 117.89,25.03 118.02,24.91 118.27,24.91 118.4,25.03 118.4,25.31 118.52,25.43 118.78,25.43 118.9,25.31 118.9,25.05 118.9,25.05 119.04,24.91 119.33,24.91 119.43,25.01 119.43,25.2 119.54,25.31 119.79,25.31 119.92,25.18 119.92,25.04 120.05,24.92 120.3,24.92 120.43,25.04 120.43,25.16 120.56,25.29 120.81,25.29 120.94,25.16 120.94,24.97 120.99,24.92 121.17,24.92 121.32,24.77 125.04,24.77 125.13,24.85 128.25,24.85 128.32,24.78 131.19,24.78 131.94,25.53 135.7,25.53 135.9,25.73 141.45,25.73 141.58,25.86 141.58,26.16 141.71,26.29 141.96,26.29 142.09,26.16 142.09,25.86 142.21,25.73 142.8,25.73 142.89,25.83 142.89,26.15 142.63,26.41 142.63,26.59 142.81,26.77 142.99,26.77 143.54,26.22 143.72,26.22 143.9,26.4 143.9,26.58 143.35,27.13 143.35,27.31 143.53,27.49 143.71,27.49 143.97,27.22 144.15,27.22 144.33,27.4 144.33,27.58 144.07,27.84 144.07,28.02 144.25,28.2 144.43,28.2 144.69,27.94 144.87,27.94 145.11,28.18 148.19,28.18 150.54,30.52 v1(151.08,30.52)
  BOTTOM w0.14: v1(151.08,30.52) 151.17,30.44 151.17,30.19 151.08,30.1 JDIMM4.33
DDR_B_D11: length 81.1
  TOP w0.089: JCPU1.G1 99.9,47.42 v3(100.4,46.92)
  TOP w0.14: JDIMM3.36 152.13,31 v1(152.6,30.52)
  IN3 w0.089: 104.49,42.78 100.4,46.87 v3(100.4,46.92)
  IN3 w0.127: 104.49,42.78 110.69,36.59 110.69,30.37 114.77,26.29 117.71,26.29 117.85,26.15 117.85,25.75 117.97,25.62 118.23,25.62 118.36,25.75 118.36,26.15 118.49,26.29 118.76,26.29 118.91,26.14 118.91,25.77 119.04,25.64 119.67,25.64 119.8,25.77 119.8,26.16 119.92,26.29 120.24,26.29 120.37,26.16 120.37,25.77 120.5,25.64 120.92,25.64 121.47,25.1 124.09,25.1 124.23,25.24 124.23,25.51 124.35,25.64 124.61,25.64 124.74,25.51 124.74,25.24 124.79,25.18 128.38,25.18 128.45,25.11 130.41,25.11 130.41,25.11 131.05,25.11 131.81,25.86 135.56,25.86 135.76,26.06 136.4,26.06 136.96,26.62 142.2,26.62 144.2,28.62 148.11,28.62 150.51,31.02 151.17,31.02 151.26,31.11 151.26,31.27 151.39,31.39 151.74,31.39 151.87,31.27 151.87,31.07 152,30.94 152.25,30.94 152.38,31.07 152.38,31.27 152.5,31.39 152.81,31.39 152.94,31.27 152.94,30.65 152.81,30.52 v1(152.6,30.52)
  BOTTOM w0.14: v1(152.6,30.52) 152.6,30.86 152.44,31.02 150.69,31.02 150.37,30.7 JDIMM4.35
DDR_B_D12: length 87.3
  TOP w0.089: JCPU1.G5 95.9,47.42 95.4,46.92 v3(95.4,46.94)
  TOP w0.14: v1(152.6,27.35) 152.14,27.81 150.53,27.81 150.12,27.4 JDIMM3.24
  IN3 w0.089: v3(95.4,46.94) 95.82,46.52 96.74,46.52 97.18,46.08 97.18,45.15 97.82,44.51 97.82,42.72 98.17,42.37 98.88,42.37 100.49,40.76 101.6,40.76 102.68,39.69
  IN3 w0.127: 102.68,39.69 104.16,39.69 108.27,35.58 108.27,29.37 111.88,25.76 111.88,25.1 114.17,22.81 120.27,22.81 120.41,22.67 126.29,22.67 126.68,22.28 127.89,22.28 128.24,22.63 133.97,22.63 134.51,23.17 145.34,23.17 146.16,23.99 147.27,23.99 147.43,24.16 147.43,24.56 147.53,24.66 147.84,24.66 148.03,24.47 148.48,24.47 150.1,26.09 153.44,26.09 153.57,26.21 153.57,26.21 153.57,26.61 153.57,26.61 153.44,26.73 152.39,26.73 152.27,26.86 152.27,27.23 152.39,27.35 v1(152.6,27.35)
  BOTTOM w0.14: JDIMM4.23 150,27.1 150.82,27.93 152.03,27.93 v1(152.6,27.35)
DDR_B_D13: length 86.7
  TOP w0.089: JCPU1.F5 95.9,46.42 95.4,45.92 v1(95.4,45.92)
  TOP w0.14: JDIMM3.21 154.98,26.5 v1(154.13,27.35)
  IN3 w0.089: v1(95.4,45.92) 95.8,46.32 96.57,46.32 97,45.89 97,42.8 99.29,40.51 101.39,40.51 102.21,39.69
  IN3 w0.127: 102.21,39.69 102.54,39.36 104.03,39.36 107.94,35.45 107.94,29.23 111.55,25.62 111.55,24.96 114.03,22.48 120.13,22.48 120.27,22.34 126.15,22.34 126.55,21.95 128.03,21.95 128.38,22.3 134.14,22.3 134.67,22.84 137.03,22.84 137.67,22.19 140.46,22.19 141.1,22.84 145.48,22.84 146.3,23.66 147.41,23.66 147.88,24.13 148.61,24.13 150.23,25.76 153.83,25.76 153.96,25.88 153.96,26.1 154.08,26.23 154.37,26.23 154.49,26.35 154.49,26.75 154.37,26.87 154.25,26.87 154.13,27 v1(154.13,27.35)
  BOTTOM w0.14: v1(154.13,27.35) 154.86,26.62 155.47,26.62 155.65,26.8 JDIMM4.22
DDR_B_D14: length 83
  TOP w0.089: v3(99.4,45.96) 99.4,45.92 98.9,46.42 JCPU1.F2
  TOP w0.14: JDIMM3.33 156.25,30.1 156.17,30.02 154.63,30.02 v1(154.13,30.52)
  IN3 w0.089: 104.49,41.85 102.03,44.31 100.46,44.31 100,44.77 100,45.36 v3(99.4,45.96)
  IN3 w0.127: v1(154.13,30.52) 154.14,30.52 154.27,30.4 154.27,30.09 154.14,29.96 150.49,29.96 148.37,27.83 147.49,27.83 147.36,27.71 147.36,27.36 147.24,27.23 146.22,27.23 146.09,27.11 146.09,26.47 145.97,26.35 145.71,26.35 145.58,26.47 145.58,27.66 145.46,27.79 145.18,27.79 145.06,27.66 145.06,27.45 144.93,27.32 144.71,27.32 144.58,27.19 144.58,26.92 144.71,26.8 144.93,26.8 145.06,26.67 145.06,26.42 144.89,26.25 144.22,26.25 144.1,26.12 144.1,25.53 143.97,25.4 136.03,25.4 135.83,25.2 132.19,25.2 131.44,24.45 128.19,24.45 128.11,24.52 125.27,24.52 125.18,24.44 121.18,24.44 121.04,24.58 114.89,24.58 113.64,25.83 113.64,26.49 110.03,30.1 110.03,36.31 104.87,41.47 104.87,41.47 104.49,41.85
  BOTTOM w0.14: JDIMM4.34 156.47,30.4 156.11,30.04 154.47,30.04 154.13,30.38 v1(154.13,30.52)
DDR_B_D15: length 81.9
  TOP w0.089: JCPU1.G2 98.9,47.42 v1(99.4,46.92)
  TOP w0.14: JDIMM3.35 155.83,30.7 v1(155.65,30.52)
  IN3 w0.089: 104.49,41.38 101.81,44.07 100.45,44.07 99,45.52 99,46.52 v1(99.4,46.92)
  IN3 w0.127: v1(155.65,30.52) 156.23,30.52 156.35,30.4 156.35,29.76 156.23,29.63 155.45,29.63 155.33,29.76 155.33,29.95 155.2,30.08 154.95,30.08 154.82,29.95 154.82,29.76 154.69,29.63 151.72,29.63 151.6,29.5 151.6,29.08 151.47,28.95 151.22,28.95 151.09,29.08 151.09,29.5 150.96,29.63 150.63,29.63 150.5,29.5 150.5,29.08 150.38,28.95 150.01,28.95 147.94,26.88 146.97,26.88 145.16,25.07 136.17,25.07 135.97,24.87 132.33,24.87 131.52,24.06 128.02,24.06 127.89,24.19 125.5,24.19 125.42,24.11 121.04,24.11 120.9,24.24 114.76,24.24 113.31,25.69 113.31,26.35 109.7,29.96 109.7,36.18 104.87,41 104.49,41.38
  BOTTOM w0.14: v1(155.65,30.52) 156.13,31 JDIMM4.36
DDR_B_D16: length 83.5
  TOP w0.089: JCPU1.J7 93.9,49.42 v1(93.4,48.92)
  TOP w0.14: v1(151.22,32.35) 151.07,32.2 JDIMM3.40
  IN3 w0.089: v1(93.4,48.92) 93.4,48.83 93.83,48.4 93.83,47.6 93.92,47.52 100.62,47.52 104.28,43.86 104.49,43.86
  IN3 w0.127: 104.49,43.86 111.45,36.91 111.45,30.69 115.09,27.05 120.59,27.05 121.79,25.86 123.3,25.86 124.01,26.57 125.75,26.57 125.87,26.44 125.87,26.15 126,26.02 127.18,26.02 127.73,26.57 128.76,26.57 128.76,26.57 129.01,26.57 129.14,26.44 129.14,26.24 129.27,26.11 130.98,26.11 131.49,26.62 135.24,26.62 135.44,26.82 135.76,26.82 136.37,27.44 137.17,27.44 137.3,27.56 137.3,27.99 137.43,28.12 141.18,28.12 141.31,27.99 141.31,27.51 141.44,27.38 141.69,27.38 141.82,27.51 141.82,27.99 141.95,28.12 142.62,28.12 143.98,29.48 144.42,29.48 144.55,29.6 144.55,30.02 144.68,30.15 144.94,30.15 145.07,30.02 145.07,29.51 145.2,29.38 145.45,29.38 145.58,29.51 145.58,29.99 145.71,30.11 148.45,30.11 150.69,32.35 v1(151.22,32.35)
  BOTTOM w0.14: v1(151.22,32.35) 150.77,31.9 JDIMM4.39
DDR_B_D17: length 85.9
  TOP w0.089: JCPU1.J8 92.9,49.42 v3(92.4,48.92)
  TOP w0.14: v1(152.74,32.35) 152.29,32.8 JDIMM3.42
  IN3 w0.089: 104.49,43.39 100.55,47.34 93.42,47.34 92.87,47.89 92.87,48.45 v3(92.4,48.92)
  IN3 w0.127: 104.49,43.39 111.12,36.77 111.12,30.55 114.95,26.72 120.46,26.72 121.65,25.53 123.44,25.53 123.98,26.07 125.47,26.07 125.85,25.69 127.32,25.69 127.71,26.09 128.82,26.09 129.13,25.78 131.12,25.78 131.63,26.29 135.38,26.29 135.58,26.49 136.22,26.49 136.78,27.05 142.02,27.05 144.02,29.05 147.91,29.05 150.69,31.83 152.22,31.83 v1(152.74,32.35)
  BOTTOM w0.14: v1(152.74,32.35) 152.27,32.82 150.56,32.82 150.24,32.5 JDIMM4.41
DDR_B_D18: length 89.2
  TOP w0.089: v1(90.4,49.92) 90.9,50.42 JCPU1.K10
  TOP w0.14: JDIMM3.51 156.3,35.5 156.01,35.2 154.85,35.2 154.36,35.69 v1(154.26,35.69)
  IN3 w0.089: 104.49,47.29 103.17,48.61 101.58,48.61 100.68,49.51 100.25,49.51 99.8,49.95 99.8,50.08 99.55,50.33 99.11,50.33 98.92,50.52 98.24,50.52 98,50.75 98,50.88 97.57,51.32 93.24,51.32 92.87,50.95 92.87,50.82 92.38,50.33 92.25,50.33 91.97,50.05 91.97,49.92 91.57,49.52 90.8,49.52 v1(90.4,49.92)
  IN3 w0.127: 104.49,47.29 113.87,37.91 113.87,33.7 117.86,29.72 122.35,29.72 122.47,29.59 122.47,29.22 122.6,29.1 122.86,29.1 122.98,29.22 122.98,29.59 123.11,29.72 123.36,29.72 123.49,29.59 123.49,29.22 123.62,29.1 123.87,29.1 124,29.22 124,29.59 124.13,29.72 124.38,29.72 124.51,29.59 124.51,29.35 124.63,29.22 124.89,29.22 125.01,29.35 125.01,29.59 125.14,29.72 129.3,29.72 129.53,29.95 130.83,29.95 131.56,30.68 135.67,30.68 136.95,31.96 142.38,31.96 144.41,33.99 148.76,33.99 150.91,36.14 153.82,36.14 v1(154.26,35.69)
  BOTTOM w0.14: JDIMM4.50 154.76,35.2 v1(154.26,35.69)
DDR_B_D19: length 86.4
  TOP w0.089: v3(91.4,49.92) 91.9,50.42 JCPU1.K9
  TOP w0.14: v1(155.79,35.69) 156.2,36.1 JDIMM3.53
  IN3 w0.089: v3(91.4,49.92) 91.8,50.32 91.8,50.89 92.41,51.5 98.39,51.5 99,50.89 99,50.75 99.24,50.52 99.63,50.52 99.83,50.32 100.58,50.32 101.69,49.21 103.03,49.21 104.49,47.75
  IN3 w0.127: v1(155.79,35.69) 155.01,36.47 150.77,36.47 148.66,34.35 144.31,34.35 142.24,32.29 136.81,32.29 136.36,31.83 135.64,31.83 135.51,31.71 135.51,31.42 135.38,31.29 135.13,31.29 135,31.42 135,31.71 134.87,31.83 134.62,31.83 134.49,31.71 134.49,31.14 134.37,31.01 134.11,31.01 133.98,31.14 133.98,31.71 133.86,31.83 131.3,31.83 131.17,31.71 131.17,30.76 130.69,30.28 129.39,30.28 129.16,30.05 117.99,30.05 114.2,33.84 114.2,38.05 104.49,47.75
  BOTTOM w0.14: v1(155.79,35.69) 155.9,35.8 JDIMM4.52
DDR_B_D20: length 87.2
  TOP w0.089: v1(91.4,48.92) 91.9,49.42 JCPU1.J9
  TOP w0.14: JDIMM3.39 156.2,31.9 156.14,31.84 154.77,31.84 v1(154.26,32.35)
  IN3 w0.089: v1(91.4,48.92) 91.61,48.92 92.01,49.32 93.57,49.32 93.82,49.06 93.82,48.68 94.18,48.32 97.56,48.32 98.19,47.7 100.69,47.7 104.06,44.33 104.49,44.33
  IN3 w0.127: 104.49,44.33 111.78,37.04 111.78,30.83 115.22,27.38 120.73,27.38 121.11,27.01 122.07,27.01 122.72,26.35 123.33,26.35 123.98,27.01 135.16,27.01 135.31,27.15 135.62,27.15 136.24,27.77 136.78,27.77 136.91,27.89 136.91,28.33 137.04,28.45 142.49,28.45 144.52,30.48 148.3,30.48 150.61,32.79 154.23,32.79 154.36,32.66 154.36,32.44 v1(154.26,32.35)
  BOTTOM w0.14: v1(154.26,32.35) 154.76,31.85 155.95,31.85 156.3,32.2 JDIMM4.40
DDR_B_D21: length 85.4
  TOP w0.089: v3(90.4,48.92) 90.9,49.42 JCPU1.J10
  TOP w0.14: v1(155.79,32.35) 155.94,32.5 JDIMM3.41
  IN3 w0.089: 104.49,44.79 103.85,44.79 100.75,47.89 98.27,47.89 97.65,48.51 94.25,48.51 94,48.75 94,49.14 93.64,49.5 91.94,49.5 91.78,49.34 91.15,49.34 90.73,48.92 v3(90.4,48.92)
  IN3 w0.127: 104.49,44.79 112.11,37.18 112.11,30.96 115.36,27.71 120.87,27.71 121.24,27.34 135.02,27.34 135.17,27.48 135.48,27.48 136.78,28.78 142.35,28.78 144.42,30.85 148.15,30.85 150.42,33.12 155.01,33.12 v1(155.79,32.35)
  BOTTOM w0.14: v1(155.79,32.35) 156.24,32.8 JDIMM4.42
DDR_B_D22: length 85.1
  TOP w0.089: v1(92.4,49.92) 92.9,50.42 JCPU1.K8
  TOP w0.14: v1(151.09,35.69) 150.6,35.2 JDIMM3.50
  IN3 w0.089: 104.49,46.82 103.09,48.22 101.71,48.22 100.61,49.32 99.43,49.32 98.94,49.81 98.94,49.97 98.56,50.34 98.15,50.34 97.98,50.51 93.42,50.51 92.84,49.92 v1(92.4,49.92)
  IN3 w0.127: 104.49,46.82 113.54,37.77 113.54,33.57 117.77,29.34 121.26,29.34 121.84,28.77 125.35,28.77 125.47,28.89 125.47,29.26 125.6,29.39 125.85,29.39 125.98,29.26 125.98,28.89 126.11,28.77 126.36,28.77 126.49,28.89 126.49,29.26 126.62,29.39 126.87,29.39 127,29.26 127,28.89 127.12,28.77 127.38,28.77 127.5,28.89 127.5,29.26 127.63,29.39 127.89,29.39 128.01,29.26 128.01,28.89 128.14,28.77 128.41,28.77 128.7,29.06 130.2,29.06 130.64,29.49 133.53,29.49 133.66,29.62 133.66,30.22 133.79,30.35 134.04,30.35 134.17,30.22 134.17,29.58 134.29,29.46 134.66,29.46 134.78,29.58 134.78,30.17 134.88,30.27 135.85,30.27 136.48,30.9 141.79,30.9 142.91,32.02 143.09,32.02 143.23,31.87 143.41,31.87 143.59,32.05 143.59,32.23 143.45,32.38 143.45,32.56 143.63,32.74 143.81,32.74 143.95,32.59 144.13,32.59 144.31,32.77 144.31,32.95 144.17,33.09 144.17,33.27 144.51,33.62 147.36,33.62 147.48,33.49 147.48,33.19 147.61,33.06 147.87,33.06 147.99,33.19 147.99,33.49 148.12,33.62 148.89,33.62 150.97,35.69 v1(151.09,35.69)
  BOTTOM w0.14: v1(151.09,35.69) 150.9,35.5 JDIMM4.51
DDR_B_D23: length 85.5
  TOP w0.089: v3(93.4,49.92) 93.9,50.42 JCPU1.K7
  TOP w0.14: v1(152.61,35.69) 152.15,36.16 150.71,36.16 150.35,35.8 JDIMM3.52
  IN3 w0.089: 104.49,46.35 103.03,47.82 101.61,47.82 100.92,48.5 99.25,48.5 98.8,48.95 98.8,49.08 98.37,49.51 98.26,49.51 98,49.77 98,49.89 97.57,50.33 94.25,50.33 93.84,49.92 v3(93.4,49.92)
  IN3 w0.127: v1(152.61,35.69) 152.61,35.34 152.49,35.21 150.96,35.21 148.33,32.59 144.6,32.59 143.6,31.59 143.37,31.36 143.21,31.36 143.05,31.51 142.87,31.51 142.68,31.32 142.68,31.14 142.86,30.97 142.86,30.84 142.61,30.6 142.47,30.6 142.33,30.74 142.1,30.74 141.93,30.57 136.62,30.57 135.17,29.13 130.74,29.13 130.05,28.44 121.7,28.44 121.13,29.01 117.09,29.01 116.95,29.14 116.95,29.55 116.83,29.67 116.57,29.67 116.44,29.55 116.44,29.14 116.31,29.01 115.97,29.01 115.89,29.09 115.89,30.75 113.21,33.43 113.21,37.64 104.49,46.35
  BOTTOM w0.14: JDIMM4.53 150.23,36.1 150.46,36.32 151.98,36.32 v1(152.61,35.69)
DDR_B_D24: length 83
  TOP w0.089: JCPU1.M5 95.9,52.41 95.42,51.93 95.4,51.93 v1(95.4,51.92)
  TOP w0.14: JDIMM3.59 156.36,37.9 155.66,38.6 154.44,38.6 153.98,38.14 v1(153.98,38.01)
  IN3 w0.089: 104.49,48.83 103.45,49.87 101.88,49.87 101.08,50.67 101.08,50.82 100.41,51.5 98.89,51.5 98.26,52.13 96.82,52.13 96.61,52.34 95.82,52.34 v1(95.4,51.92)
  IN3 w0.127: 104.49,48.83 114.96,38.36 114.96,34.16 117.51,31.61 118.12,31.61 118.25,31.48 118.25,31.34 118.37,31.22 118.63,31.22 118.75,31.34 118.75,31.48 118.88,31.61 119.58,31.61 120.38,30.81 128.84,30.81 130.63,32.6 136.01,32.6 136.97,33.55 142.43,33.55 144.05,35.17 148.39,35.17 150.45,37.23 154.07,37.23 154.2,37.35 154.2,37.78 v1(153.98,38.01)
  BOTTOM w0.14: JDIMM4.58 156.49,37.6 155.56,38.53 154.38,38.53 153.98,38.13 v1(153.98,38.01)
DDR_B_D25: length 82.3
  TOP w0.089: v1(96.4,52.94) 96.4,52.92 96.9,53.42 JCPU1.N4
  TOP w0.14: JDIMM3.56 151.21,37 152.07,37.86 v1(152.07,38.01)
  IN3 w0.089: v1(96.4,52.94) 96.09,52.94 95.96,52.82 95.96,52.64 96.09,52.51 96.75,52.51 96.95,52.32 98.32,52.32 98.97,51.67 100.48,51.67 102.05,50.1 103.69,50.1 104.49,49.3
  IN3 w0.127: 104.49,49.3 115.29,38.5 115.29,34.29 117.65,31.94 119.71,31.94 120.51,31.14 123.28,31.14 123.4,31.27 123.4,31.59 123.53,31.71 123.79,31.71 123.91,31.59 123.91,31.27 124.04,31.14 124.29,31.14 124.42,31.27 124.42,31.59 124.55,31.71 124.8,31.71 124.93,31.59 124.93,31.27 125.06,31.14 126.61,31.14 126.74,31.27 126.74,31.5 126.87,31.62 127.06,31.62 127.19,31.5 127.19,31.27 127.32,31.14 127.52,31.14 127.65,31.27 127.65,31.59 127.77,31.71 127.99,31.71 128.12,31.59 128.12,31.27 128.25,31.14 128.71,31.14 130.49,32.93 135.73,32.93 136.69,33.88 142.3,33.88 143.99,35.58 148.34,35.58 150.31,37.56 152.17,37.56 152.28,37.67 152.28,37.88 152.15,38.01 v1(152.07,38.01)
  BOTTOM w0.14: v1(152.07,38.01) 152.07,37.87 151.5,37.3 JDIMM4.57
DDR_B_D26: length 79.6
  TOP w0.089: v1(99.4,53.92) 98.93,53.45 JCPU1.N2
  TOP w0.14: JDIMM3.68 150.31,40.6 150.58,40.32 152.07,40.32 152.43,40.69 v1(152.43,40.87)
  IN3 w0.089: v1(99.4,53.92) 99.17,53.92 99.05,53.79 99.05,53.53 99.17,53.4 100.65,53.4 101.92,52.13 104.49,52.13
  IN3 w0.127: 104.49,52.13 104.8,52.13 111.76,45.17 111.94,45.17 112.2,45.43 112.38,45.43 112.56,45.25 112.56,45.07 112.3,44.81 112.3,44.63 112.48,44.45 112.66,44.45 112.92,44.71 113.1,44.71 113.28,44.53 113.28,44.35 113.02,44.09 113.02,43.91 117.38,39.55 117.38,35.86 118.07,35.17 119.62,35.17 121.28,33.52 122.3,33.52 122.87,34.08 128.38,34.08 129.93,35.64 135.16,35.64 136.69,37.17 136.9,37.17 136.98,37.25 136.98,37.42 137.11,37.55 137.45,37.55 137.58,37.42 137.58,37.23 137.71,37.11 137.96,37.11 138.09,37.23 138.09,37.42 138.22,37.55 138.59,37.55 138.71,37.42 138.71,37.24 138.84,37.12 139.09,37.12 139.22,37.24 139.22,37.42 139.35,37.55 139.69,37.55 139.82,37.42 139.82,37.26 139.94,37.13 140.2,37.13 140.33,37.26 140.33,37.42 140.45,37.55 143,37.55 143.94,38.48 148.24,38.48 150.17,40.41 152.27,40.41 152.43,40.57 v1(152.43,40.87)
  BOTTOM w0.14: v1(152.43,40.87) 152.43,40.59 152.15,40.3 JDIMM4.67
DDR_B_D27: length 76.9
  TOP w0.089: v3(100.4,53.92) 99.93,53.45 JCPU1.N1
  TOP w0.14: v1(150.91,40.87) 150.91,41.05 150.76,41.2 JDIMM3.70
  IN3 w0.089: 104.49,52.53 101.79,52.53 v3(100.4,53.92)
  IN3 w0.127: 104.49,52.53 104.87,52.53 105.1,52.3 105.36,52.3 105.59,52.53 105.72,52.53 105.95,52.3 105.95,52.14 105.69,51.89 105.69,51.71 105.87,51.53 106.05,51.53 106.31,51.79 106.49,51.79 106.67,51.6 106.67,51.43 106.41,51.17 106.41,50.99 106.59,50.81 106.77,50.81 107.01,51.05 107.19,51.05 107.37,50.87 107.37,50.69 107.13,50.45 107.13,50.27 107.31,50.09 107.49,50.09 107.75,50.35 107.93,50.35 108.11,50.17 108.11,49.99 107.85,49.73 107.85,49.55 108.03,49.37 108.21,49.37 108.46,49.63 108.64,49.63 108.88,49.39 108.88,49.21 108.65,48.98 108.65,48.81 108.83,48.63 109.01,48.63 109.23,48.85 109.41,48.85 109.59,48.67 109.59,48.49 109.37,48.27 109.37,48.09 109.55,47.91 109.73,47.91 109.96,48.14 110.14,48.14 110.32,47.96 110.32,47.78 110.09,47.55 110.09,47.37 110.27,47.19 110.45,47.19 110.67,47.42 110.85,47.42 111.09,47.18 111.09,47 110.83,46.75 110.83,46.57 111.01,46.39 111.19,46.39 111.45,46.64 111.63,46.64 111.81,46.46 111.81,46.28 111.56,46.04 111.56,45.86 111.75,45.68 111.92,45.68 112.17,45.93 112.35,45.93 113.66,44.61 113.66,43.73 117.71,39.68 117.71,36.18 118.39,35.5 119.76,35.5 120.8,34.46 128.28,34.46 129.8,35.97 135.02,35.97 136.93,37.88 142.87,37.88 143.8,38.81 148.1,38.81 150.16,40.87 v1(150.91,40.87)
  BOTTOM w0.14: v1(150.91,40.87) 150.63,41.15 150.35,41.15 150.11,40.9 JDIMM4.69
DDR_B_D28: length 80.3
  TOP w0.089: JCPU1.M4 96.9,52.43 96.4,51.93 v3(96.4,51.92)
  TOP w0.14: JDIMM3.57 155.66,37.3 155.37,37.59 v1(155.37,38.01)
  IN3 w0.089: 104.49,48.36 103.26,49.59 101.68,49.59 100.76,50.52 100.24,50.52 100,50.75 100,50.89 99.57,51.32 98.82,51.32 98.21,51.93 96.41,51.93 96.4,51.93 v3(96.4,51.92)
  IN3 w0.127: 104.49,48.36 114.63,38.23 114.63,34.02 118.17,30.48 128.98,30.48 130.77,32.27 136.18,32.27 137.13,33.22 142.57,33.22 144.18,34.84 148.53,34.84 150.59,36.9 155.6,36.9 155.73,37.02 155.73,37.88 155.6,38.01 v1(155.37,38.01)
  BOTTOM w0.14: v1(155.37,38.01) 155.37,37.83 156.2,37 JDIMM4.56
DDR_B_D29: length 81.2
  TOP w0.089: JCPU1.N5 95.9,53.42 95.42,52.93 v1(95.4,52.93)
  TOP w0.14: v1(150.8,38.01) 150.4,37.6 JDIMM3.58
  IN3 w0.089: 104.49,49.77 103.85,50.41 102,50.41 100.56,51.85 99.04,51.85 98.38,52.51 97.05,52.51 96.92,52.64 96.92,53.33 96.79,53.46 96.36,53.46 95.74,52.85 95.49,52.85 v1(95.4,52.93)
  IN3 w0.127: v1(150.8,38.01) 150.66,38.14 150.43,38.14 149.01,36.72 148.61,36.72 148.5,36.61 148.5,36.21 148.37,36.08 148.04,36.08 147.92,36.21 147.92,36.6 147.79,36.72 147.53,36.72 147.41,36.6 147.41,36.05 147.27,35.91 146.9,35.91 146.77,36.04 146.77,36.23 146.64,36.36 146.43,36.36 146.3,36.23 146.3,36.04 146.18,35.91 145.9,35.91 145.77,36.04 145.77,36.6 145.64,36.72 145.39,36.72 145.26,36.6 145.26,36.04 145.13,35.91 143.86,35.91 142.71,34.76 142.35,34.76 142.29,34.7 142.29,34.34 142.16,34.21 141.9,34.21 141.77,34.34 141.77,34.63 141.64,34.76 141.36,34.76 141.23,34.63 141.23,34.34 141.1,34.21 136.55,34.21 135.59,33.26 130.33,33.26 128.79,31.72 128.46,31.72 127.98,32.19 126.97,32.19 126.25,31.47 125.44,31.47 125.33,31.58 125.33,31.95 125,32.27 123.58,32.27 123.05,31.74 120.38,31.74 119.85,32.27 118.16,32.27 118.03,32.4 118.03,32.72 117.9,32.85 117.69,32.85 117.55,32.7 117.35,32.7 117.06,33 117.06,33.18 117.22,33.34 117.22,33.52 117.04,33.7 116.86,33.7 116.7,33.54 116.52,33.54 115.62,34.43 115.62,38.64 104.49,49.77
  BOTTOM w0.14: v1(150.8,38.01) 150.57,37.77 150.28,37.77 150.15,37.9 JDIMM4.59
DDR_B_D30: length 78.1
  TOP w0.089: JCPU1.M2 98.93,52.45 99.4,52.92 v3(99.4,52.94)
  TOP w0.14: v1(155.48,40.87) 155.48,40.55 155.74,40.3 JDIMM3.67
  IN3 w0.089: 104.49,51.32 104.36,51.46 101.94,51.46 100.88,52.52 99.82,52.52 v3(99.4,52.94)
  IN3 w0.127: 104.49,51.32 116.72,39.09 116.72,35.58 118.4,33.91 119.8,33.91 120.85,32.85 122.57,32.85 123.14,33.42 128.65,33.42 129.6,34.37 135.04,34.37 136.53,35.86 142.25,35.86 144.21,37.82 148.51,37.82 150.44,39.75 150.77,39.75 150.9,39.62 150.9,39.37 151.03,39.24 151.28,39.24 151.41,39.37 151.41,39.62 151.53,39.75 154.38,39.75 154.5,39.88 154.5,40.3 154.63,40.42 154.88,40.42 155.01,40.3 155.01,39.84 155.14,39.71 155.75,39.71 155.88,39.84 155.88,40.74 155.75,40.87 v1(155.48,40.87)
  BOTTOM w0.14: v1(155.48,40.87) 155.48,40.6 155.65,40.44 156.13,40.44 156.3,40.6 JDIMM4.68
DDR_B_D31: length 78.7
  TOP w0.089: JCPU1.M1 99.93,52.45 100.4,52.92 v1(100.4,52.94)
  TOP w0.14: JDIMM3.69 156.3,40.9 155.83,41.38 154.29,41.38 153.96,41.04 v1(153.96,40.87)
  IN3 w0.089: v1(100.4,52.94) 100.4,52.93 100.42,52.92 100.84,52.92 102.02,51.74 104.49,51.74
  IN3 w0.127: v1(153.96,40.87) 153.96,40.37 153.67,40.08 150.31,40.08 148.38,38.15 144.08,38.15 143.14,37.22 142.31,37.22 142.18,37.09 142.18,36.41 142.06,36.28 141.8,36.28 141.67,36.41 141.67,37.09 141.55,37.22 141.22,37.22 141.09,37.09 141.09,36.32 140.96,36.19 136.32,36.19 135.44,35.31 134.27,35.31 134.15,35.18 134.15,34.83 134.02,34.7 133.76,34.7 133.64,34.83 133.64,35.18 133.51,35.31 130.07,35.31 128.51,33.75 123,33.75 122.44,33.19 121.14,33.19 119.49,34.84 117.94,34.84 117.05,35.72 117.05,39.41 104.72,51.74 104.49,51.74
  BOTTOM w0.14: v1(153.96,40.87) 153.96,41.24 154.13,41.4 155.8,41.4 156.01,41.2 JDIMM4.70
DDR_B_D32: length 78.2
  TOP w0.089: v1(96.38,71.91) 96.38,71.97 JCPU1.AM5
  TOP w0.14: v1(152.3,62.77) 152.22,62.69 152.22,62.19 151.63,61.6 JDIMM3.130
  IN3 w0.089: 104.41,74.03 103.33,74.03 101.56,72.26 100.34,72.26 99.6,71.52 96.77,71.52 v1(96.38,71.91)
  IN3 w0.127: 104.41,74.03 104.65,74.03 104.77,73.9 104.77,73.67 104.9,73.55 105.15,73.55 105.28,73.67 105.28,73.9 105.41,74.03 105.66,74.03 105.79,73.9 105.79,73.67 105.92,73.55 106.17,73.55 106.3,73.67 106.3,73.9 106.42,74.03 106.68,74.03 106.8,73.9 106.8,73.67 106.93,73.55 107.19,73.55 107.31,73.67 107.31,73.9 107.44,74.03 107.69,74.03 107.82,73.9 107.82,73.67 107.95,73.55 108.2,73.55 108.33,73.67 108.33,73.9 108.46,74.03 108.71,74.03 108.84,73.9 108.84,73.67 108.96,73.55 109.22,73.55 109.34,73.67 109.34,73.9 109.47,74.03 117.75,74.03 118.03,73.75 118.21,73.75 118.49,74.03 118.67,74.03 118.85,73.85 118.85,73.67 118.57,73.39 118.57,73.21 118.75,73.03 118.93,73.03 119.24,73.34 119.42,73.34 119.6,73.16 119.6,72.98 119.29,72.67 119.29,72.49 119.47,72.31 119.65,72.31 119.79,72.45 119.97,72.45 120.15,72.27 120.15,72.09 120.01,71.95 120.01,71.77 123.39,68.39 136.04,68.39 137.04,67.4 137.37,67.4 137.49,67.53 137.49,67.55 137.62,67.68 137.87,67.68 138,67.55 138,67.53 138.13,67.4 138.38,67.4 138.51,67.53 138.51,67.55 138.64,67.68 138.89,67.68 139.02,67.55 139.02,67.53 139.14,67.4 139.4,67.4 139.52,67.53 139.52,67.55 139.65,67.68 139.91,67.68 140.03,67.55 140.03,67.53 140.16,67.4 142.62,67.4 144.54,65.48 148.12,65.48 148.44,65.16 148.44,64.73 149.7,63.48 150.53,63.48 150.8,63.21 151.17,63.21 151.23,63.27 151.23,63.35 151.36,63.48 151.64,63.48 151.76,63.35 151.76,63.28 151.84,63.21 152.17,63.21 152.3,63.09 v1(152.3,62.77)
  BOTTOM w0.14: JDIMM4.129 151.3,61.3 152.22,62.22 152.22,62.69 v1(152.3,62.77)
DDR_B_D33: length 75.8
  TOP w0.089: JCPU1.AM6 95.35,72 v1(95.35,71.91)
  TOP w0.14: v1(150.77,62.77) 150.77,62.41 150.56,62.2 JDIMM3.132
  IN3 w0.089: v1(95.35,71.91) 95.92,71.34 99.84,71.34 100.32,71.82 101.77,71.82 102.62,72.67
  IN3 w0.127: v1(150.77,62.77) 150.4,63.14 149.56,63.14 148.11,64.59 148.11,65.02 147.98,65.15 147.71,65.15 147.59,65.02 147.59,64.69 147.46,64.56 147.22,64.56 147.09,64.69 147.09,65.02 146.97,65.15 146.71,65.15 146.58,65.02 146.58,64.69 146.46,64.56 146.2,64.56 146.08,64.69 146.08,65.02 145.95,65.15 145.7,65.15 145.57,65.02 145.57,64.77 145.44,64.64 145.08,64.64 144.93,64.8 144.93,65.01 144.79,65.15 144.4,65.15 142.48,67.07 136.9,67.07 135.91,68.06 123.23,68.06 118.07,73.22 117.65,73.22 117.53,73.34 117.53,73.57 117.4,73.7 117.15,73.7 117.02,73.57 117.02,73.31 116.89,73.18 116.64,73.18 116.51,73.31 116.51,73.57 116.38,73.7 116.13,73.7 116,73.57 116,73.28 115.88,73.15 115.62,73.15 115.49,73.28 115.49,73.57 115.37,73.7 115.11,73.7 114.99,73.57 114.99,73.28 114.86,73.15 114.61,73.15 114.48,73.28 114.48,73.57 114.35,73.7 114.1,73.7 113.97,73.57 113.97,73.28 113.84,73.15 113.51,73.15 113.39,73.28 113.39,73.57 113.26,73.7 113.01,73.7 112.88,73.57 112.88,73.28 112.75,73.15 112.5,73.15 112.37,73.28 112.37,73.57 112.24,73.7 111.99,73.7 111.86,73.57 111.86,73.28 111.74,73.15 111.48,73.15 111.35,73.28 111.35,73.57 111.23,73.7 110.97,73.7 110.85,73.57 110.85,73.28 110.72,73.15 110.47,73.15 110.34,73.28 110.34,73.57 110.21,73.7 109.96,73.7 109.83,73.57 109.83,73.34 109.7,73.22 104.6,73.22 104.47,73.34 104.47,73.64 104.34,73.76 104,73.76 103.87,73.64 103.87,72.8 103.74,72.67 102.62,72.67
  BOTTOM w0.14: v1(150.77,62.77) 150.77,62.63 150.05,61.9 JDIMM4.131
DDR_B_D34: length 77.3
  TOP w0.089: v3(98.4,74.92) 97.9,75.42 JCPU1.AR3
  TOP w0.14: JDIMM3.140 151.26,64.6 152.6,65.94 v1(152.6,66.15)
  IN3 w0.089: 104.49,77.4 104.34,77.4 101.46,74.52 98.26,74.52 98.18,74.6 98.18,74.8 98.3,74.92 v3(98.4,74.92)
  IN3 w0.127: v1(152.6,66.15) 152.69,66.15 152.81,66.28 152.81,66.72 152.69,66.84 150.83,66.84 149.14,68.54 148.08,68.54 147.7,68.92 144.81,68.92 142.35,71.38 141.81,71.38 141.74,71.45 141.74,71.98 141.55,72.18 137.25,72.18 136.99,71.92 136.99,71.45 136.92,71.37 136.73,71.37 136.16,70.81 125.53,70.81 119.75,76.59 119.28,76.59 119.15,76.72 119.15,77.19 119.02,77.32 118.74,77.32 118.62,77.19 118.62,76.72 118.49,76.59 118.2,76.59 118.07,76.72 118.07,77.27 117.94,77.4 117.64,77.4 117.51,77.27 117.51,76.72 117.38,76.59 117.13,76.59 117,76.72 117,77.27 116.88,77.4 116.62,77.4 116.5,77.27 116.5,76.72 116.37,76.59 116.11,76.59 115.99,76.72 115.99,77.27 115.86,77.4 115.25,77.4 115.13,77.27 115.13,77.18 115,77.05 114.75,77.05 114.62,77.18 114.62,77.27 114.49,77.4 114.14,77.4 114.02,77.29 114.02,77.19 113.89,77.06 113.64,77.06 113.51,77.19 113.51,77.29 113.4,77.4 104.49,77.4
  BOTTOM w0.14: JDIMM4.141 151.59,64.9 152.6,65.92 v1(152.6,66.15)
DDR_B_D35: length 77.1
  TOP w0.089: JCPU1.AP3 97.9,74.42 98.4,73.92 v1(98.4,73.93)
  TOP w0.14: v1(151.33,66.15) 150.38,65.2 JDIMM3.142
  IN3 w0.089: 104.49,76.3 104.46,76.26 103.46,76.26 101.54,74.34 98.53,74.34 98.4,74.21 v1(98.4,73.93)
  IN3 w0.127: 104.49,76.3 104.59,76.39 104.59,76.94 104.71,77.07 104.97,77.07 105.1,76.94 105.1,76.39 105.22,76.26 105.48,76.26 105.6,76.39 105.6,76.94 105.73,77.07 105.98,77.07 106.11,76.94 106.11,76.39 106.24,76.26 106.49,76.26 106.62,76.39 106.62,76.94 106.75,77.07 107,77.07 107.13,76.94 107.13,76.39 107.25,76.26 107.51,76.26 107.64,76.39 107.64,76.94 107.76,77.07 108.02,77.07 108.14,76.94 108.14,76.39 108.27,76.26 108.52,76.26 108.65,76.39 108.65,76.94 108.78,77.07 109.03,77.07 109.16,76.94 109.16,76.39 109.29,76.26 109.54,76.26 109.67,76.39 109.67,76.94 109.79,77.07 110.05,77.07 110.18,76.94 110.18,76.39 110.3,76.26 110.56,76.26 110.68,76.39 110.68,76.94 110.81,77.07 111.06,77.07 111.19,76.94 111.19,76.39 111.32,76.26 111.58,76.26 111.71,76.39 111.71,76.94 111.83,77.07 112.09,77.07 112.22,76.94 112.22,76.39 112.34,76.26 112.6,76.26 112.72,76.39 112.72,76.94 112.85,77.07 113.17,77.07 113.3,76.94 113.3,76.39 113.42,76.26 113.73,76.26 113.85,76.39 113.85,76.59 113.98,76.72 115.54,76.72 115.69,76.57 115.69,76.37 115.79,76.26 119.47,76.26 125.25,70.48 136.3,70.48 136.84,71.02 142.19,71.02 144.62,68.59 147.56,68.59 147.94,68.21 149,68.21 151.05,66.15 v1(151.33,66.15)
  BOTTOM w0.14: JDIMM4.143 150.68,65.5 v1(151.33,66.15)
DDR_B_D36: length 78.2
  TOP w0.089: v3(98.42,72.9) 98.42,72.9 97.9,73.42 JCPU1.AN3
  TOP w0.14: JDIMM3.129 156.2,61.3 155.43,62.07 155.43,62.68 v1(155.35,62.77)
  IN3 w0.089: 104.49,74.69 103.45,74.69 101.7,72.94 100.08,72.94 99.71,73.3 99.2,73.3 98.8,72.9 v3(98.42,72.9)
  IN3 w0.127: v1(155.35,62.77) 155.24,62.87 155.24,63.17 155.37,63.3 155.56,63.3 155.69,63.17 155.69,63.14 155.81,63.02 156.14,63.02 156.27,63.14 156.27,63.78 156.4,63.91 156.73,63.91 156.86,63.78 156.86,63.39 156.98,63.26 157.35,63.26 157.48,63.39 157.48,64.53 157.35,64.66 155.34,64.66 155.22,64.53 155.22,64 155.09,63.87 152.24,63.87 151.81,64.3 150.88,64.3 148.41,66.78 147.35,66.78 146.97,67.16 144.03,67.16 142.72,68.46 142.56,68.63 142.23,68.63 142.13,68.73 142.13,68.92 142,69.05 141.72,69.05 141.59,68.92 141.59,68.44 141.49,68.34 137.03,68.34 136.74,68.63 136.74,68.92 136.61,69.05 124.64,69.05 119,74.69 104.49,74.69
  BOTTOM w0.14: v1(155.35,62.77) 155.35,62.18 155.92,61.6 JDIMM4.130
DDR_B_D37: length 80
  TOP w0.089: JCPU1.AN2 98.9,73.42 99.4,72.92 v1(99.4,72.9)
  TOP w0.14: JDIMM3.131 156.22,61.9 155.93,62.19 155.93,62.83 155.42,63.34 154.39,63.34 v1(153.82,62.77)
  IN3 w0.089: v1(99.4,72.9) 99.4,72.57 99.52,72.45 100.13,72.45 100.43,72.76 101.77,72.76 103.37,74.36 104.49,74.36
  IN3 w0.127: v1(153.82,62.77) 153.82,62.93 154,63.11 154,63.42 153.87,63.54 153.41,63.54 153.26,63.39 153.26,63.32 153.16,63.22 152.79,63.22 152.69,63.32 152.69,63.39 152.54,63.54 152.1,63.54 151.84,63.81 150.89,63.81 150.51,64.19 150.37,64.19 149.99,63.81 149.83,63.81 149.6,64.04 149.6,64.22 149.96,64.58 149.96,64.76 149.78,64.94 149.6,64.94 149.24,64.58 149.06,64.58 148.77,64.87 148.77,64.96 149.19,65.38 149.19,65.53 148.91,65.81 148.6,65.81 148.47,65.94 148.47,66.24 148.35,66.37 148.08,66.37 147.95,66.24 147.95,65.94 147.83,65.81 147.19,65.81 147.07,65.94 147.07,66.06 146.94,66.19 146.69,66.19 146.56,66.06 146.56,65.94 146.43,65.81 146.18,65.81 146.05,65.94 146.05,66.12 145.92,66.24 145.67,66.24 145.54,66.12 145.54,65.94 145.42,65.81 144.97,65.81 144.85,65.94 144.85,66.03 144.72,66.15 144.46,66.15 143.99,66.62 143.99,66.73 142.42,68.3 142.24,68.3 142.11,68.17 142.11,67.86 141.98,67.73 141.73,67.73 141.6,67.86 141.6,67.88 141.48,68.01 141.22,68.01 141.09,67.88 141.09,67.86 140.97,67.73 140.71,67.73 140.59,67.86 140.59,67.88 140.46,68.01 136.89,68.01 136.18,68.72 123.54,68.72 122.76,69.51 122.76,69.67 123.07,69.98 123.07,70.15 122.94,70.28 122.77,70.28 122.46,69.97 122.28,69.97 122.11,70.14 122.11,70.32 122.42,70.62 122.42,70.8 122.27,70.95 122.09,70.95 121.76,70.63 121.64,70.63 120.48,71.78 120.48,71.87 120.83,72.21 120.83,72.39 120.55,72.67 120.43,72.67 120.36,72.59 120.29,72.59 120.18,72.71 120.17,72.71 120,72.88 120,72.97 120.08,73.05 120.08,73.14 118.86,74.36 104.49,74.36
  BOTTOM w0.14: v1(153.82,62.77) 154.35,63.3 155.74,63.3 156.01,63.03 156.01,62.5 156.3,62.2 JDIMM4.132
DDR_B_D38: length 78.6
  TOP w0.089: v3(100.4,73.93) 100.4,73.92 99.93,73.45 JCPU1.AN1
  TOP w0.14: JDIMM3.141 156.4,64.9 v1(155.14,66.15)
  IN3 w0.089: v3(100.4,73.93) 100.41,73.92 101.37,73.92 103.38,75.93 104.49,75.93
  IN3 w0.127: 104.49,75.93 114.32,75.93 114.73,76.34 115.21,76.34 115.27,76.28 115.28,76.28 115.62,75.93 119.33,75.93 125.11,70.15 136.44,70.15 136.98,70.69 140.03,70.69 140.17,70.55 140.17,70.28 140.3,70.15 140.55,70.15 140.68,70.28 140.68,70.55 140.82,70.69 141.11,70.69 141.24,70.57 141.24,70.28 141.36,70.15 141.59,70.15 141.72,70.28 141.72,70.57 141.84,70.69 142.05,70.69 142.27,70.47 142.27,70.27 142.38,70.17 142.58,70.17 144.49,68.26 147.42,68.26 147.8,67.88 148.86,67.88 151.16,65.58 153.8,65.58 153.92,65.45 153.92,65.14 154.05,65.01 154.44,65.01 154.57,65.14 154.57,65.62 154.7,65.75 154.95,65.75 155.08,65.62 155.08,65.14 155.21,65.01 155.63,65.01 155.76,65.14 155.76,65.47 155.89,65.6 156.14,65.6 156.27,65.47 156.27,65.14 156.39,65.01 156.72,65.01 156.84,65.14 156.84,65.47 156.97,65.6 157.24,65.6 157.36,65.47 157.36,65.14 157.49,65.01 157.78,65.01 157.91,65.14 157.91,66.03 157.78,66.15 v1(155.14,66.15)
  BOTTOM w0.14: JDIMM4.140 156.28,64.6 155.14,65.73 v1(155.14,66.15)
DDR_B_D39: length 78.5
  TOP w0.089: JCPU1.AP2 98.93,74.45 v1(99.4,74.92)
  TOP w0.14: v1(153.87,66.15) 153.87,66.25 154.42,66.79 155.27,66.79 155.95,66.1 155.95,65.89 156.34,65.5 JDIMM3.143
  IN3 w0.089: v1(99.4,74.92) 99.99,75.5 101.95,75.5 104.18,77.73 104.49,77.73
  IN3 w0.127: v1(153.87,66.15) 153.79,66.15 153.66,66.28 153.66,66.5 153.76,66.6 157,66.6 157.12,66.72 157.12,67.04 157,67.17 150.97,67.17 149.27,68.87 148.21,68.87 147.83,69.25 144.95,69.25 141.69,72.51 137.12,72.51 136.64,72.03 136.64,71.75 136.03,71.14 125.67,71.14 119.08,77.73 104.49,77.73
  BOTTOM w0.14: v1(153.87,66.15) 153.87,66.16 154.39,66.68 155.33,66.68 155.94,66.07 155.94,65.77 156.51,65.2 JDIMM4.142
DDR_B_D40: length 79.5
  TOP w0.089: JCPU1.AP5 95.93,74.45 v3(96.4,74.92)
  TOP w0.14: JDIMM3.147 156.17,66.7 155.26,67.62 v1(154.97,67.62)
  IN3 w0.089: v3(96.4,74.92) 96.95,75.47 96.95,76.04 97.24,76.32 98.48,76.32 98.68,76.52 100.71,76.52 102.06,77.87
  IN3 w0.127: 102.06,77.87 103.34,79.15 119.67,79.15 124.21,74.61 125.2,74.61 125.29,74.52 125.29,73.53 125.42,73.4 125.67,73.4 125.8,73.53 125.8,74.52 125.92,74.65 126.18,74.65 126.31,74.52 126.31,72.69 126.43,72.56 126.69,72.56 126.81,72.69 126.81,74.52 126.94,74.65 127.19,74.65 127.32,74.52 127.32,73.95 127.45,73.83 127.7,73.83 127.83,73.95 127.83,74.36 127.96,74.49 128.24,74.49 128.37,74.36 128.37,74.28 128.48,74.17 132.76,74.17 132.9,74.04 133.33,74.04 133.46,74.17 135.93,74.17 136.52,74.77 141.85,74.77 144.4,72.21 146.94,72.21 148.86,70.29 149.88,70.29 151.37,68.8 152.89,68.8 153.26,68.43 154.15,68.43 v1(154.97,67.62)
  BOTTOM w0.14: JDIMM4.146 156.33,66.4 155.12,67.62 v1(154.97,67.62)
DDR_B_D41: length 84.2
  TOP w0.089: v1(91.4,72.91) 91.46,72.91 91.9,73.36 JCPU1.AN9
  TOP w0.14: JDIMM3.149 156.13,67.3 155.27,68.16 153.86,68.16 153.7,68 v1(153.7,67.62)
  IN3 w0.089: 102.54,77.88 101,76.34 98.76,76.34 97.73,75.32 97.09,75.32 96.86,75.09 96.86,74.77 96.41,74.32 95.24,74.32 94.8,73.89 94.8,73.67 94.63,73.5 93.17,73.5 93.02,73.34 91.83,73.34 v1(91.4,72.91)
  IN3 w0.127: v1(153.7,67.62) 153.24,68.07 152.9,68.07 152.53,68.43 151.27,68.43 149.74,69.96 148.69,69.96 146.89,71.77 144.33,71.77 141.66,74.44 136.66,74.44 136.06,73.84 133.6,73.84 133.47,73.7 132.76,73.7 132.63,73.84 128.55,73.84 128.42,73.71 128.42,72.36 128.29,72.23 128.04,72.23 127.91,72.36 127.91,73.28 127.79,73.41 127.53,73.41 127.4,73.28 127.4,72.36 127.28,72.23 126.12,72.23 119.53,78.82 103.48,78.82 102.54,77.88
  BOTTOM w0.14: JDIMM4.148 156.32,67 155.05,68.26 154.14,68.26 153.7,67.82 v1(153.7,67.62)
DDR_B_D42: length 77.7
  TOP w0.089: JCPU1.AT5 95.93,76.45 v1(96.4,76.92)
  TOP w0.14: v1(151.1,70.66) 150.44,70 JDIMM3.158
  IN3 w0.089: 97.06,77.57 v1(96.4,76.92)
  IN3 w0.127: 97.06,77.57 100.16,77.57 102.84,80.25 120.12,80.25 124.63,75.75 125.56,75.75 125.69,75.87 125.69,76.48 125.82,76.61 126.05,76.61 126.17,76.48 126.17,75.87 126.3,75.75 126.73,75.75 126.86,75.87 126.86,76.84 126.99,76.96 127.35,76.96 127.48,76.84 127.48,75.87 127.61,75.75 128.33,75.75 128.46,75.87 128.46,76.84 128.59,76.96 128.84,76.96 128.97,76.84 128.97,75.87 129.1,75.75 129.4,75.75 129.53,75.87 129.53,76.84 129.66,76.96 129.91,76.96 130.04,76.84 130.04,75.87 130.16,75.75 130.42,75.75 130.55,75.87 130.55,76.84 130.67,76.96 130.93,76.96 131.05,76.84 131.05,75.87 131.18,75.75 131.45,75.75 131.58,75.87 131.58,76.84 131.7,76.96 136.57,76.96 137.14,77.53 141.24,77.53 142.95,75.82 142.95,75.59 144.06,74.48 146.3,74.48 149.38,71.39 150.39,71.39 151.1,70.68 v1(151.1,70.66)
  BOTTOM w0.14: JDIMM4.157 150.28,69.7 151.1,70.52 v1(151.1,70.66)
DDR_B_D43: length 78.2
  TOP w0.089: v3(95.35,76.95) 95.35,76.87 94.93,76.45 JCPU1.AT6
  TOP w0.14: v1(152.62,70.66) 152.13,71.16 150.62,71.16 150.06,70.6 JDIMM3.160
  IN3 w0.089: 100.67,78.55 99.91,77.79 96.72,77.79 96.35,77.42 95.82,77.42 v3(95.35,76.95)
  IN3 w0.127: v1(152.62,70.66) 151.57,71.72 149.57,71.72 146.45,74.84 144.21,74.84 143.32,75.74 143.32,75.92 141.37,77.86 136.69,77.86 136.56,77.74 136.56,77.42 136.44,77.29 136.14,77.29 136.02,77.42 136.02,77.76 135.89,77.88 135.63,77.88 135.51,77.76 135.51,77.42 135.38,77.29 135.13,77.29 135,77.42 135,77.76 134.87,77.88 134.62,77.88 134.49,77.76 134.49,77.42 134.36,77.29 132.68,77.29 132.55,77.42 132.55,77.66 132.42,77.79 132.17,77.79 132.04,77.66 132.04,77.42 131.91,77.29 126.73,77.29 126.6,77.17 126.6,77.06 126.48,76.94 126.22,76.94 126.1,77.06 126.1,77.27 125.97,77.4 125.64,77.4 125.51,77.27 125.51,76.78 125.39,76.66 125.13,76.66 125,76.78 125,77.63 124.88,77.76 124.59,77.76 124.46,77.63 124.46,76.89 124.33,76.77 124.08,76.77 123.95,76.89 123.95,77.17 123.82,77.29 123.55,77.29 120.26,80.58 102.71,80.58 100.67,78.55
  BOTTOM w0.14: v1(152.62,70.66) 152.12,71.17 150.85,71.17 149.98,70.3 JDIMM4.159
DDR_B_D44: length 80.2
  TOP w0.089: JCPU1.AP6 95.4,73.95 v3(95.4,73.92)
  TOP w0.14: v1(152.43,67.62) 152.43,67.36 152.08,67.02 151.43,67.02 150.82,66.4 JDIMM3.146
  IN3 w0.089: 103.01,77.88 101.23,76.11 98.77,76.11 97.82,75.16 97.82,74.78 97.57,74.52 96.92,74.52 96.32,73.92 v3(95.4,73.92)
  IN3 w0.127: 103.01,77.88 103.62,78.49 119.39,78.49 125.98,71.9 128.86,71.9 128.99,72.03 128.99,73.25 129.11,73.37 129.37,73.37 129.49,73.25 129.49,72.85 129.62,72.72 129.87,72.72 130,72.85 130,73.25 130.13,73.37 130.38,73.37 130.51,73.25 130.51,72.85 130.64,72.72 130.89,72.72 131.02,72.85 131.02,73.25 131.14,73.37 131.4,73.37 131.53,73.25 131.53,72.85 131.65,72.72 131.91,72.72 132.03,72.85 132.03,73.25 132.16,73.37 133.56,73.37 133.58,73.39 141.88,73.39 144.58,70.69 145.01,70.69 145.13,70.56 145.13,70.14 145.26,70.01 145.56,70.01 145.68,70.14 145.68,70.66 145.81,70.78 146.06,70.78 146.19,70.66 146.19,70.14 146.32,70.01 146.57,70.01 146.7,70.14 146.7,70.66 146.83,70.78 147.08,70.78 147.21,70.66 147.21,70.14 147.33,70.01 148.15,70.01 148.53,69.63 149.6,69.63 151.17,68.07 151.97,68.07 v1(152.43,67.62)
  BOTTOM w0.14: JDIMM4.147 152.09,66.7 152.43,67.03 v1(152.43,67.62)
DDR_B_D45: length 81.9
  TOP w0.089: JCPU1.AN8 92.9,73.43 v5(93.41,72.91)
  TOP w0.14: v1(151.16,67.62) 150.54,67 JDIMM3.148
  IN3 w0.089: v5(93.41,72.91) 93.82,73.32 95.97,73.32 96.98,74.33 97.66,74.33 98,74.67 98,75.08 98.85,75.93 101.67,75.93 103.62,77.88
  IN3 w0.127: v1(151.16,67.62) 151.15,67.62 149.47,69.3 148.39,69.3 148.01,69.68 145.12,69.68 141.79,73.02 136.13,73.02 135.97,72.85 135.97,71.7 135.84,71.57 135.58,71.57 135.46,71.7 135.46,72.9 135.33,73.03 135.08,73.03 134.95,72.9 134.95,71.66 134.86,71.57 134.52,71.57 134.42,71.67 134.42,72.9 134.3,73.03 134.04,73.03 133.91,72.9 133.91,71.69 133.83,71.6 133.39,71.6 133.29,71.7 133.29,72.16 133.16,72.28 132.91,72.28 132.78,72.16 132.78,71.7 132.66,71.57 132.28,71.57 132.15,71.7 132.15,72.26 132.02,72.39 131.77,72.39 131.64,72.26 131.64,71.7 131.51,71.57 131.26,71.57 131.13,71.7 131.13,72.12 131.01,72.25 130.75,72.25 130.62,72.12 130.62,71.7 130.5,71.57 130.24,71.57 130.12,71.7 130.12,72.26 129.99,72.39 129.74,72.39 129.61,72.26 129.61,71.75 129.43,71.57 125.85,71.57 123.23,74.19 119.26,78.16 103.9,78.16 103.62,77.88
  BOTTOM w0.14: v1(151.16,67.62) 151.16,67.45 150.86,67.16 150.51,67.16 150.36,67.3 JDIMM4.149
DDR_B_D46: length 78.6
  TOP w0.089: JCPU1.AR6 94.9,75.42 94.48,74.99 v3(94.38,74.99)
  TOP w0.14: v1(154.15,70.66) 155.11,69.7 JDIMM3.157
  IN3 w0.089: v3(94.38,74.99) 94.64,75.25 94.94,75.25 95.15,75.45 95.5,75.45 95.8,75.75 95.8,76.09 95.57,76.33 95.3,76.33 94.92,76.71 94.92,77.12 95.78,77.98 99.64,77.98 100.21,78.55
  IN3 w0.127: 100.21,78.55 102.58,80.93 120.39,80.93 122.76,78.55 130.88,78.55 131.01,78.42 131.01,77.84 131.14,77.71 131.39,77.71 131.52,77.84 131.52,78.42 131.65,78.55 131.9,78.55 132.03,78.42 132.03,78.25 132.15,78.12 132.41,78.12 132.53,78.25 132.53,78.42 132.66,78.55 133.18,78.55 133.51,78.21 141.49,78.21 143.69,76.02 143.69,75.89 144.37,75.21 146.6,75.21 149.76,72.05 152.63,72.05 154.01,70.66 v1(154.15,70.66)
  BOTTOM w0.14: JDIMM4.158 156.27,70 156.03,69.76 155.05,69.76 v1(154.15,70.66)
DDR_B_D47: length 78.4
  TOP w0.089: JCPU1.AR5 95.87,75.45 v1(95.4,75.92)
  TOP w0.14: JDIMM3.159 155.76,70.3 155.67,70.39 v1(155.67,70.66)
  IN3 w0.089: 99.74,78.55 96.1,78.55 94.67,77.12 94.67,76.65 v1(95.4,75.92)
  IN3 w0.127: v1(155.67,70.66) 155.67,70.9 155.8,71.03 156.84,71.03 156.97,71.16 156.97,71.59 156.84,71.72 155.3,71.72 155.17,71.84 155.17,72.25 155.05,72.38 154.63,72.38 154.48,72.23 154.48,71.44 154.36,71.31 154.1,71.31 153.97,71.44 153.97,72.23 153.82,72.38 149.95,72.38 146.75,75.58 144.52,75.58 144.05,76.05 144.05,76.12 141.63,78.54 133.65,78.54 133.32,78.88 122.9,78.88 120.51,81.27 102.46,81.27 99.74,78.55
  BOTTOM w0.14: JDIMM4.160 156.32,70.6 156.02,70.3 155.81,70.3 155.67,70.44 v1(155.67,70.66)
DDR_B_D48: length 88.2
  TOP w0.089: JCPU1.AR9 91.9,75.42 v3(92.4,74.92)
  TOP w0.14: v1(151.28,72.83) 151.28,72.49 150.59,71.8 JDIMM3.164
  IN3 w0.089: 95.71,78.55 94.49,77.33 94.49,76.58 94.8,76.27 94.8,75.75 94.48,75.43 94.25,75.43 93.88,75.05 93.88,74.83 93.57,74.52 93.08,74.52 92.68,74.92 v3(92.4,74.92)
  IN3 w0.127: v1(151.28,72.83) 150.14,72.83 149.93,73.03 146.26,76.71 144.63,76.71 141.89,79.45 132.77,79.45 132.65,79.58 132.65,79.73 132.52,79.86 132.26,79.86 132.13,79.73 132.13,79.58 132,79.45 131.72,79.45 131.59,79.58 131.59,80.1 131.47,80.23 131.21,80.23 131.09,80.1 131.09,79.44 130.96,79.31 130.7,79.31 130.58,79.44 130.58,80.1 130.45,80.23 130.2,80.23 130.07,80.1 130.07,79.44 129.94,79.31 129.69,79.31 129.56,79.44 129.56,80.1 129.43,80.23 129.18,80.23 129.05,80.1 129.05,79.44 128.93,79.31 128.67,79.31 128.55,79.44 128.55,80.1 128.42,80.23 128.16,80.23 128.04,80.1 128.04,79.44 127.91,79.31 126.02,79.31 125.89,79.44 125.89,80.1 125.77,80.23 125.51,80.23 125.39,80.1 125.39,79.44 125.26,79.31 125,79.31 124.88,79.44 124.88,80.55 124.75,80.67 124.5,80.67 124.37,80.55 124.37,79.44 124.24,79.31 123.93,79.31 123.8,79.44 123.8,80.75 123.67,80.87 123.38,80.87 123.25,80.75 123.25,79.68 123.12,79.56 122.83,79.56 122.71,79.68 122.71,79.85 122.58,79.98 122.41,79.98 122.29,80.1 122.29,80.32 122.41,80.44 122.61,80.44 122.73,80.57 122.73,80.89 122.62,81 121.39,81 120.69,81.7 102.28,81.7 99.68,79.1 96.26,79.1 95.71,78.55
  BOTTOM w0.14: v1(151.28,72.83) 151.28,72.32 150.47,71.5 JDIMM4.163
DDR_B_D49: length 96.2
  TOP w0.089: JCPU1.AJ11 89.9,69.42 v1(90.4,68.92)
  TOP w0.14: v1(152.81,72.83) 152.36,73.28 151.1,73.28 150.22,72.4 JDIMM3.166
  IN3 w0.089: v1(90.4,68.92) 91.81,70.33 91.81,72.07 91.45,72.43 91.32,72.43 91,72.75 91,74.08 91.24,74.32 91.62,74.32 92,74.7 92,75.08 92.24,75.32 93.62,75.32 94,75.7 94,76.17 94.29,76.45 94.29,77.6 95.24,78.55
  IN3 w0.127: v1(152.81,72.83) 153.02,72.83 153.14,72.95 153.14,73.15 153.02,73.28 150.21,73.28 146.45,77.04 144.95,77.04 142.17,79.82 133.1,79.82 132.36,80.56 125.33,80.56 124.53,81.36 123.97,81.36 123.85,81.48 123.85,81.99 123.72,82.12 123.47,82.12 123.34,81.99 123.34,81.43 123.21,81.31 122.96,81.31 122.83,81.43 122.83,82.43 122.7,82.55 122.45,82.55 122.32,82.43 122.32,81.48 122.2,81.36 121.87,81.36 121.74,81.48 121.74,82.43 121.61,82.55 121.27,82.55 121.14,82.43 121.14,82.16 121.02,82.03 120.66,82.03 120.53,82.16 120.53,82.43 120.4,82.55 120.15,82.55 120.02,82.43 120.02,82.16 119.9,82.03 119.64,82.03 119.52,82.16 119.52,82.43 119.39,82.55 119.13,82.55 119.01,82.43 119.01,82.16 118.88,82.03 118.63,82.03 118.5,82.16 118.5,82.43 118.37,82.55 118.12,82.55 117.99,82.43 117.99,82.16 117.86,82.03 117.61,82.03 117.48,82.16 117.48,82.43 117.36,82.55 117.1,82.55 116.98,82.43 116.98,82.16 116.85,82.03 116.59,82.03 116.47,82.16 116.47,82.43 116.34,82.55 116.09,82.55 115.96,82.43 115.96,82.16 115.83,82.03 115.5,82.03 115.38,82.16 115.38,82.43 115.25,82.55 114.99,82.55 114.87,82.43 114.87,82.16 114.74,82.03 114.49,82.03 114.36,82.16 114.36,82.43 114.23,82.55 113.98,82.55 113.85,82.43 113.85,82.16 113.72,82.03 102.14,82.03 99.54,79.43 96.12,79.43 95.24,78.55
  BOTTOM w0.14: JDIMM4.165 149.92,72.1 151.1,73.28 152.24,73.28 152.69,72.83 v1(152.81,72.83)
