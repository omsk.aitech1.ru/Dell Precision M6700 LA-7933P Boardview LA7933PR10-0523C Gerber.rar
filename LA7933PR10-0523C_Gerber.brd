# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_DBRESET#_R: length 10
  TOP w0.102: JCPU1.AL35 65.49,71.45 62.84,74.11 62.84,74.98 v2(60.48,77.34) 60.48,77.35 59.5,78.33 RC28.1
XDP_FN0: length 5.7
  TOP w0.102: JXDP2.9 74.57,111.01 RH51.2 75.16,111.67 74.67,112.15 74.67,112.92 74.09,113.5 v2(73.95,113.5)
XDP_FN1: length 7
  TOP w0.102: JXDP2.11 74.06,110.92 74.14,111 RH7.2 74.14,111.67 73.57,112.24 73.57,112.9 73.3,113.17 72.97,113.17 72.58,113.56 v2(72.58,114.69)
XDP_FN2: length 3.3
  TOP w0.102: RH16.2 73.39,111.34 v2(73.39,110.66) 73.39,110.15 73.06,109.82 JXDP2.15
XDP_FN3: length 3.2
  TOP w0.102: RH5.2 72.11,111.6 v2(72.11,110.6) 72.11,110.23 72.57,109.77 JXDP2.17
XDP_FN4: length 3.2
  TOP w0.102: RH6.2 70.06,111.08 v2(70.06,110.41) JXDP2.27
XDP_FN5: length 7
  TOP w0.102: v2(69.7,115.14) 70.14,114.69 70.14,112.21 69.57,111.63 RH14.2 69.57,111.6 JXDP2.29
XDP_FN6: length 3
  TOP w0.102: RH8.2 68.57,111.59 v2(68.57,110.41) JXDP2.33
XDP_FN7: length 5.5
  TOP w0.102: JXDP2.35 68.06,109.8 68.15,109.89 68.15,110.71 67.54,111.33 RH9.2 67.54,111.74 67.99,112.19 v2(67.99,113.56)
XDP_FN8: length 5.5
  TOP w0.102: v2(74.29,97.92) 74.29,98.27 74.62,98.6 74.62,99.57 74.14,100.05 RH10.2 74.14,101 74.57,101.43 JXDP2.10
XDP_FN9: length 3.1
  TOP w0.102: JXDP2.12 74.06,101.61 v2(73.53,101.07) 73.13,100.67 RH12.2
XDP_FN10: length 5.3
  TOP w0.102: v2(71.64,98.15) 71.64,99.66 72.09,100.11 RH13.2 72.11,100.41 73.06,101.36 JXDP2.16
XDP_FN11: length 3.5
  TOP w0.102: RH26.2 71.28,100.11 v2(72.24,101.07) 72.57,101.4 JXDP2.18
XDP_FN12: length 2.8
  TOP w0.102: RH20.2 70.06,100.12 v2(70.06,101.09) JXDP2.28
XDP_FN13: length 5.1
  TOP w0.102: v2(68.55,98.2) 68.55,99.59 69.06,100.1 RH34.2 69.06,101.4 69.57,101.9 JXDP2.30
XDP_FN14: length 3
  TOP w0.102: RH17.2 68.57,100.63 v2(68.57,101.07) JXDP2.34
XDP_FN15: length 3.3
  TOP w0.102: JXDP2.36 68.06,101.61 67.53,101.07 v2(67.27,101.07) 67.03,100.83 RH18.2
XDP_FN16: length 3
  TOP w0.102: RH19.2 76.44,100.37 v2(76.44,101.09) 76.44,101.35 76.06,101.72 JXDP2.4
XDP_FN17: length 2.9
  TOP w0.102: RH53.2 v2(75.16,101.07) 75.16,101.4 75.56,101.81 JXDP2.6
XDP_HOOK2: length 4.2
  BOTTOM w0.102: v2(73.65,88.01) 74.04,88.41 74.04,89.62 73.72,89.95 RC10.2 74.15,90.59 JXDP1.12
XDP_OBS0_R: length 5.6
  TOP w0.089: 73.7,78.55 73,77.85 73,76.55 JCPU1.AT28
  TOP w0.102: T73.1 73.76,81.34 73.76,78.61 73.7,78.55
XDP_OBS1_R: length 7.6
  TOP w0.102: T74.1 71.18,82.45 71.18,80.37 71.47,80.07 71.47,75.81 71.83,75.45 JCPU1.AR29
XDP_OBS2_R: length 8.5
  TOP w0.102: JCPU1.AR30 70.45,75.9 70.45,77.79 69.19,79.05 69.19,82.36 T75.1
XDP_OBS3_R: length 5.3
  TOP w0.102: JCPU1.AT30 70.89,76.46 70.89,79.82 70.46,80.25 T76.1
XDP_OBS4_R: length 1.6
  TOP w0.089: v1(68.33,74.95) 68.82,74.45 JCPU1.AP32
  BOTTOM w0.102: T77.1 68.43,75.04 v1(68.33,74.95)
XDP_OBS5_R: length 1.4
  TOP w0.089: v1(69.37,75.93) 69.85,75.45 JCPU1.AR31
  BOTTOM w0.089: T78.1 69.82,76.39 v1(69.37,75.93)
XDP_OBS6_R: length 5.6
  TOP w0.102: JCPU1.AT31 69.9,77.79 68.88,78.8 68.88,81.52 T79.1
XDP_OBS7_R: length 7.4
  TOP w0.102: JCPU1.AR32 68.83,75.45 68.53,75.75 68.53,80.52 67.41,81.64 T80.1
XDP_PRDY#: length 24.7
  TOP w0.102: JCPU1.AP29 71.9,74.56 71.27,75.19 71.27,77.99 71.2,78.06 71.2,79.92 70.8,80.32 70.8,81.78 70.59,81.99 70.22,81.99 69.98,82.23 69.98,82.83 70.27,83.12 72.29,83.12 72.59,83.41 72.74,83.41 72.9,83.57 72.9,84.02 73.04,84.16 73.04,85.09 72.22,85.9 v2(71.84,85.9) 71.49,85.9 69.61,87.78 69.61,90.81 69.16,91.25 69.16,92.28 v1(69.02,92.43)
  BOTTOM w0.102: JXDP1.2 69.15,92.16 69.02,92.3 v1(69.02,92.43)
XDP_PREQ#: length 26.6
  TOP w0.089: JCPU1.AP27 73.9,74.51 73.35,75.06 72.76,75.06 72.27,75.54 72.27,76.67 72.64,77.04 72.64,78.13 72.22,78.55
  TOP w0.102: v1(68.76,93.08) 68.99,93.08 69.52,92.55 v2(69.52,91.69) 69.52,91.34 69.9,90.96 69.9,87.95 71.6,86.25 72.2,86.25 73.26,85.18 73.26,84.07 73.13,83.93 73.13,83.44 72.87,83.19 72.68,83.19 71.88,82.39 71.88,78.89 72.22,78.55
  BOTTOM w0.102: RC42.1 68.65,90.75 JXDP1.1 68.65,91.82 68.49,91.99 68.49,92.79 68.76,93.05 v1(68.76,93.08)
XDP_RST#_R: length 4.7
  BOTTOM w0.102: JXDP1.17 76.65,90.81 76.99,90.48 v2(76.99,89.05) 76.99,88.58 76.68,88.28 76.47,88.28 75.86,87.67 RC21.2
XDP_TCLK: length 20
  TOP w0.089: JCPU1.AR26 74.84,75.45 v5(74.4,75.89)
  BOTTOM w0.102: JXDP1.26 81.15,90.99 80.1,89.93 80.1,87.83 79.72,87.45 79.72,85.93 v4(79.14,85.36) 77.67,83.88 77,83.88 76.01,82.89 76.01,81.53 75.66,81.19 75.61,81.19 74.94,80.52 74.94,79.87 75.36,79.45 RC44.1
  BOTTOM w0.127: RC44.1 75.53,78.07 74.84,77.38 74.84,76.33 74.41,75.89 v5(74.4,75.89)
XDP_TDI: length 22.2
  TOP w0.102: RC33.2 73.55,82.71 74.18,83.34 74.18,84.21 73.71,84.68 73.71,85.04 71.69,87.06 71.69,87.08 71.07,87.71 v2(71.07,89.55) 71.07,89.97 71.69,90.59 71.69,93.26 v1(71.88,93.45)
  BOTTOM w0.102: v1(71.88,93.45) 71.97,93.54 78.46,93.54 79.13,92.86 79.13,91.45 JXDP1.22
XDP_TDI_R: length 8.7
  TOP w0.089: JCPU1.AR28 72.84,75.45 72.45,75.83 72.45,76.59 72.82,76.96 72.82,78.18 72.88,78.25 72.88,78.55
  TOP w0.102: RC33.1 72.45,81.19 v1(72.45,81.1) 72.88,80.67 72.88,78.55
  BOTTOM w0.102: v4(71.87,80.73) 72.1,80.73 72.45,81.09 v1(72.45,81.1) 72.38,81.18 RC41.1
XDP_TDO: length 10.4
  BOTTOM w0.102: v2(77.49,84.52) 77.49,84.51 ; 77.49,84.51 77.31,84.33 76.83,84.33 75.54,83.03 RC37.2 ; 77.49,84.51 78.65,85.67 78.65,87.47 78.23,87.89 RC43.1 78.13,87.96 78.13,90.68 78.15,90.7 JXDP1.20
XDP_TDO_R: length 8.4
  TOP w0.089: v5(74.4,74.96) 74.9,74.46 JCPU1.AP26
  BOTTOM w0.102: v5(74.4,74.96) 74.4,75.31 74,75.71 74,77.98 74.33,78.31 v4(74.33,78.55) 74.33,79.16 74.5,79.32 74.5,80.71 75.54,81.75 RC37.1
XDP_TMS: length 24.8
  TOP w0.089: JCPU1.AR27 73.81,75.45 v5(73.4,75.86)
  TOP w0.102: v1(76.66,85.15) 76.9,84.91 78.06,84.91 v1(79.23,86.08) 79.23,87.58 78.69,88.13 78.69,89.22 RC38.1
  BOTTOM w0.102: v1(79.23,86.08) 79.23,87.55 v4(79.38,87.7) 79.63,87.95 79.63,90.68 79.65,90.7 JXDP1.23 ; v1(76.66,85.15) 76.66,84.84 74.98,83.16 74.98,81.51 74.28,80.81 74.28,79.57 73.81,79.1 73.81,76.27 v5(73.4,75.86)
XDP_TRST#: length 36.5
  TOP w0.089: JCPU1.AP30 v5(70.39,73.94)
  TOP w0.102: RC45.1 79.07,88.41 v1(79.13,88.35) 79.67,87.82 79.67,85.88 78.45,84.66 76.53,84.66 76.22,84.96 76.22,85.41 76.78,85.97 76.78,87.88 75.74,88.93 73.68,88.93 73.32,88.56 73.32,86.77 v1(72.96,86.41)
  BOTTOM w0.102: v1(79.13,88.35) 78.63,88.85 78.63,90.54 78.65,90.56 JXDP1.21 ; v1(72.96,86.41) 72.9,86.35 v4(72.9,85.52) 73.11,85.31 73.11,84.07 72.88,83.84 72.88,81.34 73.05,81.18 73.05,80.84 72.63,80.42 v1(72.4,80.42) 72.35,80.37 72.35,79.5 71.14,78.3 71.14,76.34 70.38,75.58 70.38,73.95 v5(70.39,73.94)
XTAL25_IN: length 5.7
  TOP w0.102: UH4.V47 26.2,127.68 26.53,128 26.53,128.66 26.47,128.73
  TOP w0.203: 26.47,128.73 26.47,131.36 RH99.1 RH309.2
XTAL25_OUT: length 8.8
  TOP w0.203: YH2.3 24.9,135.15 25.07,134.99 25.07,134.03 CH18.2 25.26,133.11 25.26,132.22 25.79,131.69 RH99.2 26.14,131.29 26.14,130.37 25.87,130.11 v2(25.87,130.02) 25.87,129.43 26.14,129.16 26.14,128.23 UH4.V49
XTALI: length 7.7
  TOP w0.203: Y3.3 116.05,157.59 v2(116.88,157.59) 118.08,157.59 118.64,157.04 C471.1 119.16,157.04 119.52,157.39 119.52,158.45 120.52,159.45 U31.10
XTALO: length 3.1
  TOP w0.203: U31.9 120.37,159.85 v2(119.81,159.28) 118.71,158.18 R1144.1
XTALO_R: length 7.1
  TOP w0.203: Y3.1 114.27,157.41 114.27,158.72 C470.1 115.92,159.58 116.08,159.42 ; R1144.2 117.31,158.18 116.08,159.42 ; 116.08,159.42 v2(116.08,159.42)
Z2805: length 3.3
  TOP w0.102: v2(92.19,158.8) 91.97,158.8 91.67,158.5 v1(91.67,158.46) 91.95,158.18 R574.1
  BOTTOM w0.102: 91.67,156.89 v1(91.67,158.46)
Z2806: length 3.4
  TOP w0.102: v2(84.05,158.98) 84.43,158.6 v1(84.43,158.43) 84.43,157.61 R573.1
  BOTTOM w0.102: v1(84.43,158.43) 84.05,158.05 84.05,156.89
Z2807: length 3.5
  TOP w0.102: v2(90.4,158.88) 90.52,158.88 90.91,158.5 v1(90.91,158.43) 90.68,158.2 R572.1
  BOTTOM w0.102: T156.21 90.4,157.93 v1(90.91,158.43)
Z2808: length 3.7
  TOP w0.102: R571.1 82.8,157.91 83.16,158.27 v1(83.16,158.31) 82.8,158.66 v2(82.14,158.66)
  BOTTOM w0.102: T156.15 82.78,157.93 v1(83.16,158.31)
Z4012: length 2.3
  BOTTOM w0.254: PR1.2 48.28,99.64 v2(47.51,99.64) 46.31,99.64 PD1.2
Z4304: length 7.9
  TOP w0.102: PD2.2 193.95,8.69 v2(193.36,9.28)
  TOP w0.254: 193.27,3.49 193.95,4.18 PD2.2 193.89,6.45 PR3.1
Z4305: length 7.7
  TOP w0.102: v2(196.53,9.31) 195.88,8.66 PD2.3
  TOP w0.254: PR5.1 197.4,6.39 PD2.3 195.43,5.93 195.43,3.62
Z4306: length 11.1
  TOP w0.102: PD3.2 199.03,8.69 v2(198.35,9.37)
  TOP w0.254: 197.46,3.49 197.46,4.81 PD3.2 199.54,6.39 200.56,7.4 201.58,7.4 PR4.1
ZODD_WAKE#: length 279.3
  TOP w0.102: R796.2 28.09,24.96 v1(28.22,24.83) 27.5,24.11 R792.1 ; v1(121.18,11.67) v2(121.75,11.67)
  IN1 w0.127: v1(109.97,10.66) 109.97,10.47 110.33,10.11 112.28,10.11 113.04,9.35 118.76,9.35 121.08,11.67 v1(121.18,11.67)
  IN2 w0.127: v1(121.18,11.67) 121.44,11.93 125.61,11.93 126.24,12.55 v1(126.24,12.62) ; v1(109.97,10.66) 109.94,10.64 109.56,10.64 108.57,9.65 108.04,9.65 107.25,8.87 105.46,8.87 104.37,7.77 35.32,7.77 34.85,8.24 33.59,8.24 32.76,7.42 32.05,7.42 30.91,8.56 30.91,9.7 29.81,10.8 29.81,18.49 28.78,19.52 28.78,21.97 29.26,22.45 29.26,23.79 v1(28.22,24.83)
  IN3 w0.127: v1(243.03,70.9) 242.53,70.41 242.53,67.77 241.65,66.89 239.59,66.89 238.93,67.55 235.8,67.55 235.37,67.13 234.6,67.13 233.88,66.41 230.2,66.41 228.52,64.73 206.48,64.73 203.43,61.68 202.94,61.68 199.85,58.59 194.19,58.59 193.12,57.52 187.39,57.52 186.98,57.11 186.98,56.2 185.63,54.85 184.64,54.85 183.96,54.17 175.93,54.17 163.42,41.66 163.42,20.34 158.84,15.76 158.84,12.85 157.63,11.63 127.66,11.63 126.64,12.65 126.35,12.65 126.32,12.62 v1(126.24,12.62)
  BOTTOM w0.102: v1(243.03,70.9) 242.98,70.95 U46.A59
N17063765:
  vias: v2(17.17,76.14)
N17075402: length 21.4
  TOP w0.254: v1(4.63,64.64) 4.63,65.09 1.93,67.79 v1(1.93,68.19)
  BOTTOM w0.254: PR9.1 7.43,76.26 7.97,76.26 8.23,76.01 8.23,72.61 PR7.2 v2(6.93,67.54) 6.93,66.34 5.23,64.64 v1(4.63,64.64) ; PQ2.3 2.51,67.6 v1(1.93,68.19)
N17083694: length 4.6
  BOTTOM w0.254: PC116.1 278.01,54 PR112.1 PR113.1 v2(278.01,57.16) 277.45,57.72 PU101.13
N17132539: length 5.1
  BOTTOM w0.102: PC1001.2 130.95,105.04 v2(130.55,104.65)
  BOTTOM w0.254: PR1002.2 132.09,103.92 131.72,104.28 PC1001.2 131.72,106.11 131.8,106.19 PQ907.4
N17319754: length 14.4
  TOP w0.254: v1(179.42,18.73) v2(179.86,19.17) 180.44,19.75 PR1004.1 179.34,20.16 PC1004.1 ; 185.58,11.62 v1(183.87,11.62)
  IN3 w0.254: v1(183.87,11.62) 183.87,15.05 180.19,18.73 v1(179.42,18.73)
N17684555: length 3.1
  BOTTOM w0.102: v2(200.51,13.6) PC1005.1
  BOTTOM w0.508: PC1005.1 199.87,15.05 199.62,15.3 PR1005.2
N17708032: length 3.9
  TOP w0.127: v2(211.41,7.72) PC5.1
  TOP w0.381: PC5.1 PR6.2 209.21,7.72 208.46,8.47 PQ1.2
N17708061: length 6.2
  TOP w0.127: PQ1.1 209.48,6.39 v2(209.94,6.85)
  TOP w0.381: PD5.2 205.92,6.71 206.24,6.39 PQ1.1
N20966390: length 22.8
  BOTTOM w0.254: PR10.2 5.89,59.83 v2(5.89,61.16) 5.89,63.67 5.43,64.12 4.23,64.12 4.06,64.29 4.06,64.85 4.38,65.16 5.05,65.16 5.89,66 5.89,68.17 5.44,68.62 5.23,68.62 PQ2.1 2.74,69.69 2.26,70.17 2.26,71.1 2.8,71.64 PL3.1 2.8,72.45 3.07,72.72 4.44,72.72 5.85,71.31 PR7.1
N20966408: length 3.2
  BOTTOM w0.102: PR12.2 7.28,58.17 v2(7.29,58.18)
  BOTTOM w0.254: PR12.2 PR10.1 PQ3.2
N20966410: length 9.4
  BOTTOM w0.254: PQ3.1 3.69,60.07 3.88,60.25 PR13.1 3.31,61.97 3.31,65.03 PR11.2 4.84,65.6 v2(5.04,65.8) 5.13,65.89 PQ2.2
N21585007: length 6.4
  TOP w0.254: PQ1002.4 v1(184,17.46) ; v1(181.33,18.61) 181.46,18.73 v2(181.46,19.15) PR1006.1
  IN3 w0.254: v1(181.33,18.61) 182.85,18.61 v1(184,17.46)
N21631508: length 3.6
  BOTTOM w0.102: PR1009.1 194.95,17.9 v2(195.05,17.81)
  BOTTOM w0.508: PR1009.1 193.44,20.47 PQ1004.4
N21631518: length 3.4
  TOP w0.102: v2(180.4,77.31) PR1024.1
  TOP w0.254: PU1001.19 178.87,75.96 178.87,75.97 178.87,76.39 178.87,76.4 178.87,76.75 PR1024.1
N21750145: length 8.5
  BOTTOM w0.254: PQ204.6 239.91,50.53 240.12,50.74 240.88,50.74 241.26,50.36 v2(241.26,46.46) PR211.1
N21752779: length 4.1
  BOTTOM w0.102: PR218.2 v2(242.23,41.25)
  BOTTOM w0.254: PQ205.6 240,42.36 240.18,42.54 240.54,42.54 240.75,42.33 240.75,41.47 240.97,41.25 PR218.2
N22506578: length 2.2
  TOP w0.254: PU1001.28 v2(172.72,74.18) 172.24,74.18 172.19,74.23 PR1008.1
N27932189: length 13.3
  IN1 w0.254: v1(48.75,28.64) 48.98,28.41 48.98,21.98 v1(48.08,21.08)
  BOTTOM w0.102: v2(48.07,28.5) 48.21,28.64 v1(48.75,28.64)
  BOTTOM w0.254: PU601.14 48.63,20.54 v1(48.08,21.08) 48.04,21.08 46.71,22.41 PR604.2 ; PR614.1 49.18,28.21 v1(48.75,28.64)
N27941874: length 10.9
  IN1 w0.254: v1(48.08,27.58) 48.56,27.1 48.56,23 47.83,22.26 v1(47.83,22.01)
  BOTTOM w0.254: PU601.15 49.13,20.76 v2(48.73,21.16) 47.87,22.01 v1(47.83,22.01) 47.73,22.11 PR601.2 ; PR613.1 48.7,26.96 v1(48.08,27.58)
N27967271: length 1.8
  BOTTOM w0.508: PR605.1 50.52,23.61 PC601.1
  vias: v2(50.09,21.16)
N27995579: length 2.7
  BOTTOM w0.254: PR612.1 48.87,13.77 49.63,14.53 v2(49.63,14.63) PU601.3
N27996731: length 4.9
  BOTTOM w0.102: PC618.2 v2(50.87,11.45)
  BOTTOM w0.254: PU601.2 50.13,14.32 49.9,14.1 PC617.1 49.9,13.49 50.85,12.64 PC618.2
N28024997: length 4.3
  BOTTOM w0.254: PU601.5 48.63,14.94 v2(48.29,14.6) 47.98,14.29 47.63,14.29 PR610.2 PR611.1
N28058271: length 5.1
  BOTTOM w0.102: PC619.2 47.38,13.02 v2(47.38,11.48)
  BOTTOM w0.254: PU601.4 49.13,14.77 PC619.2
N31942683: length 2.7
  TOP w0.102: QC1.1 95.57,82.61 RC7.2 95.28,81.89 v2(95.72,81.45)
N31979527: length 1.9
  TOP w0.089: JCPU1.J15 85.85,49.45 v1(85.33,48.92)
  BOTTOM w0.089: v1(85.33,48.92) 85.7,48.92 T49.1
N31979574: length 1.4
  TOP w0.089: JCPU1.W8 92.9,59.41 v1(92.4,58.91)
  BOTTOM w0.089: v1(92.4,58.91) 91.94,59.37 T6.1
N31979576: length 1.3
  TOP w0.089: JCPU1.AT26 74.9,76.49 v5(74.4,76.99)
  BOTTOM w0.102: T8.1 74.42,76.97 v5(74.4,76.99)
N31979578: length 1.4
  TOP w0.089: JCPU1.AM33 67.85,72.45 67.35,71.95 v1(67.33,71.95)
  BOTTOM w0.102: T10.1 67.33,72.09 v1(67.33,71.95)
N31979580: length 1.4
  TOP w0.089: v5(73.4,69.94) 73.89,69.45 JCPU1.AJ27
  BOTTOM w0.089: v5(73.4,69.94) 73.4,69.81 T12.1
N31979582: length 1.5
  TOP w0.089: v1(92.4,55.93) 92.4,55.93 92.9,56.43 JCPU1.T8
  BOTTOM w0.089: T14.1 92.05,56.28 v1(92.4,55.93)
N31979584: length 1.3
  TOP w0.089: v1(85.35,49.92) 84.9,49.47 JCPU1.J16
  BOTTOM w0.089: T15.1 85.67,49.92 v1(85.35,49.92)
N31979586: length 1.4
  TOP w0.089: JCPU1.H16 84.84,48.45 v1(84.37,48.92)
  BOTTOM w0.089: T16.1 84.4,48.92 v1(84.37,48.92)
N31979588: length 1.4
  TOP w0.089: JCPU1.G16 84.86,47.45 84.39,47.91 v1(84.39,47.92)
  BOTTOM w0.089: T17.1 84.39,47.91 v1(84.39,47.92)
N31979600: length 1.4
  TOP w0.089: v5(74.39,69.92) 74.87,69.45 JCPU1.AJ26
  BOTTOM w0.089: v5(74.39,69.92) 74.76,70.3 T18.1
N31979608: length 1.9
  TOP w0.089: JCPU1.J20 80.92,49.45 v1(81.38,49.92)
  BOTTOM w0.089: T47.1 81.16,49.7 v1(81.38,49.92)
N31979610: length 1.3
  TOP w0.089: v5(83.31,41.99) 83.31,42.04 82.9,42.45 JCPU1.B18
  BOTTOM w0.089: T48.1 82.9,42.39 v5(83.31,41.99)
N31979614: length 1.4
  TOP w0.089: v5(74.4,68.91) 73.94,68.45 JCPU1.AH27
  BOTTOM w0.102: T1.1 74.78,68.53 v5(74.4,68.91)
N31979616: length 7.5
  TOP w0.102: JCPU1.AR1 99.92,75.45 100.75,76.28 100.75,80.14 T52.1
N31979618: length 1.4
  TOP w0.089: JCPU1.B1 99.9,42.45 v1(100.4,42.96)
  BOTTOM w0.089: T53.1 99.93,42.48 v1(100.4,42.96)
N31979620: length 5.8
  TOP w0.102: JCPU1.AT1 99.9,80.94 T51.1
N31979622: length 5.3
  TOP w0.102: JCPU1.AT2 98.9,81.34 T50.1
N31979624: length 6.5
  TOP w0.102: JCPU1.AR35 65.44,75.91 65.44,76.14 64.87,76.71 64.87,77.71 64.27,78.31 64.27,79.34 T19.1
N31979626: length 6
  TOP w0.089: 65.07,78.55 65.07,78.28 JCPU1.AT34
  TOP w0.102: T20.1 65.07,81.2 65.07,78.55
N31979628: length 8.8
  TOP w0.089: 68.33,77.29 68.33,78.55
  TOP w0.102: 68.33,78.55 68.33,80.44 67.68,81.09 67.45,81.09 66.88,81.66 66.88,83.16 66.7,83.34 66.7,83.92 T21.1 ; JCPU1.AT33 68.33,76.88 68.33,77.29
N31979630: length 9.6
  TOP w0.102: JCPU1.AP35 65.9,74.48 65.43,74.96 65.43,75.36 64.37,76.42 64.37,77.66 63.21,78.83 63.21,79.32 62.33,80.2 61.38,80.2 T22.1
N31979632: length 1.4
  TOP w0.089: JCPU1.AJ32 68.9,69.74 69.06,69.9 69.34,69.9 69.37,69.93 v1(69.39,69.93)
  BOTTOM w0.089: v1(69.39,69.93) 68.97,69.93 T42.1
N31979634: length 1.4
  TOP w0.089: JCPU1.AK32 68.85,70.45 v1(68.34,70.97)
  BOTTOM w0.089: T44.1 67.98,70.97 v1(68.34,70.97)
N31979636: length 7.3
  TOP w0.089: 64.87,78.13 64.87,78.55
  TOP w0.102: 64.87,78.55 64.87,80.8 T23.1 ; JCPU1.AR34 66.78,75.45 66.31,75.92 66.31,76.69 64.87,78.13
N31979642: length 1.9
  TOP w0.089: JCPU1.AE7 93.9,65.45 93.41,64.96 v1(93.41,64.97)
  BOTTOM w0.089: T4.1 v1(93.41,64.97)
N31979644: length 1.4
  TOP w0.089: v1(93.4,66.94) 93.9,67.44 JCPU1.AG7
  BOTTOM w0.089: v1(93.4,66.94) 92.97,67.37 T3.1
N31979646: length 2.4
  TOP w0.089: v1(93.4,50.92) 93.9,51.42 JCPU1.L7
  BOTTOM w0.089: 93.83,51.34 93.86,51.37 T2.1
  BOTTOM w0.102: 93.83,51.34 v1(93.4,50.92)
N31979648: length 1.5
  TOP w0.089: v1(99.4,69.92) 98.9,70.42 JCPU1.AK2
  BOTTOM w0.089: T5.1 99.91,70.42 v1(99.4,69.92)
N31979665: length 1.5
  TOP w0.089: v5(76.29,46.95) 76.26,46.93 76.24,46.93 75.9,46.58 JCPU1.F25
  BOTTOM w0.089: T24.1 76.06,47.18 v5(76.29,46.95)
N31979667: length 8.6
  TOP w0.102: T37.1 71.04,35.7 71.04,36.81 70.51,37.34 70.51,39.74 70.29,39.95 70.29,42.84 JCPU1.C30
N31979669: length 3.8
  TOP w0.089: JCPU1.D23 77.96,44.45 78.43,43.98 v1(78.43,43.95)
  BOTTOM w0.089: T35.1 77.86,42.11 78.21,42.46 78.4,42.46 78.74,42.8 78.74,43.64 v1(78.43,43.95)
N31979671: length 1.3
  TOP w0.089: JCPU1.F23 77.9,46.49 v5(78.33,46.92)
  BOTTOM w0.089: v5(78.33,46.92) 78,46.6 T26.1
N31979673: length 1.4
  TOP w0.102: v1(77.32,46.91) 77.32,46.88 76.9,46.46 JCPU1.F24
  BOTTOM w0.089: v1(77.32,46.91) 76.81,47.42 T25.1
N31979675: length 6.1
  TOP w0.102: JCPU1.B30 70.9,42.42 70.48,42.01 70.48,40.16 70.84,39.81 70.84,37.44 T39.1
N31979677: length 4.1
  TOP w0.102: T38.1 69.9,37.49 JCPU1.A31
N31979679: length 8.2
  TOP w0.102: JCPU1.C29 71.89,43.45 71.3,42.86 71.3,40.8 71.63,40.48 71.63,38.63 72.13,38.13 72.13,36.37 T46.1
N31979681: length 1.3
  TOP w0.089: v5(76.26,47.96) 76.26,47.96 75.9,47.59 JCPU1.G25
  BOTTOM w0.089: v5(76.26,47.96) 76.26,48.11 T29.1
N31979683: length 3.6
  TOP w0.089: v1(77.39,44.91) 76.93,44.45 JCPU1.D24
  BOTTOM w0.089: 76.94,44.46 75.76,44.46 74.98,43.68 T27.1
  BOTTOM w0.102: v1(77.39,44.91) 77.39,44.91 76.94,44.46
N31979685: length 2.4
  TOP w0.089: v5(78.33,45.97) 77.9,45.55 JCPU1.E23
  BOTTOM w0.089: 78.01,45.65 77.16,45.65 77.16,45.66 T33.1
  BOTTOM w0.102: 78.01,45.65 v5(78.33,45.97)
N31979687: length 1.4
  TOP w0.102: JCPU1.G24 76.9,47.59 v5(77.31,47.99)
  BOTTOM w0.089: v5(77.31,47.99) 77.64,48.32 T31.1
N31979689: length 6.1
  TOP w0.102: T40.1 72.49,37.78 72.49,38.21 71.99,38.71 71.99,40.48 71.53,40.94 71.53,42.1 71.88,42.45 JCPU1.B29
N31979691: length 1.4
  TOP w0.089: v1(70.5,43.94) 70.5,43.96 70.9,44.36 JCPU1.D30
  BOTTOM w0.102: T41.1 70.97,44.43 70.5,43.96 v1(70.5,43.94)
N31979693: length 5.8
  TOP w0.102: T43.1 69.47,38.09 69.47,42.02 JCPU1.B31
N31979695: length 7.3
  TOP w0.102: T45.1 71.82,35.36 71.82,37.95 71.31,38.46 71.31,40.23 70.9,40.64 JCPU1.A30
N31979738: length 5.5
  TOP w0.102: JCPU1.A33 67.9,36.14 T30.1
N31979740: length 8.2
  TOP w0.102: JCPU1.B34 66.5,42.05 66.5,39.69 66.47,39.66 66.47,37.41 67.45,36.44 T28.1
N31979742: length 4.4
  TOP w0.102: JCPU1.A34 66.9,41.34 67.24,41 67.24,37.3 T32.1
N31979746: length 7.7
  TOP w0.102: JCPU1.B35 65.74,42.29 59.61,42.29 T34.1
N31979748: length 6.4
  TOP w0.102: T36.1 60.95,42.6 64.81,42.6 64.87,42.54 65.18,42.54 65.9,43.26 JCPU1.C35
N32023073: length 3.7
  TOP w0.102: QC5.2 118.24,49.59 RC83.2 RC82.2 118.01,48.32 v2(117.5,47.82)
N32165635: length 4.4
  TOP w0.102: JMXM1.55 v2(195.98,158.77) 194.89,157.68 R1970.2
N32221714: length 4.9
  TOP w0.203: YH2.1 25.87,136.75 25.39,136.27 25.39,134.07 CH19.2 RH309.1
N32267992: length 1.6
  TOP w0.102: v1(21.8,108.4) 21.97,108.56 UH4.K10
  BOTTOM w0.102: T104.1 21.23,107.75 21.8,108.32 v1(21.8,108.4)
N32810427: length 37.1
  TOP w0.102: CE3.1 182.84,88.66 v1(182.18,88) ; v1(180.26,86.31) 180.26,86.59 178.62,88.23 178.62,88.98 174.1,93.5 172.85,93.5 v1(172.65,93.31) ; RE5.2 171.04,109.36 170.11,110.29 v1(170.05,110.29)
  IN3 w0.127: v1(180.26,86.31) 181.3,87.35 181.53,87.35 v1(182.18,88)
  BOTTOM w0.102: v1(170.05,110.29) 170.88,109.46 170.88,105.82 170,104.94 170,102.23 171.86,100.37 172.8,100.37 173.67,99.5 v2(173.67,97.98) 173.67,93.83 173.25,93.41 172.76,93.41 v1(172.65,93.31)
N32810638: length 2.2
  TOP w0.102: v2(174.5,93.6) 174.09,94.01 RE6.2
  TOP w0.127: RE6.2 CE4.1
N32854162: length 2
  BOTTOM w0.102: R756.2 C704.1 v2(111.85,112.11)
N32854418: length 2
  BOTTOM w0.102: RE11.2 CE8.1 v2(106.98,112.11)
N32854492: length 2
  BOTTOM w0.102: RE12.2 CE9.1 v2(99.94,112.11)
N32893408: length 4.7
  BOTTOM w0.254: PR609.2 45.99,14.68 v2(46.76,14.68) 47.23,14.68 47.34,14.8 47.78,14.8 48.13,15.15 PU601.6
N32893413: length 2.1
  BOTTOM w0.102: PR612.2 v2(48.87,11.49)
  BOTTOM w0.254: PC618.1 49.88,12.54 PR612.2
N32894918: length 3.5
  TOP w0.102: v2(139.04,136.97) R565.2 137.99,137.39 138.16,137.56 Q297.6 138.16,138.33 138.04,138.46 137.63,138.46 137.51,138.34 Q297.5
N32916170: length 7.7
  IN2 w0.127: v1(233.11,68.31) 232.37,69.05 229.49,69.05 228.84,68.4 v1(228.84,68.14)
  BOTTOM w0.102: v2(229.23,67.74) v1(228.84,68.14) R804.1 ; U46.B19 232.72,68.7 v1(233.11,68.31)
N32916205: length 10.3
  IN1 w0.109: v1(240.74,69.1) 240.74,69.19 241.58,70.03 243.62,70.03 243.93,70.33 244.3,70.33 244.56,70.07 244.56,70.06 244.56,70.05 244.56,67.41 v1(244.02,66.87)
  BOTTOM w0.102: v1(240.74,69.1) 240.84,69.2 U46.B66 ; v2(244.74,65.91) R771.1 v1(244.02,66.87)
N32917438: length 5.2
  BOTTOM w0.102: U46.B18 231.9,68.2 231.44,67.74 230.83,67.74 v2(229.3,66.21) 228.65,65.56 R802.2
N32917691: length 2.4
  BOTTOM w0.102: R795.2 C713.1 v2(226.25,72.2)
N32917698: length 10.5
  IN2 w0.127: v1(242.34,79.63) 242.2,79.49 242.2,78.24 240.51,76.56 239.17,76.56 238.83,76.22 238.83,75.78 v1(239.32,75.3)
  BOTTOM w0.102: v1(239.32,75.3) 239.72,75.71 239.72,76.38 239.83,76.48 U46.B49 ; R797.2 242.16,79.81 v1(242.34,79.63) 242.42,79.63 243.02,79.03 v2(243.31,79.03)
N32917710: length 2.6
  BOTTOM w0.102: R794.2 228.16,74.92 227.24,74 C712.1 226.4,74 v2(226.05,74.36)
N32931897: length 7.6
  TOP w0.102: U54.B8 162.46,147.63 162.56,147.54 163.03,147.54 163.49,147.99 v1(163.49,148.01)
  BOTTOM w0.102: R886.1 159.48,147.54 161.06,147.54 161.24,147.36 v2(162.15,147.36) 162.46,147.36 162.63,147.54 163.03,147.54 163.49,147.99 v1(163.49,148.01)
N32932223: length 2.1
  TOP w0.102: C747.1 167.74,136.97 v2(167.56,136.79)
  TOP w0.127: C747.1 R885.2
N32933688: length 5.6
  TOP w0.102: U54.B2 162.53,150.63 162.8,150.9 162.8,150.99 v1(162.83,151.02)
  BOTTOM w0.102: R884.1 158.75,150.61 159,150.86 v2(161.16,150.86) 162.62,150.86 162.77,151.02 v1(162.83,151.02)
N32934056: length 10.1
  TOP w0.102: R864.2 213.87,104.15 215.43,104.15 v2(215.54,104.27)
  TOP w0.508: JDEG2.1 210.79,108.94 210.39,108.53 210.39,106.21 212.01,104.59 R864.2
N32934332: length 4.2
  TOP w0.102: R887.1 v2(161.9,139.7) 161.9,141.42 162.72,142.24 U54.B18
N33080426: length 5.6
  BOTTOM w0.102: Q22.1 72.39,139.84 72.46,139.76 73.21,139.76 73.69,140.24 R423.2 73.84,139.81 v2(73.84,138.19)
N33080469: length 11.1
  BOTTOM w0.102: R412.2 68.57,152.04 69.02,151.59 Q19.3 70.5,151.59 70.93,152.02 71.31,152.02 71.8,152.51 72.66,152.51 v2(72.84,152.33) 73.01,152.16 73.01,150.71 R1632.1 C293.1 74.79,149.94 74.79,149.12 74.46,148.79 Q18.3
N33080491: length 6.7
  BOTTOM w0.102: Q19.5 Q19.2 68.23,150.94 R414.2 68.14,149.88 67.84,149.58 Q20.1 67.01,149.58 v2(66.29,150.29)
N34390933: length 4.6
  TOP w0.102: Q300.2 v2(184.25,58.62) 184.25,58.24 184.76,57.73 R505.1 R1624.2
  TOP w0.127: R1621.2 R1624.2
N34391004: length 4.7
  TOP w0.102: v2(185.53,53.76) 185.74,53.97 R513.2 ; Q29.6 186.78,55.29 186.16,54.67 R513.2 ; R513.2 185.74,55.06 186.62,55.94 Q29.5
N34391411: length 1
  TOP w0.102: Q300.6 v2(183.6,62.46)
N34658970: length 3.6
  TOP w0.102: v2(152.17,165.56) 151.12,166.61 Q28.2 149.98,167.99 R399.2
N34659507: length 8.1
  TOP w0.102: U18.19 145.57,160.08 145.9,159.75 v2(146.09,159.75) 146.41,159.75 146.81,159.35 150.46,159.35 R402.2 150.94,159.9 R395.2
N35298388: length 6.9
  TOP w0.102: v2(47.51,122.11) 47.42,122.2 47.42,123.6 47.81,123.98 R781.2 R762.2 46.7,126.47 45.79,126.47 45.57,126.7 Q304.2
N35432705: length 1.5
  BOTTOM w0.102: R939.1 Q79.1
N35432718: length 6.4
  BOTTOM w0.102: Q78.1 225.76,64.11 226.08,63.79 227.29,63.79 227.81,63.27 227.81,62.99 D60.2 D63.2 R937.2
N35432724: length 6.3
  BOTTOM w0.102: Q78.6 225.76,62.2 225.22,61.66 v2(225.22,61.21) 225.22,58.98 225.53,58.67 225.53,58.33 225.7,58.15 226.08,58.15 226.81,57.43 Q79.2
N35432750: length 1.5
  BOTTOM w0.102: R934.1 Q75.1
N35432775: length 1.6
  BOTTOM w0.102: D59.1 234.35,59.91 234.43,59.83 Q74.3
N35432783: length 8.7
  BOTTOM w0.102: Q321.1 235.67,60.29 235.75,60.37 D59.2 ; v2(236.62,60.99) 236.41,60.77 D59.2 ; D59.2 235.75,61.48 235.56,61.67 D62.2 234.67,61.47 234.29,61.47 233.37,60.55 R932.2 233.27,60.1 233.13,59.95 Q74.1
N35432801: length 1.3
  BOTTOM w0.102: Q74.6 232.61,57.28 232.46,57.43 Q75.2
N35674348: length 2.6
  TOP w0.102: Q73.1 100.82,135.45 v2(100.51,135.13) 100.32,134.94 R723.2
N35825115: length 10.1
  BOTTOM w0.102: R724.2 177.91,167.61 177.92,167.6 177.92,166.93 177.58,166.6 174.85,166.6 174.38,167.07 v2(173.39,167.07) 171.75,167.07 171.05,166.37 170.86,166.37 170.64,166.15 JMINI3.3
N35825195: length 5.7
  TOP w0.102: R730.1 179.42,160.97 v2(180.68,159.72) v1(181.33,159.07)
  BOTTOM w0.102: JMINI3.22 181.44,158.96 v1(181.33,159.07)
N36347564: length 2.5
  TOP w0.102: v2(65.34,165.18) 65.54,165.38 66.13,165.38 R43.2 L4.1
N36347682: length 2.4
  TOP w0.102: v2(67.88,165.25) 68.27,165.64 R44.2 L5.1
N38414754: length 4.1
  BOTTOM w0.102: U45.7 294.67,59.39 294.84,59.56 294.84,61.13 294.58,61.39 R747.1 v2(295.51,61.91)
N38606908: length 4
  TOP w0.102: v2(22.43,157.94) 22.43,158.32 21.2,159.54 R783.1 21.07,159.65 19.97,159.65 19.9,159.58 U48.7
N38645812: length 2.8
  BOTTOM w0.102: R1207.2 272.43,76.77 v2(272.1,76.45) 271.39,75.74 U625.7
N38645839: length 2.7
  BOTTOM w0.102: v2(265.4,77.15) 265.37,77.12 R2200.2 265.77,75.74 U625.24
N38691992: length 2.6
  BOTTOM w0.102: U626.7 259.2,75.74 v2(259.52,76.05) 260.48,77.02 R1191.2
N38692019: length 2.8
  BOTTOM w0.102: U626.24 253.61,75.74 253.21,76.14 v2(253.21,76.65) 253.08,76.77 R2202.2
N39332507: length 12.8
  TOP w0.102: v1(165.73,150.22) 165.76,150.22 166.23,150.69 166.23,151.02 165.72,151.52 U54.B62
  IN3 w0.127: v1(165.73,150.22) 166.25,150.74 166.25,151.22 165.39,152.08 165.39,154.64 166.13,155.37 166.13,156.5 165.99,156.64 v1(165.99,156.66)
  BOTTOM w0.102: v2(166.27,150.65) 165.84,150.22 v1(165.73,150.22) ; R867.2 165.95,154.28 165.45,154.78 165.45,155.7 165.71,155.96 165.71,156.38 v1(165.99,156.66)
N39801641: length 4.8
  TOP w0.102: JMXM1.57 196.11,158.27 v2(195.39,157.54) 195.39,156.01 R1971.2
N39900137: length 6.1
  TOP w0.102: R1972.1 209.78,159.75 209.52,160.01 208.37,160.01 v2(207.96,160.41) 207.96,160.44 207.64,160.76 207.64,161.02 207.19,161.48 207.19,161.96 206.63,162.52 JMXM1.40
N41278453: length 5
  BOTTOM w0.102: v2(237.53,44.12) 237.53,43.63 PR223.2
  BOTTOM w0.254: PR225.1 239.35,42.9 PQ205.5 ; PR225.1 PC217.1 ; PR225.1 238.91,43.22 PR223.2
N41278459: length 5.3
  BOTTOM w0.102: v2(237.72,52.69) 237.72,52.09 PR219.2
  BOTTOM w0.254: PQ204.5 239.26,51.62 PC215.1 ; PR220.1 PC215.1 ; PC215.1 238.21,51.66 PR219.2
N41278463: length 7.2
  BOTTOM w0.254: PC214.1 PR217.1 237.83,45.53 v2(237.59,45.77) 237.2,46.17 PR213.2 ; PC214.1 239.26,46.8 PQ204.2 ; PC214.1 238.61,46.94 PQ204.3
N41278649: length 8
  BOTTOM w0.254: PQ205.3 238.7,38.22 PC216.1 ; PC216.1 PR224.1 v2(237.79,36.89) 237.45,36.89 237.2,37.15 PR221.2 ; PC216.1 239.35,38.25 PQ205.2
N41343073: length 16
  IN1 w0.254: v1(233.45,46.93) 233.58,47.05 237.45,47.05 v1(240.63,43.88)
  BOTTOM w0.102: PC218.1 244.31,42.84 v2(243.76,42.29)
  BOTTOM w0.203: v1(233.45,46.93) 233.45,46.42 233.36,46.33 PU201.6
  BOTTOM w0.254: v1(240.63,43.88) 240.63,43.79 241.13,43.28 PR211.2 ; PC218.1 PR208.1 PR215.1 PR211.2 ; PR211.2 PR218.1
N47450571: length 6.7
  TOP w0.254: PR901.3 11.45,91.25 11.29,91.42 11.29,93 v2(10.64,93.65) 9.75,94.54 PQ902.1
N47460076: length 4.8
  BOTTOM w0.102: PR515.1 54.24,27.77 53.8,28.21 v2(53.26,28.21)
  BOTTOM w0.254: PR511.1 54.41,25.46 PQ503.3 54.34,26.63 PR510.1 PR515.1
N47645618: length 9.6
  BOTTOM w0.254: PQ106.2 PQ106.5 270.1,66.52 269.72,66.9 v2(268.64,66.9) 268.04,66.9 267.56,66.42 267.56,65.13 PQ105.1 267.6,62.98 PR117.1
N47645638: length 5.8
  BOTTOM w0.102: v2(264.74,61.53) PR115.2
  BOTTOM w0.254: PC119.1 265.94,64.38 PQ105.2 266,62.73 PR118.2 PR115.2
N47645648: length 4
  BOTTOM w0.102: v2(281.79,54.71) 281.24,55.25 PD100.2
  BOTTOM w0.254: PD100.2 PR113.2
N47912464: length 44.5
  TOP w0.254: PH703.2 v1(37.98,53.99) ; 20.55,73.75 20.11,73.75 PR733.2 ; 20.55,73.75 20.99,73.75 PR735.2 ; 20.55,73.75 v1(20.55,73.72)
  IN4 w0.254: v1(37.98,53.99) 37.63,54.34 36.77,54.34 35.87,53.44 33.98,53.44 32.52,54.9 32.52,58.85 29.3,62.08 29.3,72.75 30.92,74.37 30.92,74.88 30.69,75.11 29.21,75.11 28.19,76.12 24.24,76.12 23.65,76.72 22.73,76.72 21.82,75.81 21.82,74.92 21.82,74.91 20.76,73.85 20.67,73.85 v1(20.55,73.72)
  BOTTOM w0.102: v1(37.98,53.99) v2(37.98,54.72)
N47912533: length 3.4
  BOTTOM w0.102: PR711.1 v2(49.63,46.11)
  BOTTOM w0.508: PC712.2 47.1,46.8 47.79,46.11 PR711.1
N47912632: length 1.4
  TOP w0.102: PR738.1 v2(33.4,84.02)
N47912886: length 1.4
  TOP w0.102: PR755.1 v2(33.55,74.45)
N47912908: length 16.5
  TOP w0.102: v2(34.2,80.04) 33.97,79.81 33.2,79.81 32.35,78.96 PC722.1
  TOP w0.254: v1(23.91,70.17) 24.08,70.34 PR726.2
  IN2 w0.254: v1(23.91,70.17) 25.42,70.17 28.74,73.48 28.74,77.06 30.3,78.63 30.92,78.63 31.19,78.36 v1(31.34,78.36)
N47912912: length 1.3
  BOTTOM w0.102: PR709.2 v2(40.99,45.16)
N47912959: length 36.1
  TOP w0.102: v2(19.88,81.03) PR714.2
  TOP w0.254: v1(22.79,80.54) 22.76,80.58 21.69,80.58 21.22,80.11 PR717.2 PR714.2 ; PH702.2 v1(43.37,91.71)
  IN3 w0.254: v1(43.37,91.71) 43.55,91.53 43.55,85.42 v1(43.15,85.03)
  IN4 w0.254: v1(43.15,85.03) 42.95,84.82 33.45,84.82 33.12,85.15 31.46,85.15 30.96,85.66 25.41,85.66 22.79,83.04 v1(22.79,80.54)
N47913215: length 1
  TOP w0.254: PC743.1 26.67,72.98 26.71,73.02 PR752.2
N47913217: length 9.4
  TOP w0.102: PC735.1 29.03,73.94 29.35,73.62 v2(30.34,73.62)
  TOP w0.203: 27.66,75.65 27.66,76.28 PU702.17
  TOP w0.254: 27.66,75.65 27.66,75.5 27.82,75.34 v5(27.82,75.13) 27.74,75.04 27.74,74.66 27.15,74.08 PR752.1 PR748.1 PC735.1
  BOTTOM w0.254: PR749.2 26.27,75.92 27.2,76.85 PC736.2 27.29,76.74 27.82,76.2 v5(27.82,75.13)
N47913253: length 7.8
  TOP w0.203: PU702.38 26.07,81.93 v2(25.22,82.78) 24.97,83.03 24.97,83.11
  TOP w0.254: 24.97,83.11 24.57,83.5 v1(24.48,83.5) PC704.1 PR701.2 25.47,84.39 PR702.1
  BOTTOM w0.254: v1(24.48,83.5) 24.52,83.54 PR701.2 PC705.1 PR703.2
N47913259: length 1.1
  TOP w0.254: PR704.1 24.52,85.41 PC704.2
N47913269: length 8.7
  TOP w0.203: v1(26.17,83.01) 26.17,82.32 26.47,82.03 PU702.37
  BOTTOM w0.254: v1(26.17,83.01) 26.52,83.35 PC702.1 ; PC702.1 27.02,85.44 27.02,86.27 v2(26.42,86.87) 25.85,87.44 PR705.1 ; PC702.1 26.04,85.41 PC705.2
N47913277: length 1.3
  BOTTOM w0.254: PR703.1 25.47,86.42 26,85.88 PC702.2
N47913281: length 3.4
  BOTTOM w0.254: PR701.1 25.02,83.94 25.02,83.21 24.84,83.03 v2(24.84,82.78) 24.84,82.49 25.63,81.7 PC701.2
N47913307: length 54.3
  TOP w0.254: PH701.1 54.01,85.95 54.01,90.04 53.38,90.68 53.02,90.68 52.45,91.25 52.45,91.59 51.67,92.37 48.19,92.37 47.32,93.24 35.84,93.24 34.56,91.96 30.19,91.96 29.88,92.27 26.76,92.27 22.84,88.34 20.56,88.34 19.15,86.93 19.15,83.12 19.91,82.36 20.38,82.36 v1(20.64,82.61)
  BOTTOM w0.254: PR706.2 21.22,79.18 v2(20.04,80.36) 20.04,81.92 20.64,82.51 v1(20.64,82.61)
N47913353: length 1.1
  TOP w0.254: PR710.2 23.18,83.12 PC711.1
N47913357: length 5.1
  TOP w0.203: PU702.40 25.27,81.68 25.09,81.85 24.45,81.85 23.7,82.6 23.7,83.62 PC711.2
  TOP w0.254: PC711.2 23.18,84.14 PR712.2
N47913473: length 2.8
  TOP w0.102: v2(29.78,72.33) 29.78,72.59 29.35,73.02 PC735.2
  TOP w0.254: PC735.2 29.03,72.58 28.56,72.11 PR744.1
N47913489: length 2.6
  BOTTOM w0.254: PR749.1 27.27,75.84 27.27,75.4 27.33,75.34 v2(27.33,74.82) 27.66,74.49 28.26,74.49 PC741.2
N47913553: length 3.7
  BOTTOM w0.102: PR760.2 24.06,70.81 24.53,70.33 25.6,70.33 v2(25.84,70.57)
  BOTTOM w0.254: PR760.2 23.82,70.81 23.21,71.41 PC756.1
N47913557: length 8.4
  TOP w0.203: PU702.15 26.87,75.54 26.76,75.43 v1(26.76,75.3)
  IN4 w0.254: v1(23.2,74.31) 23.3,74.31 24.04,75.06 24.81,75.06 25.35,75.59 26.47,75.59 v1(26.76,75.3)
  BOTTOM w0.102: v1(23.2,74.31) 23.65,74.31 v2(23.79,74.18)
  BOTTOM w0.254: PR757.1 PC756.2 23.21,73.39 23.38,73.55 23.38,74.13 v1(23.2,74.31)
N47928002: length 2.8
  TOP w0.102: v2(28.6,91.67) PC764.1
  TOP w0.508: PC764.1 28.48,90.25 PR764.1
N47928569: length 1.5
  TOP w0.102: v2(32.04,85.2) 31.63,85.61 PR775.1
N47928632:
  vias: v2(32.17,88.66)
N47933880: length 9
  IN1 w0.254: v1(241.9,19.36) 241.91,19.34 241.91,16.69 v1(242.95,15.65)
  BOTTOM w0.254: v1(241.9,19.36) 241.9,19 241.69,18.8 PQ908.3 ; v1(242.95,15.65) PR935.1 243.47,16.37 v2(243.97,16.87) 243.97,17.29 243.75,17.5 PQ908.6
N47933890: length 4.6
  BOTTOM w0.102: PQ910.1 v2(243.89,15.25)
  BOTTOM w0.254: PU903.1 245.15,18.16 245.43,17.88 245.43,17.39 PR945.2 245.07,15.32 PQ910.1
N47935180: length 12.4
  TOP w0.254: v1(240.85,25.67) 240.63,25.44 v2(240.63,23.8) 240.63,20.85 v1(238.91,19.14)
  BOTTOM w0.254: PR936.2 240.68,25.49 v1(240.85,25.67) ; PQ908.2 240.41,18.15 PR931.1 239.42,19.14 v1(238.91,19.14) 238.91,19.11 238.47,18.67 PU902.7
N47935188: length 3.2
  BOTTOM w0.254: PR943.2 241.64,22.87 v2(241.8,22.71) 242,22.51 242,21.25 PQ909.1
N47935257: length 5.6
  IN4 w0.254: v1(245.83,19.46) 244.57,18.2 v1(244.02,18.2)
  BOTTOM w0.102: v1(245.83,19.46) v2(245.83,20.63)
  BOTTOM w0.254: PQ908.5 243.97,18.15 v1(244.02,18.2) ; PU903.4 v1(245.83,19.46)
N47935265: length 10.3
  TOP w0.102: v2(3.92,99.41) PR903.2
  TOP w0.254: PR903.2 4.94,99.43 PC901.2 6.4,99.38 PQ903.2 7,97.37 8.2,98.58 10.41,98.58 10.72,98.27 PQ902.2
N47935277: length 6.4
  TOP w0.254: PU901.17 179.66,30.81 180.47,30 ; 180.47,30 181.65,28.82 PC934.2 183.22,28.82 PR928.2 PC935.1 ; 180.47,30 v2(180.47,29.99)
N47935283: length 14.3
  TOP w0.127: v1(169.26,27.06) v2(169.26,26.39)
  TOP w0.254: PC920.2 PC921.2 169.3,29.27 PR920.2 PC926.1 PC918.2 169.23,27.1 v1(169.26,27.06) ; v1(172.82,30.67) 172.95,30.81 PU901.5
  IN1 w0.254: v1(169.26,27.06) 169.26,29.58 170.33,30.65 172.79,30.65 v1(172.82,30.67)
N47935329: length 2.4
  TOP w0.254: PR922.2 170.53,30.26 PC921.1 PC923.1
N47935331: length 3.6
  TOP w0.254: PU901.6 173.34,30.31 173.2,30.16 v2(172.62,30.16) 172.44,30.16 172.3,30.31 171.53,30.31 PR922.1 PR920.1
N47935337: length 4.9
  TOP w0.508: PR919.2 180.15,37.66 PC917.1 179.93,36.89 v4(179.21,36.18) 177.77,34.74
N47935378: length 14.4
  TOP w0.254: v1(111.85,116.65) 111.78,116.71 111.78,116.82 111.47,117.13 111.47,117.4 111.8,117.73 PQ904.3 ; PQ904.1 111.34,119.63 111.17,119.8 111.17,120.74 110.91,121.01 v2(110.3,121.01) 109.61,121.01 109.29,120.68 PR907.2 PR908.2 PR910.1 109.02,117.4 v1(108.6,117.4)
  IN4 w0.254: v1(111.85,116.65) 111.85,116.43 111.5,116.09 109.03,116.09 108.71,116.41 108.71,117.29 v1(108.6,117.4)
N47935380: length 5.8
  TOP w0.254: PR906.2 173.36,38.34 PC906.1 174.06,36.71 PC905.2 174.06,35.66 174.32,35.4 174.7,35.4 v2(175.02,35.08) 175.38,34.72 PU901.27
N47935394: length 17.1
  TOP w0.254: v1(228.01,22.37) 228.19,22.37 v2(229.06,21.5) 229.06,17.16 v1(227.91,16.02)
  BOTTOM w0.254: PR942.1 231.6,15.48 231.29,15.16 229.28,15.16 228.81,15.63 PR938.1 ; PR938.1 228.81,16.31 228.97,16.47 229.27,16.47 229.76,16.97 PR934.2 230.13,17.4 PU902.1 ; PR938.1 v1(227.91,16.02) ; PR930.2 v1(228.01,22.37)
N47935396: length 6.2
  TOP w0.254: PU901.28 174.88,34.41 174.36,34.93 173.77,34.93 v2(173.52,35.17) 173.11,35.59 PC905.1 173.11,36.57 PC904.2 172.37,37.49 PR905.2
N47935402: length 5.8
  TOP w0.254: PU901.7 173.22,29.81 172.82,29.4 172.82,27.5 v2(172.63,27.31) 172.31,26.99 PR924.2 PC928.1
N47935428: length 7.1
  BOTTOM w0.254: PU902.5 238.34,21.21 238.7,21.57 238.7,22.47 238.52,22.66 237.94,22.66 PC940.1 PR939.2 237.89,24.56 238.23,24.91 v2(238.81,24.91) PR936.1
N47935438: length 10.5
  TOP w0.127: v1(167.71,30.8) v2(167.04,30.8)
  TOP w0.254: PU901.4 173.33,31.31 173.2,31.18 v1(172.31,31.18) 171.93,31.18 171.8,31.31 PR921.2 ; PC920.1 PC927.1 168.08,31.34 167.71,30.98 v1(167.71,30.8)
  IN3 w0.254: v1(172.31,31.18) 171.66,31.83 168.76,31.83 167.73,30.8 v1(167.71,30.8)
N47935442: length 7.9
  TOP w0.127: PR914.1 v2(167.31,33.88)
  TOP w0.254: PR914.1 PR913.1 169.3,33.88 169.77,34.35 171.01,34.35 PC909.1 171.93,33.85 172.95,32.83 172.95,32.45 173.09,32.31 PU901.2
N47935444: length 2.9
  TOP w0.102: v2(178.31,26.95) PR915.2
  TOP w0.254: PR915.2 177.38,26.97 177.38,27.52 177.39,27.54 177.39,27.96 177.38,27.98 PU901.13
N47935488: length 6.4
  TOP w0.127: v2(167.02,28.44) 167.45,28 v1(167.49,28)
  TOP w0.254: PC918.1 v1(167.49,28) ; PR921.1 v1(169.9,31.31)
  IN3 w0.254: v1(169.9,31.31) 167.49,28.89 v1(167.49,28)
N47935534: length 6.2
  TOP w0.254: PR927.2 PC933.2 182.27,30.8 PC934.1 180.64,31.31 v2(180.35,31.31) PU901.18
N47935814: length 7.4
  TOP w0.254: v1(184.89,29.53) 184.63,29.78 PR927.1 ; v1(189.08,31.43) 189.46,31.05 PR923.3
  BOTTOM w0.254: v1(189.08,31.43) 188.67,31.03 188.55,31.03 v2(187.06,29.54) 187.05,29.54 186.79,29.27 185.22,29.27 185.1,29.4 185.01,29.4 v1(184.89,29.53)
N47935820: length 10.3
  TOP w0.254: PR901.2 10.55,91.25 10.83,91.53 10.83,92.86 9.88,93.82 v2(8.2,93.82) 6.23,93.82 5.43,94.62 PQ903.1
N47935824: length 7.1
  TOP w0.254: PR928.1 184.76,28.77 v1(184.89,28.89) ; v1(189.08,30.67) 188.7,31.05 PR923.2
  BOTTOM w0.254: v1(189.08,30.67) 189.08,30.66 v2(188.57,30.16) 187.31,28.89 v1(184.89,28.89)
N47935848: length 7.2
  BOTTOM w0.102: PR940.1 v2(229.76,25.46)
  BOTTOM w0.254: PR940.1 PR932.2 PR930.1 PC938.1 229.76,21.33 231.15,19.94 PU902.3
N47935871: length 5.1
  BOTTOM w0.254: PU902.2 231.29,18.67 v2(230.74,19.22) 229.88,20.08 PC939.1 PR941.1 PR933.2
N47935873: length 3.7
  TOP w0.254: PR902.1 2.53,88.37 2.74,88.58 v2(3.05,88.58) 3.62,88.58 3.96,88.24 PQ901.4
N47935901: length 7.1
  BOTTOM w0.102: PR937.2 239.18,23.89 v2(238.81,23.52)
  BOTTOM w0.254: PR937.2 PR943.1 239.73,22.11 239.49,21.87 PC941.1 PR944.1 239.38,19.94 PU902.6
N47992771: length 2.7
  BOTTOM w0.102: v2(228.45,64.64) D60.1 228.16,64.05 227.26,64.05 227.06,64.25 Q78.3
N48118603: length 2.6
  BOTTOM w0.102: R941.1 v2(293.18,104.42) 293.38,104.62 293.38,105.42 293.22,105.59 Q318.6
N48565658: length 3.1
  BOTTOM w0.102: v2(242.33,59.97) R942.1 241.4,60.73 241.65,60.99 Q80.1
N51303709: length 27.3
  BOTTOM w0.102: 71.22,154.97 Q13.5 ; 71.22,154.97 73.32,154.97 75.38,157.03 75.38,160 77,161.62 77,163.35 76.19,164.16 71.14,164.16 v2(69.97,163) R162.2 67.4,161.96 66.02,160.58 Q23.1 ; 71.22,154.97 Q13.2
N51303757: length 19.2
  BOTTOM w0.102: Q13.6 71.87,155.48 72.17,155.18 73.13,155.18 75.13,157.19 75.13,160.13 76.8,161.8 76.8,163.25 76.08,163.96 71.68,163.96 v2(71.43,163.71) 70.86,163.14 70.86,162.4 70.93,162.33 R161.2
N52004528: length 2.7
  BOTTOM w0.102: v2(247.72,70.24) 248.07,69.9 D34.2 247.29,69.15 247.15,69.29 U47.4
N53105221: length 1.5
  BOTTOM w0.102: Q86.1 R943.1
N53105229: length 9.2
  BOTTOM w0.102: Q86.2 229.35,56.97 229.53,56.79 231.07,56.79 231.23,56.95 231.23,57.95 231.46,58.18 232.48,58.18 232.98,58.67 233.51,58.67 233.84,58.34 233.84,58.08 234.12,57.8 235.58,57.8 235.67,57.71 Q321.6
N56200651: length 2.5
  BOTTOM w0.102: R707.2 201.49,87.95 JMINI2.3
N56200655: length 3.8
  BOTTOM w0.102: JMINI2.5 200.69,88.1 R702.2 199.67,87.91 v2(199.35,87.59)
N57447894: length 4.9
  TOP w0.102: JODD1.11 25.69,24.8 R792.2 26.55,23.87 26.94,23.48 28.14,23.48 v2(28.45,23.79)
N60710877: length 3.6
  TOP w0.102: v2(106.5,152.06) v1(106.5,151.44) 106.51,151.44 107.03,151.96 R704.1
  BOTTOM w0.102: v1(106.5,151.44) 106.91,151.85 JMINI1.22
N63560596: length 5.2
  TOP w0.102: v2(127.49,23.15) 127.72,23.38 127.72,24.27 127.32,24.67 R806.2 R808.2 127.71,26.11 128.88,26.11 129.13,26.37 Q303.2
N66037766: length 9.5
  TOP w0.102: v1(96.62,164.11) 96.85,163.88 R1167.2
  BOTTOM w0.102: JLOM1.11 92.56,163.62 93.38,162.8 v2(96.24,162.8) 96.24,163.73 v1(96.62,164.11)
N66058065: length 5.6
  TOP w0.102: R1170.2 98.89,162.64 v2(98.49,163.04) 96.68,164.85 JLOM1.10
N66078140: length 4.2
  TOP w0.102: JLOM1.13 79.57,164.85 79.18,164.47 R1171.2 78.2,164.49 v2(77.16,165.52)
N66740706: length 5.4
  TOP w0.102: v2(22.46,154.45) 22.46,152.76 R713.1 21.36,151.66 v1(21.36,151.03)
  BOTTOM w0.127: v1(21.36,151.03) 21.24,150.91 JMINI4.22
N72273015: length 3.2
  TOP w0.102: v2(208.63,153.53) 208.54,153.63 R1976.2 206.63,152.52 JMXM1.80
N72829707: length 1
  TOP w0.102: R910.1 C761.1
N72859551: length 1.9
  TOP w0.102: C764.1 R913.1 v2(44.39,99.2)
N75612423: length 3.3
  TOP w0.102: R207.2 81.15,140.7 81.24,140.79 v2(81.24,141.5) JLVDS1.3
N75638681: length 3.7
  TOP w0.102: JEDP1.3 66.24,155.56 66.38,155.42 v2(66.38,155.02) 66.38,154.05 66.09,153.76 R208.1
N83636251: length 6.4
  TOP w0.102: Q110.3 108.49,138.22 108.53,138.25 R1537.2 v2(109.9,139) 110.92,140.02 Q113.2 Q113.5
N83636398: length 6.3
  TOP w0.102: v1(115.38,141.71) 115.43,141.76 R1539.2 ; Q113.6 114,140.67 v2(114.1,140.77) 114.23,140.91 v1(114.23,141.33) ; R1538.1 113.89,142.47 113.21,141.78 v1(113.18,141.78)
  IN1 w0.109: v1(113.18,141.78) 113.28,141.78 113.52,141.54 113.52,141.53 113.75,141.3 114.21,141.3 v1(114.23,141.33) 114.65,141.33 114.87,141.54 115.21,141.54 v1(115.38,141.71)
N83636400: length 7.1
  TOP w0.102: R1523.1 115.38,138.98 v2(114.02,137.62) 113.89,137.49 111.44,137.49 111.13,137.8 R1530.2 111.13,139.34 Q113.3
N83636428: length 3.4
  TOP w0.102: v2(104.61,136.82) 105.06,136.37 R1532.2 105.85,136.37 105.9,136.32 Q110.6 106.84,136.32 106.98,136.46 106.98,136.78 106.79,136.97 Q110.5
N85750543: length 1.3
  TOP w0.102: PR402.2 v2(7.99,148.96)
N85751867: length 4.5
  BOTTOM w0.102: v2(54.2,20.13) 54.1,20.23 54.1,20.78 54.42,21.1 PR509.1
  BOTTOM w0.254: PR509.1 PC511.2 54.42,22.62 54.33,22.71 54.33,23.13 54.63,23.43 PR508.1
N85751870: length 4.9
  BOTTOM w0.102: PR502.2 63.04,20.31 62.75,20.02 60.84,20.02 v2(60.51,20.35)
  BOTTOM w0.508: PC505.2 63.42,21.87 63.04,21.49 PR502.2
N85751946: length 2.6
  BOTTOM w0.254: PR512.2 53.95,24.45 53.69,24.19 PQ503.1
N91647401: length 3.9
  BOTTOM w0.102: v2(178.13,87.4) 178.13,87.49 178.86,88.22 R709.2 179.89,88.98 JMINI2.49
N91785218: length 5.6
  BOTTOM w0.102: v2(190.84,103.7) 191.17,103.37 191.17,102.2 190.67,101.7 R703.2 190.6,101.24 190.69,101.15 JMINI2.22
N92711302: length 3.2
  BOTTOM w0.102: U7.4 181.06,148.41 180.97,148.32 180.67,148.32 180.05,148.94 R1633.1 179.68,148.57 v2(179.14,148.03)
N94639990: length 6.3
  TOP w0.102: v2(83.54,128.88) 83,129.42 D68.2 83,130.77 81.41,132.36 81.41,132.79 81.01,133.18 U3.4
N95930610:
  vias: v2(233.64,49.59)
N96028042: length 3.9
  TOP w0.254: PBATT1.7 201.34,4.5 v3(200.96,4.88) PD3.3
N97449521: length 2.4
  BOTTOM w0.102: v2(277.51,91.5) 277.51,91.24 278.2,90.55 R956.1 278.2,89.83 278.17,89.8 Q84.6
N97693169: length 8.2
  TOP w0.102: v1(47.27,155) 46.58,155 v2(45.71,154.13) 44.27,152.69 v1(44.27,152.29)
  BOTTOM w0.102: Q335.6 46.22,154.3 46.62,154.7 R2151.2 46.87,155.06 46.93,155 v1(47.27,155) ; R2156.1 45.16,150.94 44.27,151.83 v1(44.27,152.29)
N97693171: length 6.1
  BOTTOM w0.102: v2(44.72,157.16) R2155.1 44.72,156.15 R2157.2 43.78,154.99 44.4,154.37 44.4,152.79 44.92,152.28 Q335.3
N97693199: length 3.1
  BOTTOM w0.102: 48.22,154.33 48.22,154.34 47.95,154.62 R2152.2 47.95,155.71 v2(48.08,155.83) ; 48.22,154.33 Q336.5 ; 48.22,154.33 48.6,154.33 48.87,154.06 Q336.6
N101024776: length 4.1
  BOTTOM w0.102: Q337.6 52.58,156.53 51.87,155.82 R2154.2 50.96,155.88 R2162.1 v2(49.93,156.74)
N101024778: length 3.7
  BOTTOM w0.102: R2161.2 R2163.1 53.85,154.91 54.17,155.23 Q337.3 v2(55.75,155.23)
N101696083: length 2.2
  TOP w0.254: U59.6 169.47,175.2 169.82,175.55 v2(169.94,175.55) 170.73,175.55 PR28.1
N101696144: length 11.7
  TOP w0.254: PQ1005.6 164.99,175.16 164.69,175.46 v3(164.69,175.63) ; v1(173.18,172.62) 173,172.8 PR30.1
  IN4 w0.254: v3(164.69,175.63) 166.77,175.63 169.35,173.05 172.74,173.05 v1(173.18,172.62)
N101696146: length 21.9
  TOP w0.254: v3(162.28,175.29) 162.33,175.23 PR29.2 162.84,174.55 162.88,174.51 PQ1005.2
  IN4 w0.254: v1(170.19,172.36) 169.3,172.36 166.97,174.7 162.86,174.7 v3(162.28,175.29)
  BOTTOM w0.254: PR31.1 175.83,173.29 174.97,172.43 174.97,171.67 ; 174.97,171.67 170.88,171.67 v1(170.19,172.36) ; 174.97,171.67 174.97,170.35 174.46,169.84 PU2.1
N101696169: length 29.1
  TOP w0.254: PR28.2 171.83,175.45 172.46,175.45 v1(172.58,175.34) ; v1(161.38,175.33) PR29.1 PC19.1
  IN4 w0.254: v1(171.7,170.45) 170.47,170.45 168.22,172.7 163.31,172.7 161.38,174.62 v1(161.38,175.33)
  BOTTOM w0.254: v1(161.38,175.33) 161.96,174.75 165.87,174.75 v2(166.27,175.15) 166.98,175.86 172.06,175.86 v1(172.58,175.34) ; PU2.3 171.92,170.23 v1(171.7,170.45)
N101696187: length 17.5
  IN4 w0.254: v1(177.44,167.07) 177.44,166.9 176.43,165.89 173.86,165.89 172.68,167.07 170.08,167.07 v1(169.92,166.91)
  BOTTOM w0.254: v1(169.92,166.91) 170.83,166.91 v2(171.33,167.41) 171.61,167.69 172.92,167.69 173.19,167.96 PU2.2 ; PC20.1 177.78,171.01 PR26.1 PR27.2 177.35,168.7 177.35,167.16 v1(177.44,167.07)
N101982336: length 6.3
  TOP w0.254: PR24.1 171.84,172.01 172.01,171.84 172.99,171.84 v2(173,171.83) 173.59,171.83 174.39,171.03 174.39,169.43 174.79,169.04 PR25.2
N101986272: length 6.7
  TOP w0.254: PR25.3 173.79,169.04 174.04,169.29 174.04,170.85 173.47,171.43 v2(171.55,171.43) 170.94,172.03 PR14.1
N104675424: length 11.5
  TOP w0.254: v1(159.98,172.94) 159.98,173.37 159.38,173.97 158.93,173.97 158.72,174.17 U60.2
  BOTTOM w0.254: R2181.2 167.8,174.36 162.96,174.36 v2(161.94,173.34) 161.57,172.96 160.01,172.96 v1(159.98,172.94)
N104675428: length 11.6
  TOP w0.254: v1(159.28,172.91) 159.28,173.49 v2(159.24,173.52) U60.1
  BOTTOM w0.254: v1(159.28,172.91) 159.89,172.31 161.54,172.31 163.21,173.98 167.89,173.98 R2180.2
N109035766: length 2.2
  BOTTOM w0.102: Q340.3 294.5,66.03 R2190.2 v2(294.58,67.06)
N109035794: length 3.8
  BOTTOM w0.102: Q339.5 291.44,64.64 291.55,64.53 291.97,64.53 292.09,64.65 Q339.6 292.09,66.03 R2192.2 292.17,66.26 v2(291.36,67.07)
N109035808: length 2.1
  BOTTOM w0.102: R2191.2 292.41,62.6 v3(292.64,62.6) 293.04,62.6 293.2,62.76 Q340.6
N110700389: length 7
  IN1 w0.109: v1(269.47,80.46) 269.72,80.2 v1(269.72,77.71)
  BOTTOM w0.102: v1(269.72,77.71) 269.58,77.57 U625.5 ; v2(269.09,81.6) 270.14,81.6 R2201.2 270.39,81.12 269.72,80.46 v1(269.47,80.46)
N110731646: length 6.4
  IN1 w0.109: v1(257.4,77.71) v1(257.4,80.46)
  BOTTOM w0.102: U626.5 257.14,77.45 v1(257.4,77.71) ; v2(258.2,82.45) R2203.2 258.2,81.25 v1(257.4,80.46)
N141046134: length 4.2
  BOTTOM w0.102: 227.25,49.66 227.25,50.11 v2(227.7,50.56)
  BOTTOM w1.016: 227.86,46.46 227.01,47.31 227.01,49.25
N141046260: length 2.9
  BOTTOM w0.102: PR201.1 v2(224.86,44.87)
  BOTTOM w0.508: PC205.2 PR201.1
N141046431: length 2.5
  BOTTOM w0.203: PR209.2 234.52,44.51 234.42,44.41 234.15,44.41 v2(234,44.56) 234,44.56 233.44,45.13 PU201.9
N1098609670: length 109.7
  TOP w0.102: v2(54.08,71.06) 53.92,70.9 v1(53.92,70.18)
  TOP w0.254: PH704.1 v1(53.92,70.18)
  IN4 w0.254: v1(24.24,74.52) 24.66,74.1 24.66,73.36 24.01,72.71 21.31,72.71 20.45,71.84 20.45,67.16 29.75,57.85 29.75,54 36.8,46.95 36.8,44.39 41.31,39.88 56.93,39.88 61.61,44.55 61.61,54.48 62.06,54.94 62.06,70.56 58.67,73.95 56.84,73.95 56.03,73.13 56.03,71.48 54.71,70.17 53.93,70.17 v1(53.92,70.18)
  BOTTOM w0.254: v1(24.24,74.52) 24.25,74.52 24.42,74.36 PR753.2

## Copper pours and planes (outline as drawn)
1.5V_B+ on BOTTOM (solid shape): 220.99,38.77 220.99,34.27 220.11,33.39 220.11,29.59 219.66,29.13 215.57,29.13 215.57,29.68 216.13,29.68 216.13,30.43 215.57,30.43 215.57,30.86 216.13,30.86 216.13,31.62 215.57,31.62 215.57,32.44 214.06,33.95 214.06,38.14 215.06,39.14 220.62,39.14
1.5VSP_LX on BOTTOM (solid shape): 209.02,76.65 209.02,74.99 209.27,74.74 210.29,74.74 210.41,74.61 210.41,73.98 210.29,73.85 209.78,73.85 209.52,73.6 209.52,71 209.26,70.74 206.67,70.74 206.3,71.11 206.3,71.38 206.3,71.94 206.3,76.65 206.43,76.77 208.89,76.77
1.5VSP_VIN on BOTTOM (solid shape): 213.84,74.61 213.84,69.79 213.59,69.53 212.44,69.53 212.19,69.79 212.19,72.45 212.44,72.71 212.44,74.61 212.57,74.74 213.71,74.74
1.8VSP_LX on BOTTOM (solid shape): 104.34,19.5 104.9,19.5 105,19.39 105,18.73 104.88,18.61 104.43,18.61 104.05,18.23 103.85,18.23 103.54,17.92 103.54,15.18 103.41,15.05 101.83,15.05 101.45,15.43 101.45,20.87 101.54,20.97 102.87,20.97
1.8VSP_VIN on BOTTOM (solid shape): 108.69,19.37 108.69,16.19 108.18,15.69 108.18,14.54 107.8,14.16 105.89,14.16 105.64,14.42 105.64,16.7 106.15,17.21 106.91,17.21 107.03,17.34 107.03,17.9 107.04,17.9 107.04,19.38 107.16,19.5 108.56,19.5
2VREF_6182 on BOTTOM (solid shape): 276.58,64.28 276.58,61.85 275.82,61.85 275.82,63.37 275.12,64.07 275.12,64.52 275.37,64.77 276.08,64.77
+0.75V_DDR_VTT on BOTTOM (solid shape): 234.26,56.38 234.26,55.07 234.12,54.93 232.75,54.93 232.62,55.06 231.1,55.06 231.1,54.6 231.09,54.56 231.05,54.55 230.91,54.55 230.87,54.56 230.86,54.6 230.86,55.04 230.85,55.04 230.85,55.06 230.34,55.06 230.34,54.6 230.32,54.56 230.29,54.55 230.14,54.55 230.1,54.56 230.08,54.6 230.08,55.06 229.58,55.06 229.45,55.18 229.45,56.28 229.7,56.53 232.73,56.53 232.93,56.73 233.9,56.73
+0.75V_DDR_VTT on IN2 (solid shape): outline of 629 points within 167.33,56.15 235.69,85.7
+0.75V_DDR_VTT on IN4 (solid shape): outline of 240 points within 130.99,82.52 169.47,87.86
+0.75VSP on TOP (solid shape): outline of 162 points within 228.56,46.55 231.74,54.04
