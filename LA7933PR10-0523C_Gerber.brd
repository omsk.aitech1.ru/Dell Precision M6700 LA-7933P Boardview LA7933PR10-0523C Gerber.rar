# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
W25Q32BVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64CVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR214.1 R790.1 U46.A60
1.05V_0.8V_PWROK: PR731.1 R883.2 RH283.1 U50.4
1.05V_0.8V_PWROK_R: JXDP2.39 RH283.2
1.05V_A_PWRGD: PR401.2 PU401.1 U54.A14
1.5V_B+: PC201.1 PC202.1 PC203.1 PC204.1 PJP201.2 PQ201.5 PR209.1
1.5V_RUN_PWRGD: PR308.2 PU302.4 U46.B15
1.5V_SUS_PWRGD: PR205.2 PU201.10 U54.B9
1.05V_VTTPWRGD: PR501.2 PR606.2 PU501.1 U50.1
1.5VSP_FB: PC308.2 PR310.2 PR313.1 PU302.6
1.5VSP_LX: PL304.1 PR309.1 PU302.2 PU302.3
1.5VSP_VIN: PC307.1 PL303.2 PU302.8 PU302.9 PU302.10
1.8V_RUN_PWRGD: PR301.2 PU301.4 U46.B10
1.8VSP_FB: PC302.2 PR303.2 PR306.1 PU301.6
1.8VSP_LX: PL302.1 PR302.1 PU301.2 PU301.3
1.8VSP_VIN: PC301.1 PL301.2 PU301.8 PU301.9 PU301.10
2VREF_6182: PC101.1 PR27.1 PU101.3 PU101.4 PU101.14
3V_PWROK#: R391.2 U18.17
+0.75V_DDR_VTT: CD17.1 CD18.1 CD19.1 CD20.1 CD37.1 CD38.1 CD39.1 CD40.1 CD59.1 CD60.1 CD61.1 CD62.1 CD81.1 CD82.1 CD83.1 CD84.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 JDIMM3.203 JDIMM3.204 JDIMM4.203 JDIMM4.204 PJP205.1 R927.1
+0.75VSP: PC206.1 PC207.1 PJP205.2 PU201.2 PU201.20
+1.0V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 R548.1 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+1.5V_CPU_VDDQ: CC70.1 CC72.2 CC73.2 CC74.2 CC75.1 CC76.1 CC77.1 CC78.1 CC79.1 CC80.1 CC81.1 CC82.2 JCPU1.AC1 JCPU1.AC4 JCPU1.AC7 JCPU1.AF1 JCPU1.AF4 JCPU1.AF7 JCPU1.P1 JCPU1.P4 JCPU1.P7 JCPU1.U1 JCPU1.U4 JCPU1.U7 JCPU1.Y1 JCPU1.Y4 JCPU1.Y7 QC3.1 QC3.2 QC3.3 R926.1 RC4.1 RC75.1 RC77.1
+1.5V_CPU_VDDQ_CHG: Q71.1 R926.2
+1.05V_M: CH64.1 CH65.1 CH67.1 CH68.1 CH69.1 PJP402.1 Q63.5 Q63.6 Q63.7 Q63.8 R548.2 RH248.1 UH4.AA19 UH4.AA21 UH4.AA24 UH4.AA26 UH4.AA27 UH4.AA29 UH4.AA31 UH4.AC26 UH4.AC27 UH4.AC29 UH4.AC31 UH4.AD29 UH4.AD31 UH4.T19 UH4.T21 UH4.V21 UH4.W21 UH4.W23 UH4.W24 UH4.W26 UH4.W29 UH4.W31 UH4.W33
+1.05V_M_VCCSUS: CH83.1 RH248.2 UH4.T17 UH4.V19
+1.5V_MEM: CC72.1 CC73.1 CC74.1 CC82.1 CD2.1 CD3.1 CD4.1 CD5.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD46.1 CD47.1 CD48.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM3.75 JDIMM3.76 JDIMM3.81 JDIMM3.82 JDIMM3.87 JDIMM3.88 JDIMM3.93 JDIMM3.94 JDIMM3.99 JDIMM3.100 JDIMM3.105 JDIMM3.106 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM4.75 JDIMM4.76 JDIMM4.81 JDIMM4.82 JDIMM4.87 JDIMM4.88 JDIMM4.93 JDIMM4.94 JDIMM4.99 JDIMM4.100 JDIMM4.105 JDIMM4.106 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 PJP202.2 PJP203.2 QC3.5 QC3.6 QC3.7 QC3.8 RC78.1 RD4.1
+1.05V_MP: PC406.1 PJP402.2 PL401.2 PR407.1
+1.5V_RUN: C435.1 C436.1 C593.1 C594.1 C601.1 C602.1 C609.1 C620.1 C625.1 C635.1 C724.1 JIO1.76 JIO1.78 JMINI1.6 JMINI1.28 JMINI1.48 JMINI2.6 JMINI2.28 JMINI2.48 JMINI3.6 JMINI3.28 JMINI3.48 JMINI4.6 JMINI4.28 JMINI4.48 PJP302.2 R785.1 R924.1 RH211.2 U12.9 U12.11 U12.13 U12.19 U12.26 U12.28
+1.05V_RUN: C772.1 CH30.1 CH31.1 CH32.1 CH33.1 CH44.1 CH45.1 CH46.1 CH47.1 CH48.1 CH56.1 CH77.1 CH79.1 CH81.1 CH82.1 CH96.1 LH3.1 LH5.2 LH6.1 LH7.1 Q63.1 Q63.2 Q63.3 R925.1 R931.1 RH40.2 RH42.2 RH100.2 RH111.1 RH195.1 RH200.1 RH205.1 RH247.1 UH4.AA23 UH4.AC16 UH4.AC17 UH4.AC23 UH4.AD17 UH4.AD21 UH4.AD23 UH4.AF13 UH4.AF14 UH4.AF17 UH4.AF21 UH4.AF23 UH4.AF33 UH4.AF34 UH4.AG21 UH4.AG23 UH4.AG24 UH4.AG26 UH4.AG27 UH4.AG29 UH4.AG33 UH4.AG34 UH4.AH13 UH4.AH14 UH4.AJ23 UH4.AJ26 UH4.AJ27 UH4.AJ29 UH4.AJ31 UH4.AL29 UH4.AN16 UH4.AN17 UH4.AN19 UH4.AN21 UH4.AN26 UH4.AN27 UH4.AN33 UH4.AN34 UH4.AP17 UH4.AP21 UH4.AP23 UH4.AP24 UH4.AP26 UH4.AT24 UH4.N26 UH4.P26 UH4.P28 UH4.T26 UH4.T27 UH4.T29
+1.5V_RUN_CHG: Q68.1 R924.2
+1.05V_RUN_CHG: Q70.1 R925.2
+1.05V_RUN_ENABLE: C773.1 Q63.4 Q304.3 R930.2 R1611.1
+1.05V_RUN_VCCA_A_DPL: CH92.1 CH94.1 LH6.2 UH4.BD47
+1.05V_RUN_VCCA_B_DPL: CH93.1 CH95.1 LH7.2 UH4.BF47
+1.05V_RUN_VCCCLKDMI: CH50.1 CH106.1 RH205.2 UH4.AB36
+1.05V_RUN_VTT: CC66.1 CC67.1 CH49.1 CH85.1 CH86.1 CH87.1 JCPU1.A11 JCPU1.A12 JCPU1.A13 JCPU1.A14 JCPU1.AC10 JCPU1.AG10 JCPU1.AH10 JCPU1.AH13 JCPU1.B12 JCPU1.B14 JCPU1.C11 JCPU1.C12 JCPU1.C13 JCPU1.C14 JCPU1.D11 JCPU1.D12 JCPU1.D13 JCPU1.D14 JCPU1.E11 JCPU1.E12 JCPU1.E14 JCPU1.F11 JCPU1.F12 JCPU1.F13 JCPU1.F14 JCPU1.G12 JCPU1.G13 JCPU1.G14 JCPU1.H11 JCPU1.H12 JCPU1.H14 JCPU1.J11 JCPU1.J12 JCPU1.J13 JCPU1.J14 JCPU1.J23 JCPU1.L10 JCPU1.P10 JCPU1.U10 JCPU1.Y10 JXDP1.16 PC740.2 PC1125.1 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PC1154.1 PC1155.1 PC1156.1 PC1166.1 PC1167.1 PC1168.1 PJP502.1 PR732.1 PR737.2 PR743.2 PR745.2 R399.1 R862.2 R1179.1 RC1.2 RC2.1 RC14.1 RC15.1 RC16.1 RC20.2 RC38.2 RC41.2 RC42.2 RC43.2 RC49.1 RC63.1 RC65.1 RC70.1 RH262.1 UH4.AT20 UH4.AU20 UH4.BJ8
+1.5V_RUNP: PC308.1 PC309.1 PC310.1 PJP302.1 PL304.2 PR310.1
+1.5VP: PC209.1 PC218.2 PJP202.1 PJP203.1 PJP204.2 PL201.1 PR206.1 PR208.2
+1.05VTTP: PC508.1 PC511.1 PJP502.2 PL501.2
+1.8V_RUN: CC88.1 CC89.1 CC90.1 CC91.1 JCPU1.A2 JCPU1.A6 JCPU1.B6 LH8.1 PJP70.2 PJP301.2
+1.8V_RUN_LVDS: CH103.1 CH104.1 CH105.1 LH8.2 UH4.AM37 UH4.AM38 UH4.AP36 UH4.AP37
+1.8V_RUNP: PC302.1 PC303.1 PC304.1 PJP301.1 PL302.2 PR303.1
+3.3V_ALW: C90.1 C92.1 C257.1 C258.1 C259.1 C289.1 C292.1 C357.1 C711.1 C720.1 C723.1 C756.1 C778.1 JIO1.2 JIO1.4 JIO1.6 JKB1.13 JKB1.14 PC942.2 PJP28.1 PJP29.1 PJP104.2 PJP105.2 PL303.1 PR2.1 PR8.2 PR21.1 PR114.2 PR205.1 PR213.1 PR216.1 PR221.1 PR222.1 PR308.1 PR401.1 PR945.1 PR1025.2 PU903.5 Q18.1 Q18.2 Q18.5 Q18.6 Q25.5 Q25.6 Q25.7 Q25.8 Q34.1 Q34.2 Q34.5 Q34.6 Q38.1 Q38.2 Q38.5 Q38.6 Q40.1 Q40.2 Q40.5 Q40.6 Q44.1 Q44.2 Q44.5 Q44.6 Q46.1 Q46.2 Q46.5 Q46.6 Q49.1 Q49.2 Q49.5 Q49.6 Q54.1 Q54.2 Q54.5 Q54.6 Q56.5 Q56.6 Q56.7 Q56.8 Q58.1 Q58.2 Q58.5 Q58.6 Q90.3 Q91.3 R11.1 R14.1 R35.1 R94.2 R95.2 R162.1 R414.1 R418.2 R419.1 R420.2 R692.1 R693.1 R715.1 R721.1 R735.1 R738.1 R755.1 R759.1 R760.1 R761.1 R763.1 R765.1 R768.1 R769.1 R774.1 R776.1 R778.1 R779.1 R796.1 R798.1 R800.1 R805.1 R814.1 R817.1 R818.1 R820.1 R821.2 R823.1 R824.1 R827.1 R828.1 R838.2 R841.2 R847.1 R848.1 R849.1 R850.1 R854.2 R856.2 R858.1 R859.1 R860.1 R861.1 R864.1 R871.1 R872.1 R875.1 R932.1 R937.1 R938.1 R944.1 R1125.2 R1178.2 R2158.1 U7.5 U16.5 U17.5 U47.5 U50.5 U58.5
+3.3V_ALW2: CH100.1 PC105.1 PR105.2 PR937.1 PR1013.1 PR1022.1 PU101.8 R294.1 R500.1 R516.1 R565.1 R907.1 R909.1 R915.1 R918.1 R1532.1 R2152.1 R2192.1 RC76.1 RH253.1 UC4.5
+3.3V_ALW_PCH: C760.1 CC65.1 CH1.1 CH59.1 CH60.1 CH66.1 CH70.1 CH91.1 DH2.2 JXDP2.43 JXDP2.44 Q49.4 R835.2 R908.1 R928.1 R1622.2 RC3.1 RC6.1 RH54.2 RH66.1 RH80.2 RH81.2 RH94.2 RH97.2 RH98.1 RH101.1 RH106.2 RH139.1 RH140.1 RH142.1 RH144.1 RH152.2 RH170.2 RH175.2 RH177.2 RH201.1 RH287.1 RH288.1 RH298.1 RH299.1 RH300.2 RH301.2 RH302.2 RH303.2 RH304.2 RH318.1 RH319.1 RH354.1 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH2.5 RPH2.6 RPH2.7 RPH2.8 UC1.5 UH4.AN24 UH4.N20 UH4.N22 UH4.P20 UH4.P22 UH4.P24 UH4.P32 UH4.T23 UH4.T24 UH4.V23 UH4.V24
+3.3V_ALW_PCH_JTAG: RH43.2 RH44.2 RH45.2 RH288.2
+3.3V_ALW_U46: C708.1 C709.1 C710.1 C717.1 C718.1 C719.1 PJP29.2 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_U54: C726.1 C727.1 C728.1 C729.1 C730.1 C731.1 C732.1 C738.1 C739.1 PJP28.2 U54.A11 U54.A22 U54.A26 U54.A41 U54.A52 U54.A58 U54.B3 U54.B35
+3.3V_ALWP: PC112.1 PC120.2 PJP104.1 PJP105.1 PL103.1 PR101.1 PU101.7
+3.3V_ALWPCH_CHG: Q66.1 R928.2
+3.3V_LAN: C472.1 C473.1 C474.1 C475.1 C476.1 C478.1 C481.1 C483.1 C1167.1 C1178.1 JLOM1.9 JLOM1.12 Q34.4 R545.1 R546.1 R549.1 R553.1 R554.1 R563.2 RH305.2 RH306.2 U15.5 U31.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39
+3.3V_LAN_OUT: C464.1 U31.4 U31.15 U31.19 U31.29
+3.3V_M: C768.1 JSPI1.12 Q58.4 R289.2 R385.2 R389.1 R395.1 R396.1 R397.1 R398.1 R403.1 R404.2 R563.1 R893.1 R916.1 R919.1 RH202.1 RH350.1
+3.3V_M_CHG: Q60.1 R916.2
+3.3V_MXM: C8.1 C94.1 C95.1 C96.1 C332.1 C354.1 C449.1 JMXM1.306 JMXM1.308 PC17.2 Q4.2 Q5.2 Q25.1 Q25.2 Q25.3 Q295.2 Q295.5 R1.1 R2.1 R3.1 R4.1 R5.1 R6.1 R7.1 R8.1 R9.1 R10.1 R37.1 R38.1 R268.1 R400.1 R401.1 R1121.1 R1122.1 R2184.2 R2185.2 U14.5 U25.5 U27.5 U59.3 U60.4
+3.3V_PCIE_FLASH: C624.1 C633.1 C634.1 C637.2 C638.2 C639.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 Q44.4 R732.1
+3.3V_PCIE_NVM: C617.1 C618.1 C619.1 C621.1 C622.1 C623.1 JMINI4.2 JMINI4.24 JMINI4.39 JMINI4.41 JMINI4.52 Q46.4 R734.1 R740.1
+3.3V_PCIE_WWAN: C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C1176.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 Q40.4 Q77.2 R719.2 R723.1 R1159.1 R1160.1
+3.3V_RTC_LDO: PD1.3 PR105.1
+3.3V_RUN: C52.1 C91.1 C93.1 C243.1 C244.1 C248.1 C301.1 C310.1 C359.1 C391.1 C392.1 C402.1 C403.1 C404.1 C405.1 C407.1 C408.1 C410.1 C419.1 C420.1 C437.1 C496.1 C497.1 C722.1 C748.1 C766.1 C775.1 C1145.1 C1146.1 C1149.1 C1159.1 C1181.1 CC69.1 CD21.1 CD22.1 CD43.1 CD44.1 CD65.1 CD66.1 CD87.1 CD88.1 CH43.1 CH51.1 CH72.1 CH75.1 CH76.1 CH99.1 CH102.1 DH3.2 F3.2 JBT1.9 JCAM1.2 JCAM1.4 JDIMM1.199 JDIMM2.199 JDIMM3.199 JDIMM4.199 JIO1.120 JIO1.122 JIO1.124 JIO1.126 JIO1.128 JLVDS1.16 JSATA1.8 JSATA1.9 JSATA1.10 JSATA2.8 JSATA2.9 JSATA2.10 JUSH1.13 LH1.1 PJP34.2 PJP35.2 PJP77.1 PR301.1 PR501.1 PR514.2 PR602.1 PR736.1 Q24.3 Q56.1 Q56.2 Q56.3 QH5.2 QH5.5 R36.1 R39.1 R40.1 R41.1 R42.1 R46.1 R56.1 R58.1 R64.1 R65.1 R68.1 R70.1 R71.1 R72.1 R76.1 R78.1 R80.1 R83.2 R84.2 R85.2 R92.2 R93.2 R159.1 R160.1 R184.2 R339.1 R340.1 R341.1 R405.1 R407.1 R408.1 R409.1 R415.1 R421.1 R457.1 R501.1 R502.1 R503.1 R513.1 R518.1 R547.1 R766.1 R772.1 R777.2 R780.2 R782.2 R787.1 R788.1 R799.1 R822.2 R829.2 R921.1 R929.1 R1118.2 R1123.1 R1124.1 R1133.1 R1134.1 R1165.2 R1177.2 R1197.2 R1530.1 R1539.1 R2151.1 R2154.1 R2157.1 R2161.1 R2190.1 R2191.1 RC30.2 RD8.2 RD9.2 RD17.2 RD18.2 RD26.2 RD27.2 RD35.2 RD36.2 RH28.2 RH30.2 RH35.2 RH52.2 RH87.1 RH137.1 RH138.1 RH158.2 RH163.1 RH164.1 RH171.2 RH173.2 RH178.2 RH179.2 RH181.2 RH203.2 RH204.1 RH215.1 RH256.2 RH263.1 RH266.2 RH267.2 RH268.1 RH269.1 RH272.1 RH275.1 RH276.1 RH316.2 RH317.1 RH324.1 RH325.1 RH326.1 RH327.1 RH328.1 RH329.1 RH330.1 RH331.1 RH332.1 RH340.1 RH355.2 U3.5 U8.5 U9.14 U9.28 U9.41 U9.56 U11.35 U13.35 U19.11 U20.14 U22.1 U22.6 U22.12 U22.25 U22.32 U22.36 U88.1 U88.7 U88.8 U88.14 U627.5 UC2.5 UC3.5 UH3.5 UH4.AA16 UH4.AJ2 UH4.AK36 UH4.BH29 UH4.T34 UH4.V33 UH4.V34 UH4.W16
+3.3V_RUN_CHG: Q69.1 R929.2
+3.3V_RUN_ENABLE: C777.1 Q56.4 Q59.1 R920.2 R1631.1
+3.3V_RUN_R1: R90.1 R92.1 U26.16
+3.3V_RUN_R2: R91.1 R93.1 U26.6
+3.3V_RUN_REP: R83.1 U26.10
+3.3V_RUN_TPM: C550.1 C551.1 C552.1 C553.1 PJP77.2 R656.2 R657.1 R658.1 R873.1 R2189.1 U37.10 U37.19 U37.24 U39.10 U39.19 U39.24
+3.3V_RUN_VCC_CLKF33: CH73.1 CH74.1 RH215.2 UH4.T38
+3.3V_SB3V: C45.1 C48.1 R873.2 U37.5 U39.5
+3.3V_SPI: C787.1 C788.1 JSPI1.11 R890.1 R891.1 RH350.2 U52.8 U53.8
+3.3V_SUS: C53.1 C725.1 C765.1 JIO1.82 JIO1.84 JUSH1.8 JUSH1.9 JUSH1.10 Q54.4 R585.1 R589.1 R914.1 R922.1
+3.3V_SUS_CHG: Q65.1 R922.2
+3.3V_WLAN: C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 Q38.4 Q124.2 Q124.5 R705.2 R716.1 R718.2
+3V_ALW_PCH_ENABLE: C762.1 Q49.3 Q305.3 R905.2 R1619.1
+3VM_THRM: C341.1 C348.1 R289.1 R393.2 U18.4
+3VMXM_D: Q48.1 R268.2
+3VMXM_GATE: C352.1 Q25.4 Q294.3 R269.2 R305.1
+5V_ALW: C256.1 C353.1 C669.1 C670.1 C675.1 C676.1 C715.1 C721.1 JIO1.81 JIO1.83 JIO1.85 JIO1.87 JIO1.89 JIO1.91 JIO1.93 JIO1.95 JIO1.97 JIO1.99 JPB1.2 PC18.1 PC21.1 PC208.2 PC408.1 PC506.1 PC602.2 PC710.1 PC763.1 PC916.1 PC936.1 PC937.1 PD7.3 PJP30.2 PJP31.2 PJP102.2 PJP103.2 PJP601.2 PL301.1 PR11.1 PR31.2 PR204.1 PR605.2 PR709.1 PR715.2 PR718.2 PR720.1 PR726.1 PR740.1 PR776.1 PR931.2 PR1012.2 PU1.5 PU2.8 PU201.12 PU401.7 PU501.7 PU601.18 PU701.6 PU703.6 PU901.11 PU902.8 Q12.1 Q12.2 Q12.5 Q12.6 Q27.1 Q27.2 Q27.5 Q27.6 Q30.1 Q30.2 Q30.5 Q30.6 Q51.5 Q51.6 Q51.7 Q51.8 Q75.3 Q76.5 Q76.6 Q76.7 Q76.8 Q79.3 Q86.3 QH4.1 R816.2 R1614.2 U2.5
+5V_ALW2: PC117.1 PR117.2 PU101.17
+5V_ALW_ESATA: PJP31.1 U48.2 U48.3
+5V_ALW_FUSE: PJP30.1 U45.2 U45.3
+5V_ALW_PCH: CH98.1 QH4.3 R2159.1 RH208.1 RH278.1
+5V_ALW_PCH_ENBLE: CH8.1 QH4.2 QH6.1 RH32.1 RH357.1
+5V_ALW_PCH_R: C290.1 R2159.2 U4.1
+5V_ALWP: PC113.1 PC121.1 PJP102.1 PJP103.1 PL102.2 PR102.2 PU101.24
+5V_ESATA_PWR: C667.1 C668.1 JESA1.1 U48.8 U48.9
+5V_HDD: C394.1 C395.1 C406.1 C409.1 C415.1 C498.1 JSATA1.14 JSATA1.15 JSATA1.16 JSATA2.14 JSATA2.15 JSATA2.16 PJP33.1 Q27.4 R504.1 R506.1
+5V_HDMI_DDC: D70.1 R460.1 R461.1 R1169.2
+5V_MOD: C417.1 C428.1 C429.1 JODD1.9 JODD1.10 PJP32.1 Q30.4 R517.1
+5V_MXM: C7.1 C328.1 C351.1 C356.1 JMXM1.37 JMXM1.39 JMXM1.41 JMXM1.43 JMXM1.45 Q76.1 Q76.2 Q76.3 R274.1
+5V_RUN: C56.1 C311.1 C329.1 C330.1 C364.1 C365.1 C370.1 C758.1 C763.1 C771.1 C1182.1 D9.2 D12.2 D70.2 JCAM1.6 JCAM1.8 JFAN1.1 JFAN2.1 JIO1.125 JIO1.127 JIO1.129 JIO1.131 JIO1.133 JKB1.11 JKB1.12 JUSH1.14 PJP32.2 PJP33.2 Q51.1 Q51.2 Q51.3 Q80.3 QH7.2 R845.2 R846.2 R851.2 R852.2 R912.1 R923.1 R1169.1 R1537.1 R2153.1 R2193.1 RH213.1 U19.21 U19.29 U21.5
+5V_RUN_CHG: Q67.1 R923.2
+5V_RUN_CRT: D9.1 F5.2 R47.1 R48.1 R49.2 R50.1 R52.1
+5V_RUN_ENABLE: C769.1 Q51.4 Q61.1 R906.2
+5V_RUN_HDMI: D12.1 F4.2 R45.2
+5V_USB_PWR1: C324.1 C793.1 JUSB1.1 U45.8
+5V_USB_PWR2: C323.1 C794.1 JUSB2.1 U45.9
+5VMXM_D: Q50.1 R274.2
+5VMXM_GATE: C355.1 Q36.1 Q76.4 R275.2 R278.1
+V1.05S_VCCPP_B+: PC501.1 PC502.1 PC503.1 PC504.1 PJP501.2 PQ501.5
+V1.05SP_B+: PC401.1 PC402.1 PC403.1 PC404.1 PJP401.1 PQ401.5
+VCC_CORE: JCPU1.AA26 JCPU1.AA27 JCPU1.AA28 JCPU1.AA29 JCPU1.AA30 JCPU1.AA31 JCPU1.AA32 JCPU1.AA33 JCPU1.AA34 JCPU1.AA35 JCPU1.AC26 JCPU1.AC27 JCPU1.AC28 JCPU1.AC29 JCPU1.AC30 JCPU1.AC31 JCPU1.AC32 JCPU1.AC33 JCPU1.AC34 JCPU1.AC35 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG27 JCPU1.AG28 JCPU1.AG29 JCPU1.AG30 JCPU1.AG31 JCPU1.AG32 JCPU1.AG33 JCPU1.AG34 JCPU1.AG35 JCPU1.P26 JCPU1.P27 JCPU1.P28 JCPU1.P29 JCPU1.P30 JCPU1.P31 JCPU1.P32 JCPU1.P33 JCPU1.P34 JCPU1.P35 JCPU1.R26 JCPU1.R27 JCPU1.R28 JCPU1.R29 JCPU1.R30 JCPU1.R31 JCPU1.R32 JCPU1.R33 JCPU1.R34 JCPU1.R35 JCPU1.U26 JCPU1.U27 JCPU1.U28 JCPU1.U29 JCPU1.U30 JCPU1.U31 JCPU1.U32 JCPU1.U33 JCPU1.U34 JCPU1.U35 JCPU1.V26 JCPU1.V27 JCPU1.V28 JCPU1.V29 JCPU1.V30 JCPU1.V31 JCPU1.V32 JCPU1.V33 JCPU1.V34 JCPU1.V35 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1109.1 PC1110.1 PC1111.1 PC1120.2 PC1121.2 PC1122.2 PC1123.2 PC1124.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1161.2 PC1162.2 PC1163.2 PC1164.2 PC1165.2 PC1169.2 PC1170.2 PC1173.1 PC1174.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PL701.1 PL702.1 PL703.1 PR719.2 PR723.2 PR728.1 PR742.2 PR747.2 PR751.1 PR759.2 PR762.2 PR763.1 RC59.1 RC67.1
+VCC_GFXCORE: JCPU1.AH17 JCPU1.AH18 JCPU1.AH20 JCPU1.AH21 JCPU1.AH23 JCPU1.AH24 JCPU1.AJ17 JCPU1.AJ18 JCPU1.AJ20 JCPU1.AJ21 JCPU1.AJ23 JCPU1.AJ24 JCPU1.AK17 JCPU1.AK18 JCPU1.AK20 JCPU1.AK21 JCPU1.AK23 JCPU1.AK24 JCPU1.AL17 JCPU1.AL18 JCPU1.AL20 JCPU1.AL21 JCPU1.AL23 JCPU1.AL24 JCPU1.AM17 JCPU1.AM18 JCPU1.AM20 JCPU1.AM21 JCPU1.AM23 JCPU1.AM24 JCPU1.AN17 JCPU1.AN18 JCPU1.AN20 JCPU1.AN21 JCPU1.AN23 JCPU1.AN24 JCPU1.AP17 JCPU1.AP18 JCPU1.AP20 JCPU1.AP21 JCPU1.AP23 JCPU1.AP24 JCPU1.AR17 JCPU1.AR18 JCPU1.AR20 JCPU1.AR21 JCPU1.AR23 JCPU1.AR24 JCPU1.AT17 JCPU1.AT18 JCPU1.AT20 JCPU1.AT21 JCPU1.AT23 JCPU1.AT24 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1116.1 PC1117.1 PC1118.1 PC1119.1 PC1136.1 PC1137.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1157.1 PC1158.1 PL704.1 PL705.1 PR768.2 PR769.1 PR773.1 PR774.2 RC54.1 RC84.1
+VCC_PWR_SRC: PC713.1 PC714.1 PC715.1 PC716.1 PC717.1 PC724.1 PC725.1 PC726.1 PC727.1 PC728.1 PC729.1 PC730.1 PC731.1 PC744.1 PC745.1 PC746.1 PC747.1 PC748.1 PC758.1 PC759.1 PC761.1 PC762.1 PC766.1 PC767.1 PC769.1 PC770.1 PL710.1 PQ701.1 PQ702.1 PQ703.1 PQ704.1 PQ705.1 PQ706.1 PQ707.1 PQ708.1
+VCC_SA: CC83.1 CC84.1 CC85.1 CC86.1 CC87.1 JCPU1.H25 JCPU1.H26 JCPU1.J24 JCPU1.J25 JCPU1.J26 JCPU1.L26 JCPU1.M26 JCPU1.M27 PJP602.2
+VCCA_USBSUS: CH62.1 UH4.AN23
+VCCACLK: RH200.2 UH4.AD49
+VCCADAC: CH34.1 CH35.1 CH36.1 CH37.1 LH1.2 UH4.U48
+VCCAFDI_VRM: RH211.1 UH4.AF11 UH4.AP16 UH4.AT16 UH4.Y49
+VCCAPLL_CPY_PCH: CH58.1 LH3.2 UH4.BH23
+VCCAPLL_FDI: RH195.2 UH4.BG6
+VCCAPLLEXP: CH40.1 RH247.2 UH4.BJ22
+VCCDFTERM: CH52.1 PJP70.1 RH149.1 RH276.2 UH4.AG16 UH4.AG17 UH4.AJ16 UH4.AJ17
+VCCDSW3_3: CH55.1 RH201.2 RH253.2 UH4.T16
+VCCRTCEXT: CH78.1 UH4.N16
+VCCSA_BT: PR607.1 PU601.12
+VCCSA_BT_1: PC603.1 PR607.2
+VCCSA_EN: PR606.1 PU601.13
+VCCSA_P: PC604.2 PC605.2 PC606.1 PC607.2 PC608.2 PC609.1 PC610.2 PC611.2 PJP602.1 PL601.2 PR610.1
+VCCSA_PHASE: PC603.2 PL601.1 PR608.1 PU601.7 PU601.8 PU601.9 PU601.10 PU601.11
+VCCSA_PWR_SRC: PC612.2 PC613.2 PC614.1 PC615.1 PJP601.1 PU601.22 PU601.23 PU601.24
+VCCSA_PWRGD: PR602.2 PR603.2 PU601.16
+VCCSA_SNUB: PC616.1 PR608.2
+VCCSATAPLL: CH80.1 LH5.1 UH4.AK1
+VCCSPI: CH54.1 RH202.2 RH204.2 UH4.V1
+VCCSST: CH84.1 UH4.V16
+VCCSUS1: CH61.1 UH4.AL24
GND: C1.2 C2.2 C3.2 C4.2 C7.2 C8.2 C12.2 C13.2 C14.2 C15.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.1 C45.2 C48.2 C52.2 C53.2 C56.2 C86.2 C87.2 C88.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C243.2 C244.2 C248.2 C249.1 C250.2 C255.2 C256.2 C260.2 C287.2 C289.2 C290.2 C292.2 C293.2 C296.2 C298.2 C299.2 C300.2 C301.2 C305.2 C310.2 C311.2 C313.2 C323.2 C324.2 C327.2 C328.2 C329.2 C330.2 C332.2 C333.2 C336.2 C337.2 C338.2 C341.2 C343.2 C348.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C359.2 C362.2 C364.2 C365.2 C370.2 C391.2 C392.2 C393.2 C394.2 C395.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C415.2 C416.2 C417.2 C419.2 C420.2 C428.2 C429.2 C435.2 C436.2 C437.2 C449.2 C450.2 C451.2 C453.2 C455.2 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C486.2 C496.2 C497.2 C498.2 C550.2 C551.2 C552.2 C553.2 C554.2 C593.2 C594.2 C595.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C637.1 C638.1 C639.2 C644.2 C651.2 C652.2 C667.2 C668.2 C669.2 C670.2 C675.2 C676.2 C695.2 C696.2 C701.2 C702.2 C703.2 C704.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C743.1 C744.2 C745.2 C746.2 C747.2 C748.2 C749.1 C750.1 C753.2 C754.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C787.2 C788.2 C793.2 C794.2 C1145.2 C1146.2 C1149.2 C1159.2 C1167.2 C1174.2 C1176.2 C1177.2 C1178.2 C1181.2 C1182.2 C1183.2 C1184.2 C1185.2 C1186.2 C1188.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1339.2 C1340.2 C1341.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 CC92.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CE3.2 CE4.2 CE6.2 CE8.2 CE9.2 CH1.2 CH2.2 CH3.2 CH4.1 CH5.1 CH8.2 CH18.1 CH19.1 CH20.1 CH21.1 CH22.1 CH23.1 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH40.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH80.2 CH81.2 CH82.2 CH83.2 CH84.2 CH85.2 CH86.2 CH87.2 CH88.2 CH89.2 CH90.2 CH91.2 CH92.2 CH93.2 CH94.2 CH95.2 CH96.2 CH97.2 CH98.2 CH99.2 CH100.2 CH101.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CMOS1.1 D10.1 D11.1 D13.1 D14.3 D14.8 D15.1 D16.3 D16.8 D17.1 D33.1 D73.1 D86.1 D87.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) JBT1.1 JBT1.10 JBT1.13 JBT1.14 JCAM1.5 JCAM1.9 JCAM1.10 JCAM1.12 JCAM1.14 JCAM1.15 JCAM1.21 JCAM1.22 JCPU1.A3 JCPU1.A20 JCPU1.A23 JCPU1.A26 JCPU1.A29 JCPU1.A32 JCPU1.A35 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC2 JCPU1.AC3 JCPU1.AC5 JCPU1.AC6 JCPU1.AC8 JCPU1.AC9 JCPU1.AD7 JCPU1.AE9 JCPU1.AE26 JCPU1.AE27 JCPU1.AE28 JCPU1.AE29 JCPU1.AE30 JCPU1.AE31 JCPU1.AE32 JCPU1.AE33 JCPU1.AE34 JCPU1.AE35 JCPU1.AF2 JCPU1.AF3 JCPU1.AF5 JCPU1.AF6 JCPU1.AG4 JCPU1.AG8 JCPU1.AG9 JCPU1.AH4 JCPU1.AH7 JCPU1.AH16 JCPU1.AH19 JCPU1.AH22 JCPU1.AH25 JCPU1.AH26 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH32 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ1 JCPU1.AJ2 JCPU1.AJ3 JCPU1.AJ4 JCPU1.AJ7 JCPU1.AJ10 JCPU1.AJ13 JCPU1.AJ16 JCPU1.AJ19 JCPU1.AJ22 JCPU1.AJ25 JCPU1.AK4 JCPU1.AK7 JCPU1.AK10 JCPU1.AK13 JCPU1.AK16 JCPU1.AK19 JCPU1.AK22 JCPU1.AK25 JCPU1.AK27 JCPU1.AK30 JCPU1.AK33 JCPU1.AL2 JCPU1.AL4 JCPU1.AL7 JCPU1.AL10 JCPU1.AL13 JCPU1.AL16 JCPU1.AL19 JCPU1.AL22 JCPU1.AL25 JCPU1.AL28 JCPU1.AL31 JCPU1.AL34 JCPU1.AM1 JCPU1.AM2 JCPU1.AM3 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM22 JCPU1.AM25 JCPU1.AM29 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN22 JCPU1.AN25 JCPU1.AN27 JCPU1.AN30 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP22 JCPU1.AP25 JCPU1.AP28 JCPU1.AP31 JCPU1.AP34 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT22 JCPU1.AT25 JCPU1.AT27 JCPU1.AT29 JCPU1.AT32 JCPU1.AT35 JCPU1.B2 JCPU1.B3 JCPU1.B5 JCPU1.B7 JCPU1.B8 JCPU1.B9 JCPU1.B11 JCPU1.B13 JCPU1.B15 JCPU1.B17 JCPU1.B19 JCPU1.B22 JCPU1.C1 JCPU1.C10 JCPU1.C23 JCPU1.C25 JCPU1.C27 JCPU1.C28 JCPU1.C31 JCPU1.C34 JCPU1.D17 JCPU1.D20 JCPU1.D26 JCPU1.D29 JCPU1.D32 JCPU1.D35 JCPU1.E1 JCPU1.E2 JCPU1.E3 JCPU1.E4 JCPU1.E5 JCPU1.E6 JCPU1.E7 JCPU1.E8 JCPU1.E9 JCPU1.E10 JCPU1.E13 JCPU1.E15 JCPU1.E18 JCPU1.E21 JCPU1.E24 JCPU1.E27 JCPU1.E30 JCPU1.F19 JCPU1.F22 JCPU1.F29 JCPU1.F31 JCPU1.F34 JCPU1.G11 JCPU1.G17 JCPU1.G20 JCPU1.G23 JCPU1.G26 JCPU1.G29 JCPU1.G32 JCPU1.G35 JCPU1.H1 JCPU1.H2 JCPU1.H3 JCPU1.H4 JCPU1.H5 JCPU1.H6 JCPU1.H7 JCPU1.H8 JCPU1.H9 JCPU1.H10 JCPU1.H13 JCPU1.H15 JCPU1.H18 JCPU1.H21 JCPU1.H24 JCPU1.H27 JCPU1.H30 JCPU1.H33 JCPU1.J31 JCPU1.J34 JCPU1.K26 JCPU1.K29 JCPU1.K32 JCPU1.K35 JCPU1.L1 JCPU1.L2 JCPU1.L3 JCPU1.L4 JCPU1.L5 JCPU1.L6 JCPU1.L8 JCPU1.L9 JCPU1.L27 JCPU1.L30 JCPU1.L33 JCPU1.M34 JCPU1.N26 JCPU1.N27 JCPU1.N28 JCPU1.N29 JCPU1.N30 JCPU1.N31 JCPU1.N32 JCPU1.N33 JCPU1.N34 JCPU1.N35 JCPU1.P2 JCPU1.P3 JCPU1.P5 JCPU1.P6 JCPU1.P8 JCPU1.P9 JCPU1.T26 JCPU1.T27 JCPU1.T28 JCPU1.T29 JCPU1.T30 JCPU1.T31 JCPU1.T32 JCPU1.T33 JCPU1.T34 JCPU1.T35 JCPU1.U2 JCPU1.U3 JCPU1.U5 JCPU1.U6 JCPU1.U8 JCPU1.U9 JCPU1.W26 JCPU1.W27 JCPU1.W28 JCPU1.W29 JCPU1.W30 JCPU1.W31 JCPU1.W32 JCPU1.W33 JCPU1.W34 JCPU1.W35 JCPU1.Y2 JCPU1.Y3 JCPU1.Y5 JCPU1.Y6 JCPU1.Y8 JCPU1.Y9 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JCRT1.18 JCRT1.19 JDEG2.10 JDEG2.11 JDEG2.12 JDEG2.13 JDEG2.14 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDIMM3.2 JDIMM3.3 JDIMM3.8 JDIMM3.9 JDIMM3.11 JDIMM3.13 JDIMM3.14 JDIMM3.19 JDIMM3.20 JDIMM3.25 JDIMM3.26 JDIMM3.28 JDIMM3.31 JDIMM3.32 JDIMM3.37 JDIMM3.38 JDIMM3.43 JDIMM3.44 JDIMM3.46 JDIMM3.48 JDIMM3.49 JDIMM3.54 JDIMM3.55 JDIMM3.60 JDIMM3.61 JDIMM3.63 JDIMM3.65 JDIMM3.66 JDIMM3.71 JDIMM3.72 JDIMM3.127 JDIMM3.128 JDIMM3.133 JDIMM3.134 JDIMM3.136 JDIMM3.138 JDIMM3.139 JDIMM3.144 JDIMM3.145 JDIMM3.150 JDIMM3.151 JDIMM3.153 JDIMM3.155 JDIMM3.156 JDIMM3.161 JDIMM3.162 JDIMM3.167 JDIMM3.168 JDIMM3.170 JDIMM3.172 JDIMM3.173 JDIMM3.178 JDIMM3.179 JDIMM3.184 JDIMM3.185 JDIMM3.187 JDIMM3.189 JDIMM3.190 JDIMM3.195 JDIMM3.196 JDIMM3.205 JDIMM3.206 JDIMM4.2 JDIMM4.3 JDIMM4.8 JDIMM4.9 JDIMM4.11 JDIMM4.13 JDIMM4.14 JDIMM4.19 JDIMM4.20 JDIMM4.25 JDIMM4.26 JDIMM4.28 JDIMM4.31 JDIMM4.32 JDIMM4.37 JDIMM4.38 JDIMM4.43 JDIMM4.44 JDIMM4.46 JDIMM4.48 JDIMM4.49 JDIMM4.54 JDIMM4.55 JDIMM4.60 JDIMM4.61 JDIMM4.63 JDIMM4.65 JDIMM4.66 JDIMM4.71 JDIMM4.72 JDIMM4.127 JDIMM4.128 JDIMM4.133 JDIMM4.134 JDIMM4.136 JDIMM4.138 JDIMM4.139 JDIMM4.144 JDIMM4.145 JDIMM4.150 JDIMM4.151 JDIMM4.153 JDIMM4.155 JDIMM4.156 JDIMM4.161 JDIMM4.162 JDIMM4.167 JDIMM4.168 JDIMM4.170 JDIMM4.172 JDIMM4.173 JDIMM4.178 JDIMM4.179 JDIMM4.184 JDIMM4.185 JDIMM4.187 JDIMM4.189 JDIMM4.190 JDIMM4.195 JDIMM4.196 JDIMM4.205 JDIMM4.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JDP1.2 JDP1.5 JDP1.8 JDP1.11 JDP1.16 JDP1.19 JDP1.21 JDP1.22 JDP1.23 JDP1.24 JEDP1.8 JEDP1.9 JEDP1.10 JEDP1.11 JEDP1.19 JEDP1.23 JEDP1.25 JEDP1.28 JEDP1.31 JEDP1.34 JEDP1.37 JEDP1.40 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JESA1.4 JESA1.5 JESA1.8 JESA1.11 JESA1.12 JESA1.13 JESA1.14 JESA1.15 JFAN1.3 JFAN1.5 JFAN1.6 JFAN2.3 JFAN2.5 JFAN2.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.1 JIO1.5 JIO1.11 JIO1.12 JIO1.18 JIO1.19 JIO1.24 JIO1.30 JIO1.40 JIO1.41 JIO1.46 JIO1.49 JIO1.55 JIO1.56 JIO1.61 JIO1.62 JIO1.67 JIO1.68 JIO1.74 JIO1.79 JIO1.80 JIO1.86 JIO1.109 JIO1.111 JIO1.112 JIO1.113 JIO1.115 JIO1.117 JIO1.118 JIO1.119 JIO1.121 JIO1.123 JIO1.130 JIO1.132 JIO1.134 JIO1.135 JIO1.136 JIO1.137 JIO1.138 JIO1.139 JIO1.140 JIO1.141 JIO1.142 JKB1.1 JKB1.2 JKB1.5 JKB1.6 JLOM1.14 JLOM1.15 JLVDS1.8 JLVDS1.9 JLVDS1.10 JLVDS1.11 JLVDS1.17 JLVDS1.20 JLVDS1.27 JLVDS1.30 JLVDS1.37 JLVDS1.40 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JLVDS1.45 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JMINI3.54 JMINI4.4 JMINI4.9 JMINI4.15 JMINI4.18 JMINI4.21 JMINI4.26 JMINI4.27 JMINI4.29 JMINI4.34 JMINI4.35 JMINI4.43 JMINI4.50 JMINI4.53 JMINI4.54 JMXM1.19 JMXM1.20 JMXM1.21 JMXM1.22 JMXM1.23 JMXM1.24 JMXM1.25 JMXM1.26 JMXM1.27 JMXM1.28 JMXM1.29 JMXM1.30 JMXM1.31 JMXM1.32 JMXM1.33 JMXM1.34 JMXM1.35 JMXM1.36 JMXM1.47 JMXM1.49 JMXM1.51 JMXM1.53 JMXM1.72 JMXM1.73 JMXM1.82 JMXM1.83 JMXM1.88 JMXM1.89 JMXM1.94 JMXM1.95 JMXM1.100 JMXM1.101 JMXM1.106 JMXM1.107 JMXM1.112 JMXM1.113 JMXM1.118 JMXM1.119 JMXM1.124 JMXM1.125 JMXM1.130 JMXM1.131 JMXM1.136 JMXM1.137 JMXM1.142 JMXM1.143 JMXM1.148 JMXM1.149 JMXM1.154 JMXM1.155 JMXM1.160 JMXM1.161 JMXM1.162 JMXM1.163 JMXM1.168 JMXM1.169 JMXM1.174 JMXM1.175 JMXM1.180 JMXM1.181 JMXM1.187 JMXM1.194 JMXM1.202 JMXM1.203 JMXM1.208 JMXM1.209 JMXM1.214 JMXM1.215 JMXM1.220 JMXM1.221 JMXM1.226 JMXM1.227 JMXM1.232 JMXM1.233 JMXM1.238 JMXM1.239 JMXM1.244 JMXM1.245 JMXM1.250 JMXM1.251 JMXM1.256 JMXM1.272 JMXM1.278 JMXM1.281 JMXM1.284 JMXM1.287 JMXM1.290 JMXM1.293 JMXM1.296 JMXM1.299 JMXM1.305 JMXM1.311 JMXM1.312 JODD1.1 JODD1.4 JODD1.7 JODD1.12 JODD1.13 JODD1.14 JODD1.15 JPB1.5 JPB1.6 JPB1.7 JPB1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.11 JSATA2.13 JSATA2.17 JSATA2.19 JSATA2.23 JSATA2.24 JSIM1.5 JSIM1.9 JSIM1.10 JSPI1.16 JSPI1.17 JSPI1.18 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSH1.1 JUSH1.4 JUSH1.18 JUSH1.19 JUSH1.21 JUSH1.22 JUSH1.23 JUSH1.24 JWL1.1 JWL1.4 JWL1.5 JXDP1.3 JXDP1.6 JXDP1.9 JXDP1.19 JXDP1.25 JXDP1.27 JXDP1.28 JXDP2.1 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 JXDP2.60 ME1.1 PBATT1.6 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC8.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.1 PC18.2 PC19.2 PC20.2 PC21.2 PC30.2 PC31.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC198.2 PC199.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.2 PC208.1 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC299.2 PC301.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC309.2 PC310.2 PC311.2 PC312.2 PC401.2 PC402.2 PC403.2 PC404.2 PC406.2 PC407.2 PC408.2 PC409.2 PC499.2 PC501.2 PC502.2 PC503.2 PC504.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC599.2 PC601.2 PC602.1 PC604.1 PC605.1 PC606.2 PC607.1 PC608.1 PC609.2 PC610.1 PC611.1 PC612.1 PC613.1 PC614.2 PC615.2 PC616.2 PC619.1 PC701.1 PC703.2 PC706.1 PC710.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC718.2 PC721.2 PC722.2 PC723.2 PC724.2 PC725.2 PC726.2 PC727.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC737.2 PC740.1 PC743.2 PC744.2 PC745.2 PC746.2 PC747.2 PC748.2 PC749.2 PC753.2 PC755.2 PC757.2 PC758.2 PC759.2 PC761.2 PC762.2 PC763.2 PC765.2 PC766.2 PC767.2 PC769.2 PC770.2 PC772.2 PC791.1 PC792.1 PC793.1 PC794.1 PC795.1 PC796.1 PC797.1 PC798.1 PC902.2 PC903.2 PC907.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC917.2 PC925.2 PC929.2 PC930.2 PC931.2 PC932.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.1 PC999.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1120.1 PC1121.1 PC1122.1 PC1123.1 PC1124.1 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1161.1 PC1162.1 PC1163.1 PC1164.1 PC1165.1 PC1166.2 PC1167.2 PC1168.2 PC1169.1 PC1170.1 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PD2.1 PD3.1 PD7.2 PJP603.1 PJP902.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.11 PQ3.3 PQ7.3 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.2 PQ104.3 PQ105.3 PQ106.1 PQ106.4 PQ202.1 PQ202.2 PQ202.3 PQ204.1 PQ204.4 PQ205.1 PQ205.4 PQ402.1 PQ402.2 PQ402.3 PQ502.1 PQ502.2 PQ502.3 PQ701.8 PQ702.8 PQ703.8 PQ704.8 PQ705.8 PQ706.8 PQ707.8 PQ708.8 PQ906.1 PQ906.2 PQ906.3 PQ908.1 PQ908.4 PQ909.3 PQ910.3 PQ1005.1 PR12.1 PR18.2 PR19.2 PR22.2 PR26.2 PR103.1 PR104.2 PR106.1 PR107.2 PR112.2 PR215.2 PR217.2 PR220.2 PR224.2 PR225.2 PR305.2 PR306.2 PR312.2 PR313.2 PR403.1 PR406.2 PR408.1 PR503.1 PR506.2 PR515.2 PR601.1 PR604.1 PR609.1 PR705.2 PR714.1 PR733.1 PR750.2 PR916.2 PR940.2 PR941.2 PR942.2 PR944.2 PR1001.2 PR1003.2 PR1018.2 PR1028.2 PU1.2 PU2.4 PU101.15 PU201.1 PU201.3 PU201.14 PU201.21 PU301.11 PU302.11 PU401.11 PU501.11 PU601.19 PU601.20 PU601.21 PU601.25 PU701.4 PU701.9 PU702.41 PU703.4 PU703.9 PU901.19 PU902.4 PU903.3 PU1001.5 PU1001.14 PU1001.23 PU1001.32 PU1001.37 PWRSW1.2 Q13.1 Q13.4 Q19.1 Q19.4 Q20.3 Q22.3 Q23.3 Q29.1 Q29.4 Q36.3 Q45.3 Q47.3 Q48.3 Q50.3 Q52.3 Q55.3 Q59.3 Q60.3 Q61.3 Q65.3 Q66.3 Q67.3 Q68.3 Q69.3 Q70.3 Q71.3 Q72.3 Q73.3 Q87.3 Q88.3 Q110.1 Q110.4 Q294.1 Q294.4 Q297.1 Q297.4 Q300.1 Q300.4 Q301.1 Q301.4 Q303.1 Q303.4 Q304.1 Q304.4 Q305.1 Q305.4 Q306.1 Q306.4 Q310.1 Q310.4 Q311.1 Q311.4 Q312.1 Q312.4 Q313.1 Q313.4 Q318.4 Q322.1 Q322.4 Q326.1 Q336.1 Q336.4 Q338.3 Q339.1 Q339.4 QC1.3 QC5.1 QC5.4 QH2.3 QH6.3 R13.1 R17.1 R51.1 R53.2 R54.2 R55.2 R57.1 R59.1 R60.2 R61.1 R62.1 R63.1 R66.1 R67.1 R69.1 R73.1 R74.1 R75.1 R77.2 R79.2 R81.2 R82.2 R86.2 R87.2 R88.2 R89.2 R90.2 R91.2 R102.1 R103.1 R104.1 R105.1 R106.1 R107.1 R108.1 R109.1 R110.1 R111.1 R112.1 R113.1 R114.1 R222.1 R278.2 R301.2 R305.2 R336.1 R392.2 R402.1 R406.2 R491.1 R492.1 R504.2 R505.2 R514.2 R517.2 R519.1 R557.2 R561.2 R562.2 R659.2 R660.2 R716.2 R717.2 R727.2 R732.2 R733.2 R734.2 R739.2 R747.2 R757.2 R758.2 R767.1 R770.2 R773.1 R775.1 R783.2 R786.2 R789.2 R790.2 R791.2 R793.2 R801.1 R803.2 R804.2 R809.1 R812.1 R813.1 R826.1 R836.2 R843.1 R869.1 R876.1 R879.1 R880.1 R881.1 R882.1 R883.1 R888.2 R889.1 R892.1 R904.2 R908.2 R912.2 R914.2 R919.2 R921.2 R931.2 R935.2 R1128.2 R1137.2 R1138.2 R1191.1 R1207.1 R1582.1 R1611.2 R1613.1 R1617.2 R1618.2 R1619.2 R1620.2 R1625.2 R1627.2 R1628.2 R1629.2 R1630.2 R1631.2 R1632.2 R1638.2 R1970.1 R1971.1 R2160.2 R2186.1 R2187.1 R2200.1 R2201.1 R2202.1 R2203.1 RC19.2 RC23.2 RC44.2 RC45.2 RC46.2 RC47.2 RC48.2 RC50.2 RC52.2 RC53.2 RC56.1 RC57.2 RC58.2 RC61.1 RC62.2 RC71.2 RC72.2 RC77.2 RC79.2 RC80.2 RC81.2 RC86.2 RC87.1 RC88.1 RD12.1 RD13.1 RD19.1 RD20.1 RD28.1 RD29.1 RD37.1 RD38.1 RH31.1 RH32.2 RH39.2 RH46.2 RH47.2 RH48.2 RH49.2 RH59.2 RH74.2 RH75.2 RH76.2 RH77.2 RH78.2 RH79.2 RH91.2 RH112.1 RH126.2 RH129.1 RH131.1 RH132.1 RH133.1 RH134.1 RH141.2 RH151.2 RH172.2 RH174.2 RH183.2 RH270.1 RH271.2 RH273.2 RH274.2 RH278.2 RH282.2 RH333.2 RH342.2 RH344.1 RH353.2 U2.9 U3.3 U4.2 U7.3 U8.3 U9.26 U9.35 U9.38 U9.43 U9.57 U10.3 U11.11 U11.37 U12.1 U12.10 U12.12 U12.14 U12.20 U12.25 U12.27 U12.29 U13.11 U13.37 U14.3 U15.3 U16.3 U17.3 U18.5 U18.6 U18.9 U18.28 U18.31 U18.32 U18.49 U19.10 U19.20 U19.30 U19.41 U20.7 U21.3 U22.3 U22.18 U22.24 U22.31 U22.49 U25.3 U26.3 U26.13 U26.21 U27.3 U31.49 U32.43 U37.1 U37.2 U37.4 U37.8 U37.11 U37.18 U37.25 U39.1 U39.2 U39.4 U39.8 U39.11 U39.18 U39.25 U40.2 U45.1 U45.11 U46.B27 U46.C1 U47.3 U48.1 U48.11 U50.3 U52.4 U53.4 U54.B11 U54.B54 U54.B60 U54.B66 U54.C1 U58.3 U59.1 U59.2 U60.3 U88.5 U88.10 U88.12 U88.13 U88.15 U88.16 U625.10 U625.21 U625.25 U626.10 U626.21 U626.25 U627.3 UC1.3 UC2.3 UC3.3 UC4.3 UH3.3 UH4.AA2 UH4.AA3 UH4.AA17 UH4.AA33 UH4.AA34 UH4.AB4 UH4.AB5 UH4.AB7 UH4.AB11 UH4.AB14 UH4.AB39 UH4.AB43 UH4.AC2 UH4.AC19 UH4.AC21 UH4.AC24 UH4.AC33 UH4.AC34 UH4.AC48 UH4.AD4 UH4.AD8 UH4.AD10 UH4.AD11 UH4.AD12 UH4.AD13 UH4.AD14 UH4.AD16 UH4.AD19 UH4.AD24 UH4.AD26 UH4.AD27 UH4.AD33 UH4.AD34 UH4.AD36 UH4.AD37 UH4.AD38 UH4.AD39 UH4.AD40 UH4.AD42 UH4.AD43 UH4.AD45 UH4.AD46 UH4.AD47 UH4.AE2 UH4.AE3 UH4.AE47 UH4.AE48 UH4.AF4 UH4.AF5 UH4.AF7 UH4.AF8 UH4.AF10 UH4.AF12 UH4.AF16 UH4.AF19 UH4.AF24 UH4.AF26 UH4.AF27 UH4.AF29 UH4.AF31 UH4.AF38 UH4.AF42 UH4.AF46 UH4.AG2 UH4.AG19 UH4.AG31 UH4.AG48 UH4.AH3 UH4.AH7 UH4.AH8 UH4.AH10 UH4.AH11 UH4.AH36 UH4.AH39 UH4.AH40 UH4.AH42 UH4.AH46 UH4.AJ3 UH4.AJ19 UH4.AJ21 UH4.AJ24 UH4.AJ33 UH4.AJ34 UH4.AK3 UH4.AK4 UH4.AK8 UH4.AK10 UH4.AK11 UH4.AK12 UH4.AK37 UH4.AK38 UH4.AK42 UH4.AK46 UH4.AL2 UH4.AL16 UH4.AL17 UH4.AL19 UH4.AL21 UH4.AL23 UH4.AL26 UH4.AL27 UH4.AL31 UH4.AL33 UH4.AL34 UH4.AL48 UH4.AM7 UH4.AM11 UH4.AM14 UH4.AM36 UH4.AM39 UH4.AM43 UH4.AM45 UH4.AM46 UH4.AN2 UH4.AN3 UH4.AN29 UH4.AN31 UH4.AP1 UH4.AP3 UH4.AP4 UH4.AP8 UH4.AP12 UH4.AP13 UH4.AP19 UH4.AP28 UH4.AP30 UH4.AP32 UH4.AP38 UH4.AP42 UH4.AP46 UH4.AR2 UH4.AR48 UH4.AT7 UH4.AT11 UH4.AT13 UH4.AT18 UH4.AT22 UH4.AT26 UH4.AT28 UH4.AT30 UH4.AT32 UH4.AT34 UH4.AT39 UH4.AT42 UH4.AT46 UH4.AU24 UH4.AU30 UH4.AV4 UH4.AV8 UH4.AV11 UH4.AV16 UH4.AV20 UH4.AV24 UH4.AV30 UH4.AV38 UH4.AV43 UH4.AW2 UH4.AW14 UH4.AW18 UH4.AW22 UH4.AW26 UH4.AW28 UH4.AW32 UH4.AW34 UH4.AW36 UH4.AW40 UH4.AW48 UH4.AY4 UH4.AY8 UH4.AY12 UH4.AY22 UH4.AY28 UH4.AY42 UH4.AY46 UH4.B7 UH4.B11 UH4.B15 UH4.B19 UH4.B23 UH4.B27 UH4.B31 UH4.B35 UH4.B39 UH4.B43 UH4.BB4 UH4.BB12 UH4.BB16 UH4.BB20 UH4.BB22 UH4.BB24 UH4.BB28 UH4.BB30 UH4.BB38 UH4.BB46 UH4.BC2 UH4.BC14 UH4.BC16 UH4.BC18 UH4.BC22 UH4.BC26 UH4.BC32 UH4.BC34 UH4.BC36 UH4.BC40 UH4.BC42 UH4.BC48 UH4.BD3 UH4.BD5 UH4.BD46 UH4.BE10 UH4.BE16 UH4.BE22 UH4.BE26 UH4.BE40 UH4.BF8 UH4.BF10 UH4.BF12 UH4.BF16 UH4.BF20 UH4.BF22 UH4.BF24 UH4.BF26 UH4.BF28 UH4.BF30 UH4.BF38 UH4.BF40 UH4.BG8 UH4.BG17 UH4.BG21 UH4.BG22 UH4.BG24 UH4.BG28 UH4.BG29 UH4.BG33 UH4.BG41 UH4.BG44 UH4.BH7 UH4.BH11 UH4.BH15 UH4.BH17 UH4.BH19 UH4.BH27 UH4.BH31 UH4.BH33 UH4.BH35 UH4.BH39 UH4.BH43 UH4.BJ28 UH4.C22 UH4.D3 UH4.D8 UH4.D12 UH4.D16 UH4.D18 UH4.D22 UH4.D24 UH4.D26 UH4.D30 UH4.D32 UH4.D34 UH4.D38 UH4.D42 UH4.E18 UH4.E26 UH4.F3 UH4.F45 UH4.G14 UH4.G18 UH4.G20 UH4.G26 UH4.G28 UH4.G36 UH4.G48 UH4.H5 UH4.H10 UH4.H12 UH4.H16 UH4.H18 UH4.H22 UH4.H24 UH4.H26 UH4.H30 UH4.H32 UH4.H34 UH4.H46 UH4.K7 UH4.K18 UH4.K26 UH4.K39 UH4.K46 UH4.L2 UH4.L18 UH4.L20 UH4.L26 UH4.L28 UH4.L36 UH4.L48 UH4.M4 UH4.M8 UH4.M12 UH4.M14 UH4.M18 UH4.M22 UH4.M24 UH4.M30 UH4.M32 UH4.M34 UH4.M38 UH4.M42 UH4.M46 UH4.N18 UH4.N24 UH4.N47 UH4.P7 UH4.P11 UH4.P16 UH4.P18 UH4.P30 UH4.P40 UH4.P43 UH4.P47 UH4.R2 UH4.R48 UH4.T4 UH4.T8 UH4.T12 UH4.T31 UH4.T33 UH4.T36 UH4.T37 UH4.T42 UH4.T46 UH4.T47 UH4.U47 UH4.V7 UH4.V11 UH4.V17 UH4.V26 UH4.V27 UH4.V29 UH4.V31 UH4.V36 UH4.V39 UH4.V43 UH4.W2 UH4.W17 UH4.W19 UH4.W27 UH4.W34 UH4.W48 UH4.Y4 UH4.Y8 UH4.Y12 UH4.Y38 UH4.Y42 UH4.Y46 Y3.2 Y3.4 YH2.2 YH2.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
GNDA_CHG: PC904.1 PC906.2 PC908.2 PC909.2 PC916.2 PC922.2 PC923.2 PC924.2 PC926.2 PC927.2 PC928.2 PC933.1 PC935.2 PJP902.1 PR914.2 PR925.2 PU901.1 PU901.12 PU901.14 PU901.29
GNDA_VCCSA: PC617.2 PJP603.2 PU601.1
VCC_AXG_SENSE: JCPU1.AK35 PC703.1 PR702.2 PR704.2 RC84.2 RC85.1
VCC_VAL_SNESE: JCPU1.AJ33 RC59.2 RC60.1
VCCP: PC723.1 PR718.1 PU702.26
VCCP_PWRCTRL: PC510.1 PQ503.2 PR514.1 RC89.2
VCCP_PWRCTRL_R: JCPU1.A19 RC89.1
VCCSA_SENSE: JCPU1.H23 PR611.2
VCCSA_VID_0: JCPU1.C22 PR614.2
VCCSA_VID_1: JCPU1.C24 PR613.2
VCCSAPWROK: PR603.1 U50.2
VCCSENSE: PC749.1 PR744.2 PR748.2 RC66.1 RC67.2 RC68.2
VCCSENSE_R: JCPU1.AJ35 RC68.1
VDD_1.5V: PC211.1 PR202.1 PR204.2 PU201.11
VDD_PWRGD: R389.2 U18.18
VDDPWRGOOD: RC4.2 RC5.1 RC7.1 UC1.4
VDDPWRGOOD_R: JCPU1.V8 RC5.2
VSS_AXG_SENSE: JCPU1.AK34 PC706.2 PU702.39 RC85.2 RC86.1
VSS_NCTF_1: UH4.A4
VSS_NCTF_2: UH4.A44
VSS_NCTF_3: UH4.A45
VSS_NCTF_4: UH4.A46
VSS_NCTF_5: UH4.A5
VSS_NCTF_6: UH4.A6
VSS_NCTF_7: UH4.B3
VSS_NCTF_8: UH4.B47
VSS_NCTF_9: UH4.BD1
VSS_NCTF_10: UH4.BD49
VSS_NCTF_11: UH4.BE1
VSS_NCTF_12: UH4.BE49
VSS_NCTF_13: UH4.BF1
VSS_NCTF_14: UH4.BF49
VSS_NCTF_15: UH4.BG2
VSS_NCTF_16: UH4.BG48
VSS_NCTF_17: UH4.BH3
VSS_NCTF_18: UH4.BH47
VSS_NCTF_19: UH4.BJ4
VSS_NCTF_20: UH4.BJ44
VSS_NCTF_21: UH4.BJ45
VSS_NCTF_22: UH4.BJ46
VSS_NCTF_23: UH4.BJ5
VSS_NCTF_24: UH4.BJ6
VSS_NCTF_25: UH4.C2
VSS_NCTF_26: UH4.C48
VSS_NCTF_27: UH4.D1
VSS_NCTF_28: UH4.D49
VSS_NCTF_29: UH4.E1
VSS_NCTF_30: UH4.E49
VSS_NCTF_31: UH4.F1
VSS_NCTF_32: UH4.F49
VSS_VAL_SNESE: JCPU1.AH33 RC60.2 RC61.2
VSSAXG_VAL_SENSE: JCPU1.AH31 RC55.2 RC56.2
VSSIO_SENSE_R: JCPU1.A10 PR510.2 RC72.1
VSSSENSE: PC753.1 PU702.16 RC66.2 RC69.2 RC71.1
VSSSENSE_R: JCPU1.AJ34 RC69.1
3D_ON: Q85.2 U627.4
3301_ACAV_IN_NB: PR1019.1 PU1001.24
3301_DC_IN_SS: PR1010.2 PU1001.34
3301_PWRSRC: PR1029.1 PU1001.15
+A_ENABLE: C770.1 Q58.3 Q306.3 R917.2 R1617.1
+ADDR_XEN: R393.1 U18.3
+AUX_EN: C632.1 Q38.3 Q310.3 R720.2 R1620.1
+BL_PWR_SRC: C249.2 C250.1 C296.1 JEDP1.4 JEDP1.5 JEDP1.6 JEDP1.7 JLVDS1.4 JLVDS1.5 JLVDS1.6 JLVDS1.7 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JCAM1.18 JCAM1.20 Q24.1
+CAP_LDO: C714.1 U46.B46
+CHAGER_SRC: PC902.1 PC903.1 PC912.1 PC913.1 PC914.1 PC915.1 PL901.1 PQ905.5
+CHGR_DC_IN: PR909.1 PU1001.35
+COINCELL: JRTC1.1 PR1.1
+CRT_VCC: C14.1 F5.1 JCRT1.9 R49.1
+DC1_PWR_SRC: PC102.1 PC103.1 PC104.1 PC106.1 PC107.1 PC108.1 PC109.1 PC118.1 PL100.1 PQ101.5 PQ102.5 PU101.16
+DC_IN: PC9.2 PC15.1 PL4.2 PQ5.1 PQ5.2 PQ5.3 PR16.1 PR19.1 PR932.1 PR1011.1
+DC_IN_SS: PC10.1 PC12.1 PC13.1 PC14.1 PD901.2 PD902.3 PQ5.5 PQ901.5 PR18.1 PR1010.1
+DCIN: PC907.1 PD902.1 PR909.2 PU901.22
+DCIN_JACK: PC11.1 PJPDC1.7 PJPDC1.8 PJPDC1.9 PJPDC1.10 PL4.1
+DDR_CHG: Q72.1 R927.2
+DIMM0_1_CA_CPU: JCPU1.D1 QD2.3 RC88.2 RD6.1
+DIMM0_1_VREF_CPU: JCPU1.B4 QD1.3 RC87.2 RD5.1
+DIMM1_VREF_CA: CD15.1 CD16.1 JDIMM1.126 RD7.1
+DIMM1_VREF_DQ: CD1.1 CD6.1 JDIMM1.1 RD1.2 RD2.2
+DIMM2_VREF_CA: CD41.1 CD42.1 JDIMM2.126 RD16.1
+DIMM2_VREF_DQ: CD23.1 CD24.1 JDIMM2.1 RD14.2 RD15.2
+DIMM3_VREF_CA: CD63.1 CD64.1 JDIMM3.126 RD25.1
+DIMM3_VREF_DQ: CD45.1 CD49.1 JDIMM3.1 RD23.2 RD24.2
+DIMM4_VREF_CA: CD85.1 CD86.1 JDIMM4.126 RD34.1
+DIMM4_VREF_DQ: CD67.1 CD68.1 JDIMM4.1 RD32.2 RD33.2
+DOCK_PWR_BAR: C702.1 C703.1 CE6.1 D33.2 D33.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD902.2 PD1001.2 PD1001.3 PQ907.5 PR1001.1 PR1007.1
+DP_VCC: C313.1 C482.1 F3.1 JDP1.20 R184.1
+EDPVDD: C305.1 JEDP1.13 JEDP1.14 JEDP1.15 JEDP1.16 Q12.4 R161.1
+ENAB_3VLAN: C477.1 Q34.3 Q297.3 R564.2 R1638.1
+LCDVDD: C298.1 JLVDS1.13 JLVDS1.14 JLVDS1.15 Q18.4 R413.1
+LCVDVDD_CHG: Q19.6 R413.2
+LOM_VCT: C701.1 JDOCK1.116 JDOCK1.118
+MISC_PWREN: C651.1 Q44.3 Q312.3 R731.2 R1628.1
+MXM_PWR: PJP78.1 PJP79.1 PR25.4 Q186.5 Q186.6 Q186.7 Q186.8
+MXM_PWR_R: PC6.2 PR14.2 R2180.1 U59.4
+MXM_PWR_SRC: C1.1 C2.1 C3.1 C4.1 C776.1 JMXM1.1 JMXM1.2 JMXM1.3 JMXM1.4 JMXM1.5 JMXM1.6 JMXM1.7 JMXM1.8 JMXM1.9 JMXM1.10 JMXM1.11 JMXM1.12 JMXM1.13 JMXM1.14 JMXM1.15 JMXM1.16 JMXM1.17 JMXM1.18 PJP78.2 PJP79.2 PR25.1 R935.1
+MXM_PWR_SRC_A0: R2185.1 R2187.2 U60.7
+MXM_PWR_SRC_A1: R2184.1 R2186.2 U60.8
+MXM_PWR_SRC_R: PC6.1 PR24.2 R2181.1 U59.5
+MXM_SRC_EN#: C774.1 Q87.1 Q186.4 R940.2
+NBDOCK_DC_IN_SS: JDOCK1.41 PR1024.2
+NVRAM_PWREN: C652.1 Q46.3 Q313.3 R737.2 R1629.1
+PCH_V5REF_RUN: CH71.1 DH3.1 RH213.2 UH4.P34
+PCH_V5REF_SUS: CH63.1 DH2.1 RH208.2 UH4.M26
+PCH_VCCDSW: CH57.1 UH4.V12
+PECI_VREF: C737.1 R862.1 U54.B51
+PWR_SRC: C257.2 C258.2 C259.2 C260.1 C297.1 JIO1.101 JIO1.103 JIO1.105 JIO1.107 PC7.1 PC1001.1 PC1002.1 PC1003.1 PD100.1 PD1001.1 PD1002.1 PJP201.1 PJP401.2 PJP501.1 PL1.1 PL100.2 PL710.2 PL901.2 PQ4.3 PQ907.1 PQ907.2 PQ907.3 PQ1004.1 PQ1004.2 PQ1004.3 PR15.1 PR901.4 PR1029.2 Q21.4 R422.1
+PWR_SRC_MXM: PC1.1 PC30.1 PC31.1 PL1.2 Q186.1 Q186.2 Q186.3 R940.1
+PWR_SRC_S: PC8.1 PQ4.1 R158.1 R269.1 R275.1 R412.1 R499.1 R515.1 R564.1 R720.1 R722.1 R731.1 R737.1 R905.1 R906.1 R911.1 R917.1 R920.1 R930.1 RC73.1 RH357.2
+RSVD_VCC3P3_1: R553.2 U31.1
+RSVD_VCC3P3_2: R554.2 U31.2
+RTC_CELL: C287.1 C336.1 CH88.1 CH89.1 CH90.1 PC2.1 PD1.1 R390.2 R810.1 R815.1 R819.1 R870.1 R1156.2 RH11.1 RH22.1 RH23.1 RH38.1 RH127.2 U10.5 U18.21 UH4.A22
+RTC_CELL_VBAT: C745.1 R815.2 U54.B64
+SDC_IN: PC901.1 PD901.1 PQ901.1 PQ901.2 PQ901.3 PR901.1 PR913.2 PR1015.1
+SIM_PWR: C616.1 JMINI1.8 JSIM1.1 U40.5
+SUS_ENABLE: C767.1 Q54.3 Q303.3 R911.2 R1618.1
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C484.1 T156.9
+TRM_CT4: C486.1 T156.10
+USB1_REPEATER_VDD: C450.1 C453.1 PJP34.1 Q90.1 R12.1 R15.1 R16.1 R18.1 R21.1 R22.1 R23.1 R24.1 R25.1 R94.1 U625.1 U625.13
+USB2_REPEATER_VDD: C451.1 C455.1 PJP35.1 Q91.1 R26.1 R27.1 R28.1 R29.1 R30.1 R31.1 R32.1 R33.1 R34.1 R95.1 U626.1 U626.13
+V_DDR_REF: PC210.1 PU201.4 RD2.1 RD7.2 RD15.1 RD16.2 RD24.1 RD25.2 RD33.1 RD34.2
+V_DDR_REFA_M3: QD1.1 RD1.1 RD5.2 RD14.1
+V_DDR_REFB_M3: QD2.1 RD6.2 RD23.1 RD32.1
+V_DDR_SMREF: QC4.1 RC74.1 RC78.2 RC80.1
+V_SM_VREF_CNT: JCPU1.AL1 QC4.3 RC74.2 RC75.2 RC81.1
+VCHGR: PC929.1 PC930.1 PC931.1 PC932.1 PQ1002.5 PQ1002.6 PQ1002.7 PQ1002.8 PR923.1 PR926.2
+VCHGR_B: PC910.2 PC919.2 PL902.2 PQ905.1 PQ905.2 PQ905.3 PQ906.5 PR919.1 PR929.2
+VCHGR_L: PL902.1 PR923.4
+VDISPLAY_VCC: C337.1 C338.1 F4.1 JHDMI1.18 R45.1
+VR_CAP: C740.1 U54.B12
+WWAN_PWREN: C644.1 Q40.3 Q311.3 R722.2 R1625.1
A_ON_3.3V#: Q60.2 Q306.5 Q306.6 R918.2
A_PRE0: R42.2 R88.1 U26.9
A_PRE1: R40.2 R89.1 U26.19
AC_PRESENT: R835.1 U54.A54 UH4.H20
ACAV_DOCK_SRC#: JDOCK1.42 PR1013.2 PR1017.1
ACAV_IN: PQ910.2 PR911.2 PR912.2 PR915.1 PR916.1 PR1021.1 U17.1 U18.27 U54.B1
ACAV_IN_NB: PR938.2 PR1019.2 U47.1 U54.A15
ACAVDK_SRC: PR1017.2 PU1001.4
ACAVIN: PR1021.2 PU1001.8
ALERT#: PR725.2 PR743.1 PU702.6
ALW_ON_3.3V#: Q66.2 Q305.5 Q305.6 QH6.2 R907.2
ALW_PWRGD_3V_5V: PR114.1 PU101.23 U54.B15
ALWON: PR115.1 U54.A60
AUD_HP_NB_SENSE: JIO1.39 U46.A41
AUD_NB_MUTE#: JIO1.43 U46.A39
AUX_EN_WOWL: Q310.2 R717.1 U46.B67
AUX_EN_WOWL#: Q310.5 Q310.6 R715.2
AUX_MODE_EN: R13.2 U46.A45
B_PRE0: R46.2 R87.1 U26.8
B_PRE1: R39.2 R82.1 U26.17
BAT1_LED#: JIO1.104 U46.B64
BAT2_LED#: JIO1.102 U46.A9
BAY_SMBCLK: R856.1 U54.A7
BAY_SMBDAT: R854.1 U54.B7
BBS_BIT0_R: QH1.1 RH26.1 RH52.1 UH4.P1
BBS_BIT1: RH342.1 UH4.D47
BC_CLK_ECE1117: JKB1.3 JKB1.4 U54.A20
BC_CLK_ECE5048: U46.A30 U54.A43
BC_CLK_EMC4002: U18.11 U54.A12
BC_DAT_ECE1117: JKB1.7 JKB1.8 R817.2 U54.B21
BC_DAT_ECE5048: R814.2 U46.B31 U54.B45
BC_DAT_EMC4002: R821.1 U18.10 U54.B13
BC_INT#_ECE1117: JKB1.9 JKB1.10 U54.A19
BC_INT#_ECE5048: U46.A29 U54.A42
BC_INT#_EMC4002: R385.1 U18.12 U54.A13
BCM5882_ALERT#: JUSH1.7 U46.B62
BEEP: JIO1.45 U54.A16
BIA_PWM_EC: D71.2 R431.2 U54.B25
BIA_PWM_LVDS: D66.1 D68.1 D71.1 R207.1 R208.2 R431.1 R1137.1
BIA_PWM_PCH: D66.2 UH4.P45
BLK_MOSFET_GC: PR1006.2 PU1001.30
BLKNG_MOSFET_GC: PR1009.2 PU1001.20
BLUE_CRT: C22.1 L3.1 R55.1 U19.31
BLUE_CRT_L: C13.1 D10.2 JCRT1.3 L3.2
BLUE_DOCK: JDOCK1.45 U19.22
BOARD_ID: C744.1 R875.2 U54.B10
BOOT: PR917.1 PU901.25
BOOT1: PR755.2 PU702.20
BOOT1G: PR775.2 PU702.31
BOOT2: PR738.2 PU702.30
BOOT2G: PR764.2 PU703.2
BOOT3: PR711.2 PU701.2
BOOT_1.5V: PR201.2 PU201.18
BOOT_D: PC910.1 PD903.1 PR917.2
BREATH_LED#: JDOCK1.98 Q84.1 R955.1 U46.B39
BREATH_LED#_Q: JIO1.98 R955.2
BREATH_WHITE_LED: JPB1.4 R956.2
BST1_3V: PC100.2 PR108.1
BST1_5V: PC110.1 PR109.2
BST_3V: PR108.2 PU101.9
BST_5V: PR109.1 PU101.22
BST_+V1.05S_VCCPP: PR502.1 PU501.10
BST_+V1.05SP: PR402.1 PU401.10
BT_ACTIVE: JBT1.6 Q318.5
BT_COEX_STATUS2: JBT1.4 JUSH1.11 R1133.2
BT_LED: JIO1.92 R941.2
BT_LED#: JMINI2.46 R708.1
BT_LED#_R: Q318.1 Q318.3 R708.2 R938.2
BT_PRI_STATUS: JBT1.5 JUSH1.12 R1134.2
BT_RADIO_DIS#: D28.1 D30.1 R691.1 R693.2 R694.1 U46.A13
BT_RADIO_DIS#_CON: C754.1 D28.2 JBT1.7 R694.2
BT_RADIO_DIS#_R: D30.2 JMINI2.51 R691.2
CAM_MIC_CBL_DET#: JCAM1.16 RH331.2 UH4.C42
CARD_SMBCLK: JIO1.48 U54.A49
CARD_SMBDAT: JIO1.50 U54.B52
CARDCLK_REQ#: JIO1.32 RH87.2 UH4.V10
CCD_OFF: Q24.2 U46.B43
CD3301_DCIN: PC1006.1 PR1011.2 PU1001.1
CD3301_SDC_IN: PR1015.2 PU1001.6
CD_PBATT_OFF: PR1016.1 PU1001.26
CEXT: C86.1 U9.1
CFD_PWRBTN#_XDP: JXDP1.11 RC9.2
CFG0: JCPU1.AK28 RC10.1
CFG1: JCPU1.AK29 T60.1(TP-1)
CFG2: JCPU1.AL26 RC52.1
CFG3: JCPU1.AL27 T55.1(TP-1)
CFG4: JCPU1.AK26 RC53.1
CFG5: JCPU1.AL29 RC57.1
CFG6: JCPU1.AL30 RC58.1
CFG7: JCPU1.AM31 RC62.1
CFG8: JCPU1.AM32 T64.1(TP-1)
CFG9: JCPU1.AM30 T68.1(TP-1)
CFG10: JCPU1.AM28 T69.1(TP-1)
CFG11: JCPU1.AM26 T70.1(TP-1)
CFG12: JCPU1.AN28 T7.1(TP-1)
CFG13: JCPU1.AN31 T9.1(TP-1)
CFG14: JCPU1.AN26 T11.1(TP-1)
CFG15: JCPU1.AM27 T13.1(TP-1)
CFG16: JCPU1.AK31 T71.1(TP-1)
CFG17: JCPU1.AN29 T72.1(TP-1)
CHARGER_SMBCLK: PU901.10 R828.2 U54.B50
CHARGER_SMBDAT: PU901.9 R827.2 U54.A47
CHG_LGATE: PC999.1 PQ906.4 PU901.20
CHG_SNUB: PC925.1 PR929.1
CHG_UGATE: PC919.1 PQ905.4 PU901.24
CLK_80H: RH314.2 UH4.H47
CLK_BCLK_ITP: RH281.1 UH4.AK13
CLK_BCLK_ITP#: RH280.1 UH4.AK14
