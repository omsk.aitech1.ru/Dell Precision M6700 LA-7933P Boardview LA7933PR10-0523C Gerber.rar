# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NUM_LED: length 273.3
  TOP w0.102: v1(34.78,19.27) 34.9,19.15 JIO1.90
  IN1 w0.109: v1(171.65,15.13) 169.2,12.68 159.14,12.68 155.93,15.88 152.6,15.88 150.3,13.58 128.08,13.58 127.58,14.07 119.46,14.07 117.43,16.11 114.2,16.11 111.53,13.44 110.21,13.44 109.22,12.45 108.63,12.45 107.51,11.33 106.39,11.33 104.35,9.28 37.57,9.28 31.77,15.08 31.77,19.03 32.05,19.3 34.75,19.3 v1(34.78,19.27)
  IN3 w0.127: v1(171.65,15.13) 171.65,19.73 166.57,24.81 166.57,34.61 167.2,35.24 167.2,40.56 174.64,47.99 180.4,47.99 182.32,49.91 187.57,49.91 188.17,50.51 190.95,50.51 194.1,53.66 201.38,53.66 209.02,61.29 219.4,61.29 221.42,59.27 223.85,59.27 224.01,59.44 225.99,59.44 226.22,59.21 230.91,59.21 232.63,57.48 242.14,57.48 v1(242.39,57.73)
  BOTTOM w0.102: R942.2 241.72,59.03 v2(242.39,58.36) v1(242.39,57.73)
NUM_LED#: length 3.5
  BOTTOM w0.102: U46.A2 240.08,65.84 v2(241,64.91) Q80.2
NVRAM_PWR_EN: length 313.7
  TOP w0.102: v2(17.25,154.67) 17.55,154.67 v1(17.75,154.47) 17.98,154.24 R739.1 18.48,154.19 18.48,152.73 18.21,152.46 Q313.2
  IN2 w0.127: v1(232.92,75.1) 232.92,75.11 233.48,75.67 233.62,75.67 233.96,76.01 233.96,79.64 231.47,82.13 231.47,82.41 230.61,83.27 230.59,83.27 230.59,83.29 230.47,83.41 230.47,83.71 230.08,84.09 229.59,84.09 224.48,89.2 224.48,89.39 222.66,91.21 221.63,91.21 219.43,93.41 210.89,93.41 208.15,96.16 208.15,101.24 206.3,103.09 206.3,118.99 205.37,119.91 205.37,130.87 205.67,131.17 205.67,151.62 201.52,155.78 199.87,155.78 197.28,158.37 191.6,158.37 190.27,159.7 184.24,159.7 183.14,158.6 179.8,158.6 179.29,159.11 175.74,159.11 175.07,159.78 171.21,159.78 171.14,159.84 169.72,159.84 169.61,159.73 167.29,159.73 165.19,161.84 159.4,161.84 152.18,154.61 148.82,154.61 148.6,154.83 147.1,154.83 146.2,155.73 144.56,155.73 144.05,156.24 136.64,156.24 135.92,155.52 135.92,153.5 135.42,153 130.49,153 128.54,151.04 117.41,151.04 116.55,151.91 97.09,151.91 96.71,151.52 82.37,151.52 77.34,156.55 77.34,159.16 76.25,160.25 76.25,161.72 76.4,161.87 76.4,163.12 76.11,163.41 56.96,163.41 55.43,161.89 48.83,161.89 46.7,159.75 45.46,159.75 44.13,161.09 39.64,161.09 36.17,157.62 30.72,157.62 26.71,153.61 19.91,153.61 19.14,154.38 17.84,154.38 v1(17.75,154.47)
  BOTTOM w0.102: U46.B32 232.81,75.2 v1(232.92,75.1)
NVRAM_PWR_EN#: length 2.6
  TOP w0.102: R738.2 20.71,152.46 Q313.5 19.51,152.46 19.37,152.6 19.37,153.02 19.46,153.11 Q313.6
NVRCLK_REQ#: length 94.9
  TOP w0.102: v1(22.4,109.42) 22.4,109.49 UH4.K12
  IN1 w0.102: v1(22.4,109.42) 22.4,109.33 22.07,109 18.52,109 17.64,109.88 17.29,109.88 17.28,109.89 17.02,109.89
  IN1 w0.109: v1(7.66,136.28) 7.66,136.08 5.14,133.57 5.14,128.11 5.92,127.33 5.92,126.25 5.15,125.49 5.15,107.94 5.21,107.89 5.21,107.43 6.55,106.08 9.37,106.08 10.91,107.63 12.7,107.63 14.11,109.04 14.11,109.58 14.67,110.14 16.27,110.14 16.36,110.05 16.37,110.05 16.53,109.89 17.02,109.89
  IN3 w0.127: v1(18.9,147.32) 18.9,146.24 17.61,144.96 16.74,144.96 16.42,144.64 16.42,140.92 v1(14.39,138.89)
  BOTTOM w0.102: v1(7.66,136.28) 8.14,136.77 12.27,136.77 v2(13.51,138) 14.39,138.88 v1(14.39,138.89) ; v1(22.4,109.42) 22.4,109.09 22.13,108.83 21.45,108.83 21.37,108.75 21.37,108.18 21.14,107.95 19.29,107.95 18.77,108.47 18.05,108.47 17.55,108.97 15.96,108.97 15.19,109.74 14.76,109.74 14.3,109.28 RH106.1 ; JMINI4.7 12.04,153.38 14.35,151.07 16.25,151.07 18.9,148.43 v1(18.9,147.32)
P1_SNUB: length 3.4
  BOTTOM w0.102: v2(41.76,63.68) PC757.1
  BOTTOM w0.508: PC757.1 42.22,64.81 43.16,63.87 PR756.2
P1_SW: length 27.7
  TOP w0.254: PR761.2 28.29,65.42 28.62,65.09 30.96,65.09 v1(31,65.05) ; PL703.2 v1(47.73,66.41)
  IN4 w0.254: v1(47.73,66.41) 47.65,66.49 46.58,66.49 44.96,64.86 35.25,64.86 34.96,65.15 31.1,65.15 v1(31,65.05)
  BOTTOM w0.127: v2(43.66,68.36) PR756.1
  BOTTOM w0.254: v1(31,65.05) 30.97,65.05 30.35,65.67 PR758.2
  BOTTOM w0.508: v1(43.15,65.9) 43.66,66.41 PR756.1
P2_SNUB: length 3.8
  BOTTOM w0.102: PR739.2 v2(45.18,74.92)
  BOTTOM w0.508: PC737.1 42.19,75.47 42.75,74.92 PR739.2
P2_SW: length 31.1
  TOP w0.254: v1(30.91,70.21) 30.91,69.55 30.14,68.77 PR746.2 ; PL702.2 v1(47.73,73.52)
  IN4 w0.254: v1(30.91,70.21) 30.41,70.7 30.41,71.81 30.66,72.05 31.18,72.05 32.29,70.93 46.96,70.93 47.98,71.95 47.98,73.26 v1(47.73,73.52)
  BOTTOM w0.127: PR739.1 v2(45.24,77.96)
  BOTTOM w0.254: PR741.2 31.2,69.56 30.91,69.85 v1(30.91,70.21)
  BOTTOM w0.508: PR739.1 43.53,77.58 v1(42.9,76.95)
P3_SNUB: length 3.9
  BOTTOM w0.102: PR721.2 40.61,56.13 v2(40.99,56.52)
  BOTTOM w0.508: PC721.1 40.11,53.43 40.61,53.94 PR721.2
P3_SW: length 47.6
  TOP w0.254: PR724.2 24.22,65.53 25.83,63.92 v1(30.24,63.92) ; PL701.2 v1(47.73,59.29)
  IN4 w0.254: v1(47.73,59.29) 47.73,59.75 47.5,59.98 46.68,59.98 46.2,59.5 46.2,56.07 45.44,55.31 36.55,55.31 35.81,54.57 34.24,54.57 33.39,55.42 33.39,59.23 31.48,61.14 31.48,63.42 30.99,63.92 v1(30.24,63.92)
  BOTTOM w0.254: v1(30.24,63.92) 28.27,63.92 v2(27.63,64.55) 27.02,65.16 27.02,65.39 PR716.2
  BOTTOM w0.508: PR721.1 43.66,55.82 v1(44.42,56.58)
P33ALW: length 4.3
  TOP w0.102: PR1025.1 182,76.44 v2(182.54,76.98)
  TOP w0.254: PU1001.18 180.39,74.18 181.33,75.12 181.33,75.34 PR1025.1
P33ALW2: length 2.9
  TOP w0.254: PR1022.2 v2(178.87,67.9) PU1001.9
P50ALW: length 2.9
  TOP w0.254: PU1001.27 174.87,75.78 v2(174.27,76.38) PR1012.1
PANEL_BKEN_EC: length 189.3
  TOP w0.102: v1(230.38,77.74) 230.87,78.23 230.87,78.64 231.06,78.83 233.12,78.83 v1(233.34,79.05) ; v1(85.76,136.51) 85.76,137.92 85.44,138.24 D69.2
  IN2 w0.127: v1(230.38,77.74) 229.38,77.74 228.43,78.69 225.75,78.69 222.35,82.08 218.17,82.08 215.57,84.68 215.57,85.67 215.31,85.93 208.33,85.93 206.86,87.39 201.77,87.39 201,88.16 197.92,88.16 196.34,89.74 196.34,90.27 196.09,90.53 196.09,92.24 191.12,97.2 191.12,98.28 189.98,99.42 189.98,103.77 185.94,107.8 185.94,108.52 184.1,110.36 184.1,114.44 183,115.53 180.18,115.53 178.08,117.63 178.08,120.96 169.43,129.6 161.26,129.6 159.61,131.26 155.83,131.26 151.91,135.17 132.98,135.17 131.24,133.43 114.8,133.43 112.57,135.66 109.31,135.66 108.84,135.19 103.55,135.19 102.73,136.02 85.94,136.02 85.76,136.2 v1(85.76,136.51)
  BOTTOM w0.102: v1(233.34,79.05) 234.08,78.3 U46.A35 ; v1(85.76,136.51) v2(85.76,137.22)
PANEL_BKEN_PCH: length 107.4
  TOP w0.102: v1(85.84,116.97) 85.84,118.03 88.29,120.49 88.29,121.51 87.1,122.71 v2(87.1,124.47) 87.1,129.34 86.43,130 86.43,131.18 85.32,132.29 85.32,135.56 84.97,135.91 D67.2 ; v1(20.62,130.18) 21.41,129.39 21.41,128.47 21.58,128.3 21.58,128.02 21.43,127.87 21.43,127.57 21.75,127.25 UH4.J47
  IN2 w0.127: v1(20.62,130.18) 20.76,130.18 21.26,130.67 22.39,130.67 22.52,130.54 23.43,130.54 24.11,131.22 29.01,131.22 30.12,132.33 38.66,132.33 39.1,132.78 46.05,132.78 48.11,134.84 55.42,134.84 56.22,135.64 61.52,135.64 61.62,135.53 63.32,135.53 63.66,135.19 63.66,134.76 64.46,133.96 65.6,133.96 66.17,133.39 67.22,133.39 67.66,132.94 67.66,132.14 69.81,130 69.81,121.38 74.92,116.27 85.14,116.27 v1(85.84,116.97)
PBAT_PRES#: length 99
  TOP w0.102: PR2.2 202.54,8.51 201.74,9.31 v2(201.74,10.35)
  TOP w0.254: PR4.2 PR2.2 202.56,8.5 203.45,8.5 PD5.1 v1(204.06,10.22)
  IN1 w0.109: v1(235.44,75.77) 235.45,75.76 235.56,75.76 235.85,75.46 235.85,70.08 235.3,69.53 235.3,67.72 234.26,66.68 232.99,66.68 232.27,65.96 232.27,63.5 231.57,62.8 231.57,57.18 230.96,56.57 v1(228.76,56.57)
  IN2 w0.127: v1(228.76,56.57) 228.26,56.06 224.83,56.06 223.87,55.11 209.64,55.11 209.05,54.52 209.05,14.45 204.82,10.22 v1(204.06,10.22)
  BOTTOM w0.102: U46.B40 235.33,76.38 235.43,76.28 235.43,75.78 v1(235.44,75.77)
PBAT_SMBCLK: length 185.7
  TOP w0.102: v1(180.55,88.96) 181.24,89.65 181.24,96.51 180.92,96.83 180.92,102.13 180.97,102.18 180.97,104.23 181.63,104.89 181.63,111.41 178.13,114.91 178.13,129.5 178.7,130.07 178.7,132.69 177.7,133.69 177.7,135.05 v1(177.6,135.15) ; PR3.2 v1(193.14,7.4) ; v1(166.55,153.37) 166.55,153.84 R820.2 167.16,154.1 167.16,153.15 166.97,152.97 U54.A56
  IN1 w0.109: v1(177.6,135.15) 177.6,135.14 176.88,135.85 176.88,136.28 177.62,137.02 177.62,139.75 176.88,140.49 176.88,142.6 176.39,143.09 176.39,145.12 175.71,145.8 175.71,146.31 173.1,148.91 172.46,148.91 171.66,149.71 169.64,149.71 169.38,149.97 169.38,151.4 169.08,151.7 167.12,151.7 166.57,152.25 166.57,153.34 v1(166.55,153.37) ; v1(180.69,16.7) 180.24,17.16 176.24,17.16 167.02,26.38 167.02,39.19 178.85,51.03 178.85,58.42 178.13,59.14 178.13,61.15 180.45,63.48 180.45,67.12 182.17,68.83 182.17,74.33 180.94,75.57 180.94,82.83 179.5,84.27 179.5,87.91 v1(180.55,88.96)
  BOTTOM w0.102: v1(193.14,7.4) 187.08,7.4 182.55,11.93 v2(182.55,12.38) 182.55,15.1 180.95,16.7 v1(180.69,16.7)
PBAT_SMBDAT: length 199.7
  TOP w0.102: v1(166.99,150.32) 167.22,150.55 U54.B59 ; v1(165.26,135.73) 165.26,133.08 164.15,131.97 164.15,109.02 162.62,107.49 162.62,101.71 161.42,100.51 161.42,92.56 163.83,90.15 171.19,90.15 173.61,87.73 173.61,87.03 177.19,83.45 178.75,83.45 186.92,75.29 186.92,71.08 v1(187.56,70.43) ; PR5.2 v1(197.46,8.19)
  IN1 w0.109: v1(165.26,135.73) 165.68,136.14 165.68,138.76 166.97,140.04 166.97,142.07 167.19,142.3 167.19,144.58 167.51,144.89 167.51,148.92 166.99,149.44 v1(166.99,150.32) ; v1(180.69,17.34) 180.57,17.46 176.26,17.46 168.18,25.54 168.18,31.21 167.49,31.91 167.49,39.27 179.09,50.88 179.09,58.5 178.37,59.23 178.37,61.06 180.68,63.38 180.68,65.98 181.51,66.8 v1(181.51,67.41)
  IN4 w0.109: v1(187.56,70.43) 184.54,67.41 v1(181.51,67.41)
  BOTTOM w0.102: v1(180.69,17.34) 180.82,17.34 182.94,15.22 182.94,11.91 187.09,7.76 192.33,7.76 192.76,8.19 v2(194.46,8.19) v1(197.46,8.19) ; v1(166.99,150.32) 167.17,150.5 167.17,153.43 166.98,153.62 R818.2
PBATT+: length 94.4
  TOP w0.508: v1(159.64,15.09) 159.64,14.8 160.77,13.67 172.58,13.67 173.75,14.83 173.75,16.19 175.27,17.72 179.55,17.72 179.93,18.1 180.95,18.1 181.2,17.84 181.84,17.84 ; PR1008.2 v1(170.15,74.23)
  IN1 w0.508: v1(159.64,15.09) 159.66,15.06 159.97,15.06 160.82,15.91 160.82,22.39 159.87,23.34 159.87,26.99 160.87,28 160.87,42.57 162.62,44.32 162.62,45.42 163.56,46.36 163.94,46.36 164.68,47.09 164.68,48.35 167.08,50.75 170.1,50.75 171.97,52.62 171.97,62.23 171.33,62.87 171.33,62.88 170.84,63.38 170.84,63.41 170.79,63.46 170.79,73.6 v1(170.15,74.23)
  vias: v2(182.65,14.2)
PBATT+_C:
  vias: v2(190.61,9.96)
PBATT_IN_SS:
  vias: v1(192.76,13.91) v1(192.76,13.15) v1(192.76,12.38) v1(192.76,11.62) v1(193.52,13.91) v1(193.52,13.15) v1(193.52,12.38) v1(193.52,11.62) v1(194.28,13.91) v1(194.28,13.15) v1(194.28,12.38) v1(194.28,11.62) v1(195.05,13.91) v1(195.05,13.15) v1(195.05,12.38) v1(195.05,11.62) v2(189.2,12.14)
PCH_ALW_ON: length 253.7
  TOP w0.102: R880.2 165.71,139.42 v1(166.04,139.75) 165.97,139.82 U54.A23
  TOP w0.254: PR23.1 132.4,126.04 130.02,128.41 130.02,131.88 128.13,133.77 128.13,138.56 v1(128.27,138.7)
  IN2 w0.127: v1(166.04,139.75) 164.29,139.75 162.47,141.57 157.78,141.57 157.44,141.91 149.99,141.91 v1(149.06,140.98) ; v1(128.27,138.7) 133.26,138.7 134.31,139.75 v1(145.13,139.75) ; v1(150.14,155.07) 147.32,155.07 146.43,155.96 144.71,155.96 144.17,156.5 136.58,156.5 135.69,155.61 135.69,153.7 135.22,153.23 130.11,153.23 128.15,151.27 117.55,151.27 116.62,152.2 96.98,152.2 96.56,151.78 82.45,151.78 77.57,156.66 77.57,159.26 76.48,160.35 76.48,161.56 76.63,161.71 76.63,163.22 76.2,163.65 56.83,163.65 55.29,162.12 48.74,162.12 46.6,159.98 45.56,159.98 44.22,161.32 39.46,161.32 36.08,157.94 30.49,157.94 29.34,156.78 18.82,156.78 v1(18.18,156.15)
  IN4 w0.109: v1(18.18,156.15) 17.71,156.62 16.79,156.62 16.2,156.03 16.2,154.27 17.56,152.91 17.56,150.38 19.66,148.29 19.66,142.51 18.16,141.01 v1(18.16,140.4)
  BOTTOM w0.102: v1(18.16,140.4) v2(17.56,139.8) 15.52,137.76 15.52,135.8 15.11,135.4 15.11,134.37 14.51,133.77 14.51,133.53 14.07,133.08 Q305.2 ; v1(150.14,155.07) 148.28,153.21 148.28,151.6 147.66,150.98 147.66,144.58 149.06,143.18 v1(149.06,140.98) 147.83,139.75 v1(145.13,139.75)
PCH_AZ_BITCLK: length 12.7
  TOP w0.102: v1(23.53,121.32) 23.6,121.26 23.6,120.26 23.72,120.13 24.54,120.13 24.65,120.24 24.65,120.39 24.54,120.5 24.46,120.5 24.33,120.63 24.33,120.9 24.22,121.02 24.06,121.02 23.95,120.91 UH4.N34
  BOTTOM w0.102: RH25.2 18.76,120.21 18.63,120.08 18.63,119.88 18.76,119.75 19.52,119.75 19.65,119.88 19.65,120.23 19.8,120.38 19.95,120.38 20.1,120.23 20.1,119.91 20.23,119.79 20.47,119.79 20.6,119.91 v2(20.6,120.09) 20.6,120.23 20.72,120.36 21.06,120.36 21.44,120.74 21.7,120.74 21.83,120.87 22.29,120.87 22.43,120.73 23.1,120.73 23.21,120.84 23.21,120.99 23.09,121.12 22.93,121.12 22.81,121.25 22.81,121.56 22.93,121.69 23.4,121.69 23.53,121.56 v1(23.53,121.32)
PCH_AZ_CODEC_BITCLK: length 121.7
  TOP w0.127: CH101.1 11.92,126.32 11.92,125.81 12.04,125.69 v1(12.04,125.63) ; JIO1.3 30.09,44.95 29.93,44.79 27.57,44.79 v1(27.41,44.96)
  IN3 w0.127: v1(27.41,44.96) 27.33,44.96 26.48,45.81 26.48,56.24 23.54,59.17 12.81,59.17 12.48,59.5 11.57,59.5 3.63,67.44 3.63,75.64 3.95,75.96 3.95,84.35 2.89,85.41 2.89,101.28 3.53,101.92 3.53,102.68 2.89,103.32 2.89,108.27 3.91,109.28 3.91,119.35 5.62,121.06 5.62,121.48 6.25,122.1 8.24,122.1 9.46,123.32 10.33,123.32 11.47,124.46 11.47,125.34 11.75,125.63 12.03,125.63 v1(12.04,125.63) 12.22,125.45 12.22,125.33 12.48,125.07 13,125.07 13.37,124.7 13.37,122.28 13.05,121.96 12.4,121.96 v1(12,121.55)
  BOTTOM w0.102: 16.36,120.7 17.58,120.7 18.07,120.21 RH25.1
  BOTTOM w0.127: v1(12,121.55) 12.13,121.43 12.13,121.23 12.66,120.7 12.86,120.7 13.35,120.22 v2(13.64,120.22) 15.29,120.22 15.77,120.7 16.36,120.7
PCH_AZ_CODEC_RST#: length 106.6
  TOP w0.102: JIO1.15 29.85,41.35 v3(29.55,41.05)
  IN3 w0.127: v3(29.55,41.05) 29.55,41.31 28.52,42.34 28.52,45.24 27.53,46.23 27.53,56.71 24.05,60.19 13.31,60.19 12.98,60.52 12,60.52 5.24,67.27 5.24,76.07 5.05,76.26 5.05,84.8 3.91,85.94 3.91,92.16 4.46,92.71 4.46,97.89 4.67,98.11 4.67,105.88 5.05,106.26 5.05,118.39 7.15,120.49 11.76,120.49 12.63,121.36 v1(12.63,121.48)
  BOTTOM w0.127: v1(12.63,121.48) 12.63,121.5 12.74,121.6 RH41.1
PCH_AZ_CODEC_SDIN0: length 108.1
  TOP w0.102: v1(19.74,121.24) 19.74,121.23 20.07,120.91 UH4.E34 ; v3(29.54,43.75) JIO1.7
  IN3 w0.127: v1(16.1,120.21) 15.87,120.44 14.69,120.44 14.34,120.08 14.34,118.38 13.26,117.3 13.26,112.57 12.79,112.1 12.11,112.1 12.01,112 10.97,112 10.17,111.2 10.17,110.41 9.56,109.8 8.8,109.8 7.86,108.86 7.86,106.22 7.91,106.17 7.91,104.16 7.06,103.3 6.86,103.3 5.69,102.13 5.69,94.88 6.07,94.5 6.07,92.76 4.93,91.62 4.93,86.68 6.07,85.54 6.07,76.77 6.26,76.58 6.26,67.72 12.38,61.6 13.42,61.6 13.82,61.2 24.56,61.2 28.55,57.21 28.55,46.65 30.07,45.13 30.07,44.28 v3(29.54,43.75)
  IN4 w0.109: v1(19.74,121.24) 19.74,121 19.44,120.7 16.36,120.7 16.1,120.44 16.1,120.21 v1(16.1,120.21)
PCH_AZ_CODEC_SDOUT: length 110.5
  TOP w0.102: v1(27.95,43.42) 27.95,43.09 28.17,42.88 v2(28.42,42.88) 28.71,42.88 28.99,43.15 JIO1.9 ; v1(12.67,123.7) 12.86,123.51 RH29.1
  IN3 w0.127: v1(12.67,123.7) 12.67,123.23 12.26,122.81 9.68,122.81 9.1,122.24 9.1,121.15 8.95,120.99 6.64,120.99 4.42,118.77 4.42,109.07 3.4,108.06 3.4,105.27 4.08,104.6 4.08,99.68 3.95,99.56 3.55,99.56 3.43,99.43 3.43,99.12 3.55,99 3.96,99 4.09,98.87 4.09,98.55 3.96,98.43 3.53,98.43 3.4,98.3 3.4,85.66 4.55,84.52 4.55,75.84 4.14,75.43 4.14,70.57 4.74,69.98 4.74,67.06 11.78,60.01 12.75,60.01 13.08,59.68 23.8,59.68 27.02,56.45 27.02,46.01 27.95,45.09 v1(27.95,43.42)
PCH_AZ_CODEC_SYNC: length 133.8
  TOP w0.102: JIO1.13 28.18,41.95 27.79,41.55 v1(27.79,41.34) ; RH27.1 16.61,133.01 v2(15.62,134) 14.79,134 14.44,133.64 14.44,131.79 12.67,130.02 12.53,130.02 12.52,130.01 v1(12.48,130.01)
  IN3 w0.127: v1(27.79,41.34) 27.13,41.34 26.52,41.95 26.52,43.79 24.9,45.4 24.9,55.91 23.47,57.34 5.94,57.34 2.08,61.2 2.08,61.84 1.42,62.5 1.42,73.42 1.12,73.72 1.12,76.57 2.51,77.97 2.51,82.07 1.62,82.96 1.62,122.89 2.35,123.61 2.35,124.42 1.7,125.07 1.7,127.19 2.63,128.12 6.34,128.12 6.58,127.88 10.39,127.88 10.87,127.39 11.43,127.39 12.19,128.16 12.19,129.27 12.48,129.57 v1(12.48,130.01)
PCH_AZ_RST#: length 12.8
  TOP w0.102: UH4.K34 21.97,120.93 21.69,121.21 v1(21.69,121.26)
  BOTTOM w0.102: 18.79,120.69 20.04,120.69 20.17,120.82 20.17,121.21 20.29,121.34 20.48,121.34 20.61,121.21 20.61,120.82 20.74,120.69 21.09,120.69 21.66,121.26 v1(21.69,121.26)
  BOTTOM w0.127: 18.79,120.69 18.67,120.82 18.67,121.31 18.54,121.44 18.22,121.44 18.1,121.31 18.1,121.12 17.97,120.99 17.69,120.99 17.56,121.12 17.56,121.31 17.44,121.44 17.16,121.44 17.03,121.31 17.03,121.15 16.9,121.02 16.58,121.02 16.1,121.5 v2(15.71,121.5) 14.98,121.5 14.87,121.39 14.87,120.85 14.74,120.73 14.07,120.73 13.94,120.85 13.94,121.26 RH41.2
PCH_AZ_SDOUT: length 32.2
  TOP w0.102: RH287.2 14.29,122.11 14.42,121.98 14.54,121.98 14.91,122.35 15.01,122.35 15.24,122.12 15.24,122.02 14.84,121.63 13.23,121.63 13.1,121.5 13.1,121.3 13.23,121.17 15.06,121.17 15.53,121.64 15.73,121.64 15.86,121.77 15.86,122.19 16.02,122.35 16.17,122.35 16.29,122.23 16.29,121.7 16.78,121.22 16.85,121.22 16.91,121.29 16.91,121.65 17.03,121.77 17.19,121.77 17.31,121.65 17.31,121.37 17.42,121.26 17.5,121.26 17.71,121.47 17.71,121.66 UH4.A36 ; RH287.2 13.7,121.96 12.18,121.96 11.97,122.17 v1(11.84,122.17) ; RH287.2 RH29.2
  IN2 w0.127: v1(16.24,134.06) 16.04,133.86 16.04,132.95 15.28,132.19 14.74,132.19 14.16,131.61 14.16,128.17 14.03,128.04 14.03,125.37 13.4,124.73 13.4,123.79 12.86,123.25 12.34,123.25 12.17,123.09 12.06,123.09 11.76,122.78 11.76,122.25 v1(11.84,122.17)
  BOTTOM w0.102: v1(16.24,134.06) 16.27,134.09 16.27,134.15 16.52,134.4 v2(16.52,134.8) 16.29,135.03 16.29,135.67 RH50.2
PCH_AZ_SYNC: length 22.4
  TOP w0.102: UH4.L34 22.61,121.05 v1(22.37,121.29) ; v1(15.48,129.44) 13.27,129.44 13.18,129.35 QH7.1 11.96,129.35 11.34,129.97 v2(11.25,129.97) 10.43,129.97 9.79,129.33 RH66.2 9.79,129.03 RH282.1
  IN1 w0.102: v1(22.37,121.29) 22.77,121.29 23.2,121.72 23.2,122.46 22.94,122.72 22.52,122.72 22.26,122.98 22.26,124.51 21.31,125.46 20.93,125.46 20.55,125.84 18.22,125.84 16.58,127.49
  IN1 w0.109: 16.58,127.49 16.36,127.71 16.36,128.84 15.76,129.44 v1(15.48,129.44)
PCH_AZ_SYNC_Q: length 4.7
  TOP w0.102: RH27.2 RH31.2 15.59,131.34 14.96,130.7 14.96,130.17 14.79,130 QH7.3 v2(14.26,131.13)
PCH_BATLOW#: length 9.4
  TOP w0.102: UH4.E10 20.07,108.68 20.28,108.47 v1(20.28,108.42)
  IN4 w0.102: 16.53,105.44 17.09,106.01 17.09,106.43 18.71,108.04 19.45,108.04 19.48,108.01 19.88,108.01 v1(20.28,108.42)
  IN4 w0.109: v1(15.2,104.57) 15.9,105.27 16.36,105.27 16.53,105.44
  BOTTOM w0.102: v2(15.8,105.09) 15.28,104.57 v1(15.2,104.57)
  BOTTOM w0.127: RH139.2 14.83,104.2 v1(15.2,104.57)
PCH_CL_CLK1: length 230.4
  TOP w0.102: v1(23.68,107.68) 23.68,107.67 23.66,107.67 23.37,107.38 UH4.M7 ; v1(155.83,94.55) 155.17,95.21 155.17,99.51 155.57,99.91 155.57,101.23 v2(155.43,101.37) 155.28,101.52 155.28,117.67 155.73,118.11 155.73,124.1 v1(155.05,124.78)
  IN1 w0.109: v1(23.68,107.68) 23.68,107.66 24.2,107.14 24.2,105.6 24.83,104.98 27.51,104.98 27.62,105.09 33.26,105.09 33.4,104.95 37.41,104.95 38.61,103.76 39.17,103.76 40.83,102.1 40.83,101.84 41.9,100.78 48.02,100.78 48.5,100.29 55.23,100.29 56.01,99.51 61.1,99.51 61.47,99.88 62.27,100.67 64.84,100.67 65.56,101.38 68.16,101.38 68.98,102.21 70.17,102.21 74,106.05 76.97,106.05 77.56,105.45 82.65,105.45 85.69,108.49 85.69,109.68 86.42,110.42 87.48,110.42 87.81,110.74 88.9,110.74 91.32,113.17 95.3,113.17 96.44,114.31 96.44,116.05 97.91,117.52 100.22,117.52 101.27,116.47 101.61,116.47 101.95,116.13 101.95,114.5 103.03,113.43 113.29,113.43 115.93,116.07 124.7,116.07 124.95,116.32 128.34,116.32 129.51,117.49 131.35,117.49 136.63,122.76 136.63,129.81 137,130.19 152.02,130.19 155.69,126.52 155.69,125.41 v1(155.05,124.78)
  BOTTOM w0.102: JMINI2.45 181.49,92 180.49,93 178.32,93 177.7,92.38 177.7,89.78 176.31,88.39 175.16,88.39 174.54,87.76 168.82,87.76 168.23,88.35 160.41,88.35 156.87,91.9 156.87,93.51 v1(155.83,94.55)
PCH_CL_DATA1: length 230.7
  TOP w0.102: v1(24.7,109.03) 24.74,109.03 25,109.29 UH4.T11 ; v1(156.31,124.47) 155.97,124.13 155.97,117.89 v2(155.75,117.67) 155.51,117.43 155.51,101.76 155.83,101.45 155.83,99.76 155.41,99.34 155.41,95.91 v1(155.89,95.43)
  IN1 w0.109: v1(156.31,124.47) 156.31,126.3 152.2,130.42 136.91,130.42 136.4,129.91 136.4,122.85 131.26,117.72 129.36,117.72 128.19,116.55 124.81,116.55 124.56,116.29 115.83,116.29 113.2,113.66 103.12,113.66 102.18,114.6 102.18,116.23 101.7,116.71 101.35,116.71 100.32,117.75 97.82,117.75 96.21,116.14 96.21,114.41 95.21,113.4 91.23,113.4 88.84,111.01 87.77,111.01 87.41,110.65 86.33,110.65 85.46,109.78 85.46,108.58 82.56,105.68 77.66,105.68 77.06,106.27 73.88,106.27 70.04,102.44 68.88,102.44 68.07,101.63 65.47,101.63 64.75,100.9 62.17,100.9 61.01,99.75 56.1,99.75 55.32,100.52 48.59,100.52 48.11,101 41.99,101 41.06,101.94 41.06,102.19 39.22,104.03 38.75,104.03 37.6,105.17 33.58,105.17 33.44,105.31 27.32,105.31 27.23,105.22 26.15,105.22 25.25,106.12 25.25,108.47 24.7,109.02 v1(24.7,109.03)
  BOTTOM w0.102: v1(155.89,95.43) 155.84,95.43 155.26,94.84 155.26,94.25 156.54,92.96 156.54,91.77 160.2,88.11 168.15,88.11 168.73,87.54 174.63,87.54 175.28,88.18 176.46,88.18 178,89.73 178,92.33 178.41,92.74 180.25,92.74 180.69,92.3 JMINI2.47
PCH_CL_RST1#: length 342.9
  TOP w0.102: v1(23.67,108.95) 23.82,108.95 24.12,108.65 UH4.P10 ; v1(159.03,88.48) 159.03,89.41 157.69,90.74 157.69,93.99 158.18,94.48 158.18,96.48 157.82,96.84 157.82,98.46 158.04,98.68 158.04,102.81 157.66,103.19 157.66,111.93 159.26,113.53 159.26,125.65 157.21,127.7 157.21,132.08 154.53,134.76 154.53,135.95 151.04,139.45 151.04,146.81 149.82,148.03 149.82,151.82 v2(150.05,152.04) 152.08,154.08 152.08,157.7 152.33,157.95 152.33,159.08 v1(151.61,159.8)
  IN1 w0.102: v1(23.67,108.95) 23.63,108.99 22.53,108.99 22.34,108.8 21.64,108.8 21.4,108.56 21.4,108.31 21.09,108 18.48,108 17.99,108.48 17.99,108.49 17.39,109.09 16.62,109.09
  IN1 w0.109: 16.62,109.09 16.07,109.65 14.84,109.65 14.57,109.38 14.57,108.51 14.45,108.4 14.45,107.79 12.88,106.21 11.99,106.21 11.98,106.21 10.42,106.21 9.8,105.59 6.21,105.59 5.83,105.97 4.52,105.97 4.16,106.32 4.16,106.36 4.04,106.49 4.04,107 4.08,107.04 4.08,108.05 4.77,108.75 4.77,133.73 4.98,133.93 4.98,136.02 7.05,138.09 8.09,138.09 8.82,138.82 10.26,138.82 12.14,140.7 12.14,142.57 13.47,143.9 14.34,143.9 15.68,145.25 15.68,149.78 18.78,152.88 19.46,152.88 20.22,152.12 31.91,152.12 32.5,151.52 33.31,151.52 33.82,152.03 38.02,152.03 40.12,149.94 44.54,149.94 50.56,155.96 59.08,155.96 60.1,154.93 63.69,154.93 63.91,155.16 66.8,155.16 68.74,153.21 71.01,153.21 71.62,153.83 73.77,153.83 77.4,150.2 80.39,150.2 81.25,149.34 92.97,149.34 99.02,155.39 99.02,158.03 100.88,159.89 101.85,159.89 102.6,160.63 102.6,161.23 106.03,164.67 106.03,165.61 108.93,168.5 108.93,168.51 110.78,170.36 128.16,170.36 129.37,169.15 129.37,161.43 130.26,160.54 132.08,160.54 132.14,160.6 132.65,160.6 133.45,159.8 136.42,159.8 138.16,158.06 144.82,158.06 145.44,158.69 148.06,158.69 148.67,159.3 151.1,159.3 v1(151.61,159.8)
  BOTTOM w0.102: R709.1 179.13,85.87 177.98,84.71 176.26,84.71 173.66,87.31 168.63,87.31 168.05,87.88 159.62,87.88 v1(159.03,88.48)
PCH_CRT_BLU: length 60.7
  TOP w0.102: UH4.N48 23.84,127.83 23.84,130.02 v2(23.76,130.1) 23.76,130.45 v1(23.23,130.99) 22.71,131.51 RH131.2
  IN1 w0.109: v1(23.23,130.99) 23.62,131.38 23.62,133.81 23.25,134.18 23.25,137.87 24.8,139.42 33.33,139.42 34.1,140.2 37.7,140.2 38.17,140.67 42.59,140.67 42.7,140.77 45.62,140.77 45.94,141.09 45.94,141.8 46.52,142.38 47.5,142.38 48.21,143.09 49.35,143.09 49.76,143.5 50.86,143.5 50.93,143.43 55.26,143.43 55.71,142.98 57.41,142.98 59.87,145.44 v1(61.52,145.44)
  BOTTOM w0.102: U19.19 60.17,150.09 59.94,149.86 59.94,147.02 v1(61.52,145.44)
PCH_CRT_DDC_CLK: length 85.2
  TOP w0.102: UH4.T39 25.21,123.53 24.78,123.97 24.78,124.36 v1(24.75,124.38)
  IN1 w0.102: 22.38,128.11 23.95,128.11 24.17,127.89 24.17,125.08 24.55,124.7 24.55,124.7 24.75,124.5 v1(24.75,124.38)
  IN1 w0.109: v3(61.87,148.11) 61.7,147.93 61.7,147.45 61.28,147.03 54.68,147.03 53.11,145.45 49.55,145.45 48.09,143.99 46.87,143.99 45.11,142.23 39.79,142.23 39.57,142.01 34.59,142.01 33.32,140.74 31.63,140.74 31.18,141.2 24.75,141.2 21.73,138.18 21.73,135.81 22.15,135.4 22.15,133.49 22.27,133.36 22.58,133.36 22.71,133.24 22.71,132.72 22.58,132.59 19.52,132.59 19.39,132.46 19.39,132.08 19.52,131.95 19.95,131.95 20.07,131.83 20.07,131.38 20.2,131.26 20.45,131.26 20.58,131.38 20.58,131.83 20.71,131.95 22.2,131.95 22.33,131.83 22.33,130.79 22.2,130.66 21.86,130.66 21.73,130.79 21.73,131.2 21.6,131.33 21.28,131.33 21.16,131.2 21.16,128.31 21.36,128.11 22.38,128.11
  BOTTOM w0.102: v1(24.75,124.38) 23.61,124.38 23.21,124.78 23.21,127.19 22.58,127.83 22.58,130.26 22.71,130.39 RH317.2 ; U19.15 61.77,150.85 61.68,150.77 61.68,148.3 v3(61.87,148.11)
PCH_CRT_DDC_DAT: length 65
  TOP w0.102: v1(22.71,124.46) 22.75,124.46 23.17,124.05 UH4.M40
  IN1 w0.109: v3(21.59,134.6) 21.11,135.08 21.11,135.5 21.16,135.55 21.16,138.24 24.48,141.57 31.27,141.57 31.81,141.02 33.12,141.02 34.38,142.28 39.38,142.28 39.64,142.53 44.88,142.53 46.7,144.35 47.98,144.35 49.51,145.87 53,145.87 54.38,147.26 54.58,147.26 54.59,147.26 61.18,147.26 61.46,147.55 61.46,147.89 v1(61.24,148.11)
  BOTTOM w0.102: v3(21.59,134.6) 21.14,134.15 21.14,132.16 20.67,131.69 RH316.1 20.67,131.4 21.14,130.96 21.14,129.9 21.33,129.71 21.33,125.84 21.31,125.81 21.31,125.48 21.81,124.98 22.2,124.98 v1(22.71,124.46) ; v1(61.24,148.11) 61.45,148.32 61.45,150.77 61.37,150.85 U19.16
PCH_CRT_GRN: length 59.1
  TOP w0.102: UH4.P49 24.22,128.73 24.43,128.94 v1(24.43,130.57) 24.43,130.7 23.72,131.41 RH132.2
  IN1 w0.109: v1(24.43,130.57) 24.46,130.59 24.46,132 26.83,134.38 27.72,134.38 28.08,134.73 28.08,136.28 27.54,136.82 27.54,138.16 28.17,138.79 33.59,138.79 34.36,139.56 42.54,139.56 43.1,140.12 45.87,140.12 47.04,141.29 47.4,141.29 48.57,142.46 50.01,142.46 50.53,141.94 50.9,141.94 51.76,142.8 54.99,142.8 55.45,142.34 57.67,142.34 59.93,144.6 61.36,144.6 62.19,145.43 v1(62.19,145.44)
  BOTTOM w0.102: U19.18 60.57,149.27 v2(60.38,149.08) 60.38,147.25 v1(62.19,145.44)
PCH_CRT_HSYNC: length 59.2
  TOP w0.102: RH123.1 21.53,132.62 20.85,133.3 v1(20.67,133.3)
  IN1 w0.109: v1(20.67,133.3) 20.51,133.3 19.71,134.1 19.71,135.54 20.14,135.97 20.14,138.68 25.32,143.87 33.51,143.87 34.09,143.29 38.61,143.29 39.03,143.71 44.59,143.71 46.73,145.86 47.66,145.86 49.34,147.54 49.34,148.37 50.42,149.45 51.08,149.45 51.72,148.81 60.07,148.81 60.39,149.12 62.43,149.12 v1(62.91,148.64)
  BOTTOM w0.102: v1(62.91,148.64) 62.6,148.96 v2(62.6,149.73) 62.57,149.76 U19.13
PCH_CRT_RED: length 57
  TOP w0.102: RH133.2 24.74,131.32 25.09,130.96 v1(25.09,130.54) 25.09,129.34 24.97,129.21 24.97,128.41 UH4.T49
  IN1 w0.109: v1(25.09,130.54) 25.14,130.59 25.15,130.59 25.42,130.86 25.54,130.86 28.81,134.13 28.81,135.45 30.75,137.38 30.75,137.55 31.34,138.15 34.17,138.15 34.94,138.91 42.92,138.91 43.47,139.46 45.06,139.46 45.36,139.15 45.89,139.15 47.39,140.65 47.66,140.65 48.68,141.66 49.71,141.66 50.07,141.3 51.16,141.3 52.03,142.16 54.73,142.16 55.18,141.71 57.94,141.71 59.72,143.5 61.8,143.5 62.83,144.53 v1(62.83,145.39)
  BOTTOM w0.102: U19.17 60.97,150.99 60.81,150.83 60.81,147.83 v2(62.17,146.46) 62.83,145.81 v1(62.83,145.39)
PCH_CRT_VSYNC: length 57.5
  TOP w0.102: RH124.1 20.67,132.63 20.23,133.07 20.23,133.49 v3(20.67,133.93)
  IN1 w0.109: v3(20.67,133.93) 20.56,133.93 20.15,134.34 20.15,135.45 20.52,135.81 20.52,138.53 25.46,143.47 33.04,143.47 33.6,142.91 38.86,142.91 39.14,143.19 44.63,143.19 46.9,145.47 48.2,145.47 48.87,146.13 48.87,146.14 49.24,146.51 49.24,146.51 50.39,147.65 50.91,147.65 51.09,147.47 51.09,146.79 51.37,146.51 52.74,146.51 54.68,148.45 60.23,148.45 60.52,148.74 62.14,148.74 v1(62.27,148.62)
  BOTTOM w0.102: v1(62.27,148.62) 62.27,150.95 62.17,151.05 U19.14
PCH_DPWROK: length 312.3
  TOP w0.102: RH113.1 13.34,115.35 13.78,114.91 14.57,114.91 15.06,114.41 v1(15.06,114.14) ; v1(20.41,114.39) 20.41,114.4 20.07,114.74 UH4.E22
  IN1 w0.109: v1(226.97,79.19) 227.99,79.19 229.8,77.37 229.8,76.14 231.24,74.7 231.24,74.23 230.99,73.98 229.48,73.98 227.9,72.4 227.9,67.4 226.6,66.1 v1(226.49,66.1) ; v1(15.06,114.14) 15.09,114.11 15.19,114.11 15.65,113.65 17.14,113.65 18.32,114.83 19.88,114.83 20.32,114.39 v1(20.41,114.39)
  IN2 w0.127: v1(15.06,114.14) 15.05,114.15 15.05,114.46 14.34,115.18 14.34,120.02 13.47,120.89 11.93,120.89 11.23,121.6 11.23,124.45 11.84,125.07 12.84,125.07 13.46,125.69 13.46,128.46 13.64,128.64 13.64,132.17 14.31,132.84 15.21,132.84 15.53,133.16 15.53,134.53 16.06,135.06 16.06,136.45 17.03,137.41 17.45,137.41 17.84,137.03 18.21,137.03 18.62,137.43 18.62,137.47 19.49,138.34 20.18,138.34 22.63,140.79 25.25,140.79 26.21,139.83 27.02,139.83 27.91,138.94 28.62,138.94 29.04,138.52 32.29,138.52 32.43,138.38 35.18,138.38 36.25,137.31 45.6,137.31 47.23,138.94 53.88,138.94 54.77,139.83 54.86,139.83 61.66,139.83 61.86,139.62 65.02,139.62 65.47,139.18 68.46,139.18 70.49,137.15 70.63,137.15 71.05,136.73 72.95,136.73 75.05,134.63 78.67,134.63 79.34,135.3 79.34,136.45 79.73,136.84 82.24,136.84 82.78,137.38 86.6,137.38 87.62,136.36 102.78,136.36 103.72,135.42 108.75,135.42 109.22,135.89 112.66,135.89 114.9,133.66 130.93,133.66 132.67,135.4 152.01,135.4 155.92,131.48 159.71,131.48 161.36,129.83 169.53,129.83 178.31,121.05 178.31,117.73 180.27,115.76 183.1,115.76 184.33,114.53 184.33,110.53 186.17,108.69 186.17,107.9 190.21,103.86 190.21,99.52 191.35,98.37 191.35,97.3 196.32,92.33 196.32,90.62 196.57,90.37 196.57,89.83 198.01,88.39 201.09,88.39 201.87,87.62 206.96,87.62 208.42,86.16 215.4,86.16 215.8,85.76 215.8,84.78 218.1,82.47 222.3,82.47 225.59,79.19 v1(226.97,79.19)
  BOTTOM w0.102: R802.1 227.04,65.56 v1(226.49,66.1) v2(225.91,66.1)
PCH_GPIO3: length 11.7
  TOP w0.102: v1(21.01,124.23) 21.01,124.22 20.7,123.92 UH4.G40
  BOTTOM w0.102: v1(21.01,124.23) 20.75,124.48 20.75,125.44 20.29,125.9 v2(20.22,125.9) 18.21,125.9 17.63,126.48 17.63,130.18 16.94,130.86 16.53,130.86 RH332.2
PCH_GPIO15: length 78.9
  TOP w0.102: RH354.2 16.1,102.07 v1(16.65,102.62) 16.97,102.93 19.4,102.93 20.87,104.4 20.87,104.96 UH4.G2 ; v1(69.48,93.27) v2(69.48,93.95)
  TOP w0.127: v1(76.22,98.48) 76.17,98.53 RH19.1
  IN2 w0.127: v1(69.48,93.27) 69.4,93.27 69.15,93.52 64.01,93.52 63.97,93.49 59.86,93.49 57.92,95.43 57.53,95.43 56.02,93.92 38.37,93.92 37.58,93.13 36.61,93.13 36.14,92.66 32.81,92.66 32.22,93.24 32.2,93.24 31.78,93.66 30.73,93.66 30.11,93.04 28.08,93.04 27.1,94.02 26.29,94.02 24.5,95.81 23.75,95.81 23.2,96.36 21.56,96.36 20.84,97.08 20.84,98.54 20.69,98.69 20.69,99.68 19.66,100.71 18.55,100.71 v1(16.65,102.62)
  IN3 w0.127: v1(76.22,98.48) 76.12,98.58 74.45,98.58 69.73,93.87 69.73,93.52 69.49,93.27 v1(69.48,93.27)
PCH_GPIO16: length 55.4
  TOP w0.102: RH17.1 67.57,98.68 66.64,98.68 66.37,98.95 v1(66.37,98.96) ; UH4.U2 25.65,104.93 25.65,104.31 25.75,104.2 25.75,103.21 25.77,103.2 25.77,103.18 25.67,103.07 25.67,102.36 v1(25.09,101.79) 25.09,101.77 25.25,101.61 RH272.2 RH274.1
  IN2 w0.127: v1(66.37,98.96) 64.68,100.65 64.05,100.65 61.23,103.46 60.07,103.46 58.52,105.02 57.22,105.02 56.04,103.84 53.07,103.84 51.44,102.21 46.6,102.21 45.83,101.44 43.24,101.44 41.67,103 37.64,103 36.25,101.61 32.76,101.61 32.41,101.26 30.76,101.26 30,100.5 28.52,100.5 27.7,101.31 25.57,101.31 v1(25.09,101.79)
  BOTTOM w0.102: v2(25.56,102.16) 25.19,101.79 v1(25.09,101.79)
PCH_GPIO17: length 8.6
  TOP w0.102: v1(19.66,123.29) 19.63,123.32 19.63,123.58 UH4.D40
  BOTTOM w0.102: v1(19.66,123.29) 19.62,123.29 18.72,124.19 18.67,124.19 v2(16.33,126.53) 15.98,126.89 14.62,126.89 RH269.2
  BOTTOM w0.127: RH269.2 RH273.1
PCH_GPIO22: length 11.2
  TOP w0.102: v1(24.7,106.35) 24.81,106.35 UH4.T5
  BOTTOM w0.102: RH181.1 25.67,98.17 24.99,98.84 24.99,99.51 24.74,99.76 24.74,101.53 24.66,101.61 24.66,104.38 25.25,104.97 v2(25.25,105.09) 25.25,106.01 24.9,106.35 v1(24.7,106.35)
PCH_GPIO24: length 1.3
  TOP w0.102: UH4.E8 19.99,107.93 19.65,107.59 v1(19.65,107.4)
  BOTTOM w0.102: T107.1 19.33,107.08 v1(19.65,107.4)
PCH_GPIO27: length 11.6
  TOP w0.102: UH4.E16 20.07,111.84 19.7,111.47 v1(19.7,111.4)
  IN4 w0.109: v1(11.42,110) 11.42,109.92 11.62,109.72 13.92,109.72 14.26,110.06 16.65,110.06 17.45,110.86 19.14,110.86 19.7,111.42 v1(19.7,111.4)
  BOTTOM w0.102: RH175.1 11.11,110.3 v1(11.42,110) 11.42,110.3 v2(11.9,110.78)
PCH_GPIO33: length 5.1
  TOP w0.102: RH355.1 15.14,120.56 15.73,121.16 v2(16.09,121.16) 16.48,121.16 16.7,120.94 17.47,120.94 18.2,121.67 18.62,121.67 UH4.C36
PCH_GPIO35: length 65.2
  TOP w0.102: UH4.K4 22.37,106.11 22.67,106.41 v1(22.71,106.41) ; v1(72.82,98.48) 72.83,98.46 72.83,97.9 v2(72.95,97.79)
  TOP w0.127: RH12.1 73.13,98.78 v1(72.82,98.48)
  IN2 w0.102: v1(22.71,106.41) 23.23,105.89 23.23,105.6 23.92,104.91
  IN2 w0.127: 23.92,104.91 24.19,104.64 27.65,104.64 28.47,103.81 28.8,103.81 29.44,104.45 41.24,104.45 41.76,104.97 45.46,104.97 48.04,107.54 49.89,107.54 52.19,109.84 60.36,109.84 62.1,108.1 62.1,106.46 70.09,98.48 v1(72.82,98.48)
  BOTTOM w0.102: RH275.2 20.55,104.44 21.71,105.6 21.96,105.6 22.71,106.35 v1(22.71,106.41)
PCH_GPIO36: length 62.2
  TOP w0.102: v1(26.69,108.38) 26.57,108.38 UH4.V8 ; v1(66.72,98.21) 67.17,97.77 69.72,97.77 v2(70.08,98.12) RH20.1
  IN2 w0.127: v1(26.12,101.79) 26.38,101.54 27.8,101.54 28.61,100.72 29.91,100.72 30.67,101.49 32.31,101.49 32.67,101.84 36.15,101.84 37.55,103.23 41.77,103.23 43.34,101.66 45.71,101.66 46.48,102.44 51.35,102.44 52.98,104.06 55.95,104.06 57.13,105.25 58.76,105.25 60.23,103.77 61.3,103.77 64.18,100.89 64.76,100.89 66.25,99.4 66.55,99.4 66.91,99.04 66.91,98.4 v1(66.72,98.21)
  IN4 w0.109: v1(26.12,101.79) 25.67,102.25 25.67,103.19 26.01,103.53 26.01,106.41 26.2,106.6 26.2,107.89 v1(26.69,108.38)
  BOTTOM w0.102: RH174.1 RH171.1 26.26,101.65 v1(26.12,101.79)
PCH_GPIO37: length 66.5
  TOP w0.102: v1(69.54,100.75) 69.54,99.64 RH34.1 ; UH4.M5 23.11,106.75 22.79,107.07 v1(22.69,107.07)
  IN2 w0.102: v1(22.69,107.07) 23.2,106.57 23.2,106.26 23.48,105.98 23.48,105.76 24.39,104.85 28.12,104.85 28.31,104.66 41.05,104.66 41.68,105.28 42.77,105.28
  IN2 w0.127: v1(69.54,100.75) 68.77,100.75 65.35,104.17 65.35,104.86 65.12,105.09 64.11,105.09 62.33,106.87 62.33,108.19 60.45,110.07 52.09,110.07 49.8,107.77 47.76,107.77 45.27,105.28 42.77,105.28
  BOTTOM w0.102: v1(22.69,107.07) 22.19,106.57 22.19,106.16 21.83,105.8 21.63,105.8 19.62,103.8 v2(19.62,103.48) 19.62,101.59 RH172.1 RH173.1
PCH_GPIO52: length 6.8
  TOP w0.102: v1(18.4,126.33) 18.75,125.98 UH4.C44
  BOTTOM w0.102: RH340.2 17.37,131.03 17.37,130.89 17.59,130.68 ; 17.59,130.68 17.83,130.44 17.83,126.9 v1(18.4,126.33) ; 17.59,130.68 v2(17.59,130.7)
PCH_GPIO54: length 12.8
  TOP w0.102: v1(20.36,124.26) 20.36,124.22 20.07,123.94 UH4.E40
  IN1 w0.109: v1(11.27,126.94) 11.51,127.18 12.85,127.18 14.16,125.87 15.39,125.87 15.58,126.06 16.79,126.06 18.03,124.82 20.03,124.82 20.36,124.49 v1(20.36,124.26)
  BOTTOM w0.102: RH328.2 11.27,126.07 v1(11.27,126.94) 11.35,126.94 v2(11.75,127.33)
PCH_GPIO71: length 2.3
  TOP w0.102: v1(16.29,124.04) 16.58,123.75 17.83,123.75 UH4.A40
  BOTTOM w0.102: T109.1 16.14,123.89 v1(16.29,124.04)
PCH_GPIO74: length 8.9
  TOP w0.102: UH4.C13 18.81,110.41 18.51,110.1 18.18,110.1 18.06,110.22 17.4,110.22 16.93,109.74 12.06,109.74 v2(11.87,109.54) 11.61,109.28 RH301.1
PCH_INTVRMEN: length 14.5
  TOP w0.102: v1(11.42,111.01) 11.42,111.1 ; 11.42,111.1 11.2,111.32 RH38.2 RH39.1 ; 11.42,111.1 11.42,111.43 v2(11.68,111.7) ; UH4.C17 18.8,112.39 18.45,112.04 18.18,112.04 17.93,112.29 17.5,112.29 17.17,112.62 16.39,112.62 v1(16.38,112.61)
  IN1 w0.109: v1(16.38,112.61) 16.38,112.55 15.94,112.1 15.17,112.1 12.84,109.78 12.38,109.78 12.14,109.54 10.95,109.54 10.58,109.91 10.58,110.32 11.27,111.01 v1(11.42,111.01)
PCH_JTAG_TCK: length 82.7
  TOP w0.102: v1(30.97,93.19) 32.5,94.72 37.18,94.72 39.99,97.52 43.33,97.52 43.53,97.32 48.14,97.32 48.58,97.75 49.25,97.75 49.71,97.3 51.12,97.3 51.26,97.43 54.77,97.43 54.99,97.22 59.38,97.22 61.34,99.17 61.34,104.94 59.04,107.24 59.04,109.26 60.22,110.44 61.9,110.44 62.57,109.77 JXDP2.57 ; v1(21.77,106.38) 21.77,106.3 21.75,106.28 UH4.J3
  IN2 w0.127: v1(16.97,98.49) 16.97,98.46 17.32,98.11 17.32,97.87 17.98,97.21 18.95,97.21 21.69,94.46 25.13,94.46 27.07,92.52 30.25,92.52 30.92,93.19 v1(30.97,93.19)
  IN3 w0.102: v1(21.77,106.38) 21.49,106.38 21.3,106.57 21.3,107.39 20.81,107.87 18.46,107.87 17.85,107.26 17.85,104.77 17.84,104.76 17.84,104.43 17.85,104.42 17.85,103.19
  IN3 w0.127: v1(16.66,101.92) 17.85,103.11 17.85,103.19
  BOTTOM w0.102: v1(16.97,98.49) 16.61,98.84 v4(16.61,99.02) 16.61,100.61 RH59.1 17.12,101.46 v1(16.66,101.92)
PCH_JTAG_TDI: length 69.8
  TOP w0.102: v1(59.64,109.09) 59.82,108.92 59.82,107.07 63.06,103.82 JXDP2.56 ; UH4.K5 22.01,106.75 v1(21.75,107.01)
  IN2 w0.102: 42.77,103.96 36.74,103.96 36.31,103.53 35.7,103.53 35,104.23 29.53,104.23 28.89,103.59 28.38,103.59 27.56,104.42 24.04,104.42 23.28,105.18 22.7,105.18 22.19,105.69 22.19,106.57 v1(21.75,107.01)
  IN2 w0.127: 42.77,103.96 44.11,103.96 44.73,104.59 45.4,104.59 48.13,107.32 49.99,107.32 52.28,109.61 59.12,109.61 v1(59.64,109.09)
  IN4 w0.109: v1(11.8,98.02) 12.77,99 12.77,100.48 15.36,103.07 17.44,103.07 18.06,103.68 19.91,103.68 20.39,104.17 20.39,104.18 21.27,105.05 21.27,106.62 21.66,107.01 v1(21.75,107.01)
  BOTTOM w0.102: RH45.1 RH49.1 12.04,97.78 v1(11.8,98.02) v4(12.46,98.02)
PCH_JTAG_TDO: length 72.8
  TOP w0.102: RH43.1 RH47.1 v1(18.13,102.18) 18.54,102.59 19.8,102.59 20.57,103.37 20.57,103.71 21.25,104.39 UH4.H1 ; v1(64.69,105.77) 64.69,105.69 64.06,105.06 JXDP2.52
  IN2 w0.127: v1(60.56,95.19) 60.56,96.11 57.9,98.77 52.86,98.77 50.49,96.41 48.48,96.41 47.93,96.95 41.43,96.95 40.82,96.34 38.64,96.34 38.32,96.03 36.05,96.03 35.2,95.17 33.64,95.17 33.02,95.8 27.99,95.8 27.1,96.69 24.16,96.69 23.65,97.19 22.53,97.19 22.25,97.47 22.25,97.59 21.78,98.06 21.57,98.06 21.26,98.37 21.26,98.86 21.59,99.19 21.59,99.56 20.03,101.12 19.2,101.12 v1(18.13,102.18)
  BOTTOM w0.102: v1(64.69,105.77) 64.03,105.77 v4(63.54,105.28) 63.12,104.85 63.12,101.17 61.01,99.06 61.01,95.63 v1(60.56,95.19)
PCH_JTAG_TMS: length 98.8
  TOP w0.102: UH4.H7 21.5,107.38 v1(21.77,107.65) ; v1(31.62,93.14) 32.79,94.31 37.48,94.31 40.26,97.09 43.14,97.09 43.34,96.89 48.82,96.89 48.84,96.86 51.31,96.86 51.45,97 54.59,97 54.85,96.74 59.51,96.74 62.57,99.79 JXDP2.58
  IN1 w0.109: v1(7.58,98.9) 7.58,99.06 8.9,100.38 9.87,100.38 12.25,102.77 15.45,102.77 16.31,103.62 20.81,103.62 22.21,105.02 22.21,107.42 21.98,107.65 v1(21.77,107.65)
  IN2 w0.127: v1(31.62,93.14) 31.56,93.08 31.52,93.08 30.44,92 26.92,92 24.93,93.99 21.45,93.99 20.95,94.49 19.82,94.49 18.92,93.6 16.52,93.6 14.87,95.25 13.84,95.25 12.95,96.14 12.95,98.27 12,99.23 7.91,99.23 v1(7.58,98.9)
  BOTTOM w0.102: v1(21.77,107.65) 21.28,107.17 21.28,105.75 19.73,104.2 18.35,104.2 v4(17.7,103.56) 17.33,103.19 16.58,103.19 16.1,102.71 RH48.1 RH44.1
PCH_PCIE_WAKE#: length 218.6
  TOP w0.102: v1(162.95,133.62) 163.57,134.24 163.57,141.11 163.47,141.21 U54.A18 ; UH4.B9 17.57,108.43 v1(17.52,108.38)
  IN2 w0.102: 16.36,108.71 16.69,108.38 v1(17.52,108.38)
  IN2 w0.127: 16.36,108.71 15.3,109.77 14.63,109.77 13.35,111.05 13.35,112.81 12.13,114.03 7.85,114.03 7.16,114.73 7.16,116.05 8.19,117.08 8.19,120.63 8.48,120.92 8.48,121.82 9.09,122.43 9.09,124.45 8.51,125.03 8.51,131.19 9.07,131.75 10.23,131.75 11.17,132.69 12.34,132.69 13.73,134.07 13.73,136.6 18.08,140.96 19,140.96 20.66,142.62 31.66,142.62 31.98,142.3 31.98,140.92 32.62,140.27 33.02,140.27 33.16,140.13 35.91,140.13 36.98,139.07 42.34,139.07 43.37,140.1 43.56,140.1 44.92,140.1 45.74,140.92 46.06,140.92 46.35,141.21 48.72,141.21 49.2,141.69 49.46,141.69 50.13,141.02 50.15,141.02 51.28,141.02 52.18,141.92 61.82,141.92 62.51,142.61 63.57,142.61 64.08,143.12 66,143.12 66.29,143.4 67.84,143.4 68.48,142.76 70.59,142.76 70.99,142.36 70.99,141.85 72.94,139.9 73.13,139.9 73.49,139.54 74.53,139.54 74.94,139.13 79.39,139.13 81.74,141.48 91.65,141.48 92.61,142.44 108.23,142.44 108.61,142.82 117.76,142.82 118.26,142.33 119.89,140.7 119.89,140.51 121.05,139.34 123.78,139.34 125.19,137.94 149.6,137.94 150.66,138.99 154.03,138.99 154.87,138.15 158.43,138.15 162.95,133.63 v1(162.95,133.62)
  BOTTOM w0.102: RH142.2 15.57,106.24 16.36,107.02 16.36,107.21 v2(16.9,107.76) v1(17.52,108.38)
PCH_PLTRST#: length 102.4
  TOP w0.102: UH4.C6 18.75,106.79 v5(18.4,106.44)
  TOP w0.127: RH335.2 RH338.2 RH336.2 ; 8.89,103.95 8.89,103.63 8.56,103.3 UH3.1 ; 8.89,103.95 9.22,103.95 9.43,103.74 10.2,103.74 10.74,103.21 RH336.2 ; 8.89,103.95 UH3.2 ; RH343.2 12.41,102.17 RH337.2 12.13,102.2 v1(11.4,102.93) 11.15,103.19 RH336.2 ; UC2.2 66.65,87.9 66.7,87.95 66.7,90.43 66.57,90.56 64.66,90.56 61.25,93.97 v2(60.37,93.97) 57.57,93.97 55.97,95.57 54.16,95.57 53.85,95.89 52.4,95.89 v1(51.99,95.48) ; v1(20.7,93.73) 23.47,93.73 23.83,94.09 QH1.2
  IN1 w0.102: 16.36,104.38 16.36,104.39 v5(18.4,106.44)
  IN1 w0.127: v1(7.33,96.84) 7.39,96.9 7.39,97.89 6.95,98.34 6.95,99.07 8.69,100.81 9.45,100.81 11.36,102.73 11.36,102.93 v1(11.4,102.93) 11.75,103.28 15.25,103.28 16.36,104.38
  IN4 w0.127: v1(51.99,95.48) 51.52,95.95 48.4,95.95 47.62,96.72 44.83,96.72 44.17,96.06 44.17,94.86 43.84,94.53 42.16,94.53 41.95,94.74 41.95,95 39.95,97 39.2,97 38.82,97.38 34.56,97.38 34.45,97.28 33.92,97.28 32.95,96.32 30.44,96.32 30.15,96.03 27.68,96.03 27.25,95.59 26.45,95.59 25.83,94.97 24.83,94.97 23.59,93.73 v1(20.7,93.73) 19.62,94.81 17.02,94.81 16.42,94.21 13.02,94.21 12.05,95.18 8.98,95.18 v1(7.33,96.84)
PCH_PLTRST#_BUF: length 26.1
  TOP w0.102: UC2.4 65.55,85.3 65.44,85.19 RC49.2 64.87,85.33 64.43,85.78 64.43,87.5 64.59,87.67 64.86,87.67 64.98,87.54 64.98,86.87 65.11,86.75 65.44,86.75 65.57,86.87 65.57,88.09 65.44,88.21 64.6,88.21 64.48,88.34 64.48,88.54 64.6,88.67 65.43,88.67 65.56,88.8 65.56,89.61 65.43,89.73 65.17,89.73 65.05,89.61 65.05,89.27 64.92,89.15 64.6,89.15 64.48,89.27 64.48,89.57 64.35,89.7 64.07,89.7 63.94,89.57 v2(63.94,88.48) 63.94,85.64 64.36,85.22 64.36,83.13 64.49,83.01 64.69,83.01 64.82,83.13 64.82,84.54 64.95,84.67 65.16,84.67 65.29,84.54 65.29,83.95 65.41,83.83 65.59,83.83 65.71,83.95 65.71,84.55 65.82,84.66 65.97,84.66 66.08,84.55 66.08,83.97 66.19,83.86 66.19,83.04 RC51.1
PCH_PLTRST#_EC: length 516.5
  TOP w0.102: v1(178.54,161.9) 178.54,161.98 179.4,162.84 R730.2 ; U54.B30 168.72,143.02 168.36,143.38 168.36,143.62 167.88,144.11 v1(167.88,144.12) ; R704.2 110.04,151.96 v1(110.79,151.2) ; v1(233.78,69.7) 233.78,69.74 233.3,70.22 231.6,70.22 230.91,69.53 228.48,69.53 228.29,69.72 225.3,69.72 v1(225.06,69.97) ; v1(3.43,104.19) 3.54,104.08 5.43,104.08 5.96,104.6 UH3.4 ; U39.16 U37.16 174.11,106.29 174.48,106.67 v1(174.51,106.67) 174.53,106.67 174.76,106.9 174.86,106.9 175.36,107.39 175.36,107.49 175.58,107.71 175.58,109.93 174.56,110.95 172.29,110.95 169.67,113.56 169.67,115.53 170.09,115.95 170.09,134.57 v1(169.57,135.09) ; R713.2 v1(21.94,154.12) ; JIO1.38 35.1,34.75 34.81,34.46 v1(32.38,34.46)
  IN1 w0.109: v1(169.57,135.09) 169.18,135.48 167.4,135.48 167.19,135.7 167.19,136.36 167.32,136.5 167.32,137.53 167.97,138.18 167.97,139.56 167.87,139.66 167.87,140.16 168.12,140.41 168.12,142.34 168.41,142.63 168.41,143.59 v1(167.88,144.12) ; v1(3.43,104.19) 3.03,104.59 3.03,108.45 3.31,108.73 3.31,121.84 3.76,122.29 3.76,132.54 3.06,133.24 2.58,133.24 2.14,133.67 2.14,136.89 4.29,139.04 7.67,139.04 8.42,139.79 9.78,139.79 11.16,141.17 11.16,142.9 13.08,144.82 13.9,144.82 14.71,145.62 14.71,150.11 19.42,154.83 21.23,154.83 v1(21.94,154.12) ; v1(32.38,34.46) 31.9,34.94 31.61,34.94 30.88,35.67 v1(29.59,35.67) ; v1(192.19,87.68) 190.66,89.21 190.66,92.76 188.62,94.81 188.62,97.96 189.57,98.91 189.57,103.25 189.52,103.3 v1(189.52,103.59)
  IN2 w0.127: v1(29.59,35.67) 30.5,36.59 30.5,44.72 27.2,48.02 27.2,57.03 22.71,61.52 11.33,61.52 5.79,67.06 5.79,76.82 4.6,78.02 4.6,85.09 3.82,85.87 3.82,89.73 4.6,90.5 4.6,93.31 4.48,93.42 4.48,103.45 3.74,104.19 v1(3.43,104.19)
  IN3 w0.127: v1(163.07,160.54) 161.69,159.16 161.69,157.7 161.22,157.23 161.22,156.74 161.43,156.54 161.43,155.54 164.55,152.41 164.55,149.98 165.1,149.43 167.16,149.43 167.45,149.14 167.45,144.78 167.88,144.35 v1(167.88,144.12)
  IN4 w0.109: v1(189.52,103.59) 189.32,103.8 183.61,103.8 183.32,103.51 181.05,103.51 180.96,103.61 179.35,103.61 176.73,106.22 174.9,106.22 174.51,106.61 v1(174.51,106.67) ; v1(21.94,154.12) 22.77,153.29 29.17,153.29 32.19,156.31 33.93,156.31 34.28,155.97 42.63,155.97 43.13,156.46 43.14,156.46 46.8,160.12 57.34,160.12 60.26,157.2 61.11,157.2 61.54,156.77 66.27,156.77 67.18,155.85 67.54,155.85 69.62,153.77 71.98,153.77 73.13,152.63 74.15,152.63 77.54,149.24 80.9,149.24 81.64,148.51 86.2,148.51 86.69,149 100.29,149 101.19,149.9 106.63,149.9 108.15,151.42 110.57,151.42 v1(110.79,151.2) 111.1,151.51 116.71,151.51 117.56,150.66 148.39,150.66 150.19,148.86 150.19,147.33 154.96,142.56 156.11,142.56 157.94,140.73 159.99,140.73 162.81,137.91 163.78,137.91 164.27,137.41 164.27,137.08 165.18,136.17 165.45,136.17 166.64,134.98 169.45,134.98 v1(169.57,135.09) ; v1(192.19,87.68) 192.19,85.75 198.51,79.43 214.24,79.43 215.39,78.28 215.39,73.43 218.49,70.33 224.69,70.33 v1(225.06,69.97)
  BOTTOM w0.102: v1(233.78,69.7) 233.28,70.2 U46.B22 ; R703.1 190.6,103.26 190.26,103.61 189.53,103.61 v1(189.52,103.59) ; JMINI3.17 179.44,162.8 v1(178.54,161.9) 178.11,161.47 175.47,161.47 174.56,162.38 172.92,162.38 172.15,163.16 169.67,163.16 168.54,162.02 168.47,161.98 164.51,161.98 v2(164.18,161.65) v1(163.07,160.54)
PCH_PLTRST#_R: length 25.5
  TOP w0.102: JCPU1.AR33 67.81,75.45 67.37,75.88 67.37,77.31 67.5,77.43 67.94,77.43 68.07,77.56 68.07,77.75 67.94,77.88 65.82,77.88 65.7,78 65.7,78.22 65.82,78.35 67.81,78.35 67.92,78.46 67.92,78.62 67.81,78.73 65.61,78.73 65.48,78.85 65.48,79.04 65.61,79.17 67.8,79.17 67.92,79.29 67.92,79.46 67.8,79.58 65.6,79.58 65.48,79.69 65.48,79.86 65.6,79.98 67.8,79.98 67.92,80.1 67.92,80.27 67.65,80.55 67.27,80.55 67.11,80.39 65.6,80.39 65.48,80.51 65.48,80.68 65.6,80.79 66.76,80.79 v2(66.88,80.91) 66.88,81.08 66.76,81.2 66.17,81.2 66.04,81.33 66.04,81.76 66.17,81.89 RC51.2
PCH_PWRBTN#_XDP: length 3.5
  TOP w0.102: RH21.2 66.57,110.54 v2(66.57,110.47) JXDP2.41
PCH_PWRGD#: length 38.2
  TOP w0.102: v2(178.66,154.31) v1(178.66,153.72) 178.95,153.44 R893.2 178.95,152.79 179.42,152.31 Q52.1
  TOP w0.127: R391.1 v1(151.64,158.81)
  IN4 w0.109: v1(178.66,153.72) 178.66,154.98 177.62,156.02 170.15,156.02 169.71,156.46 169.19,156.46 168.07,155.35 163.18,155.35 162.14,154.31 157.43,154.31 156.49,155.25 154.72,155.25 154.49,155.02 154.49,154.45 154.25,154.2 153.44,154.2 152.33,155.31 152.33,158.12 v1(151.64,158.81)
PCH_PWROK: length 17.8
  TOP w0.102: v1(22.35,114.38) 22.61,114.64 UH4.L22
  IN4 w0.102: 16.36,113.48 18.02,113.48 18.59,114.05 19.44,114.05 19.52,113.98 21.95,113.98 v1(22.35,114.38)
  IN4 w0.109: v1(8.23,113.22) 8.23,113.23 9.02,114.02 12.59,114.02 13.13,113.48 16.36,113.48
  BOTTOM w0.102: RH117.2 9.76,113.35 9.17,112.75 v2(8.57,112.75) 8.23,113.09 v1(8.23,113.22)
PCH_RI#: length 5.7
  TOP w0.102: UH4.A10 17.45,108.92 17.09,108.56 17.09,107.85 15.23,105.99 14.82,105.99 14.76,105.94 14.76,105.9 14.65,105.79 14.62,105.79 14.29,105.47 RH140.2
PCH_RSMRST#: length 15.9
  TOP w0.102: U54.B47 171.04,149.13 170.93,149.02 v1(170.55,149.02)
  BOTTOM w0.102: v1(170.55,149.02) 171.61,150.09 173.24,150.09 173.66,149.67 173.66,149.43 174.18,148.91 v2(174.56,148.91) R892.2 176.14,148.41 177.46,148.41 177.98,148.94 R1623.1 178.66,147.96 178.92,147.7 179.88,147.7 180.05,147.54 182.32,147.54 182.36,147.5 U7.1
PCH_RSMRST#_Q: length 257.7
  TOP w0.102: v1(180.06,151.58) 183.41,151.58 185.35,149.63 185.35,138.89 184.48,138.01 v1(184.48,135.47) ; v1(12.55,116.27) 12.57,116.29 13.24,116.29 RH120.1 ; v1(155.01,100.24) 155.01,100.28 155.05,100.32 155.05,117.73 155.5,118.17 155.5,123.62 v1(155.08,124.04) ; v1(177.32,130.82) 176.66,130.16 176.66,124.24 v1(176.34,123.93) ; v1(63.05,97.24) 64.97,99.16 RH24.1
  IN2 w0.127: v1(184.48,135.47) 184.48,135.17 180.87,131.56 178.05,131.56 v1(177.32,130.82) ; v1(155.01,100.24) 154.91,100.24 154.51,100.65 150.86,100.65 149.5,102.01 128.81,102.01 127.67,100.86 121.64,100.86 121.04,100.27 109.32,100.27 108.72,100.86 86.23,100.86 v1(85.41,101.69) ; v1(63.05,97.24) 62.76,97.24 61.49,98.51 59.13,98.51 58.19,99.45 52.57,99.45 50.49,97.37 49.64,97.37 49.15,97.87 41.05,97.87 40.44,97.26 38.26,97.26 37.94,96.94 36.19,96.94 36.01,97.12 34.43,97.12 34.38,97.07 32.87,97.07 32.52,96.71 28.42,96.71 27.53,97.6 25,97.6 23.9,98.7 23.9,99.52 23.31,100.11 21.78,100.11 20.1,101.79 20.1,103.51 17.94,105.66 17.94,108.56 17.5,109 16.46,109 15.47,110 14.72,110 13.68,111.04 13.68,113.21 12.93,113.96 12.93,115.82 12.55,116.21 v1(12.55,116.27)
  IN3 w0.127: v1(85.41,101.69) 84.97,101.26 83.64,101.26 83.21,101.69 80.7,101.69 80.27,101.26 78.83,101.26 76.92,103.18 72.5,103.18 71.94,102.62 64.24,102.62 63.05,101.44 v1(63.05,97.24)
  BOTTOM w0.102: R1623.2 R1633.2 179.68,150.08 179.36,150.39 179.36,150.88 v1(180.06,151.58) ; v1(176.34,123.93) 176.08,123.67 v2(174.83,123.67) 174.34,123.67 173.72,123.05 164.9,123.05 164.03,123.91 155.21,123.91 v1(155.08,124.04)
PCH_RSMRST#_R: length 6.7
  TOP w0.102: RH120.2 RH113.2 14.64,115.38 v2(15.58,114.44) 16.05,113.97 17.3,113.97 17.51,114.19 18.05,114.19 18.17,114.06 18.45,114.06 18.76,114.37 UH4.C21
PCH_RTCRST#: length 197.9
  TOP w0.102: v1(19.66,113.37) 19.66,113.37 19.63,113.37 19.43,113.57 UH4.D20 ; v1(144.12,93.96) 144.36,94.2 146.92,94.2 147.83,95.1 147.83,102.45 147.29,102.98 147.29,114.1 145.52,115.88 140.62,115.88 136.87,119.63 136.87,133.22 136.31,133.78 v1(136.31,133.92)
  IN1 w0.102: v1(19.66,113.37) 19.66,113.37 19.7,113.33 19.7,113.28 20.14,112.84 22.49,112.84 22.84,112.48 24.78,112.48 25.28,111.98 25.84,111.98 25.91,111.9 28.17,111.9 28.55,111.52 29.74,111.52 29.92,111.34 30.77,111.34 30.8,111.32 33.29,111.32 33.34,111.37 36.08,111.37 36.55,110.9 38.47,110.9 38.58,110.78 39.2,110.78 39.29,110.87 39.8,110.87 40.7,109.97 40.7,107.75 40.84,107.61 40.84,106.63 41.95,105.52 42.16,105.52
  IN1 w0.109: 42.16,105.52 42.82,105.52 43.28,105.07 44.85,105.07 45.69,104.23 45.69,103.86 46.49,103.06 49.54,103.06 50.05,102.55 56.44,102.55 57.1,101.89 57.59,101.89 57.7,102.01 59.78,102.01 60.59,102.82 60.84,102.82 61.43,103.4 62.94,103.4 63.28,103.75 65.83,103.75 67.68,105.59 69.28,105.59 70.27,106.58 70.75,106.58 71.13,106.96 71.13,107.29 72.79,108.95 79.67,108.95 81.16,110.45 82.59,110.45 84.95,112.81 85.06,112.81 88.85,116.61 88.85,116.86 90.8,118.81 92.28,118.81 93.43,119.96 99.19,119.96 99.34,120.12 101.69,120.12 102.47,120.9 107.85,120.9 109.64,122.7 109.64,125.6 110.49,126.45 114.23,126.45 116.56,128.78 122.06,128.78 126.72,133.44 135.82,133.44 v1(136.31,133.92)
  BOTTOM w0.102: RH22.2 16.2,113.38 16.36,113.22 16.36,113.21 16.79,112.78 16.79,112.31 CH4.2 17.79,112.33 18.62,112.33 19.65,113.37 v1(19.66,113.37) ; v4(144.64,95.02) 144.64,94.48 v1(144.12,93.96) 143.86,93.7 CMOS1.2
