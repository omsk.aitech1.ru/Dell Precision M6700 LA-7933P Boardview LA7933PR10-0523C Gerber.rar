# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLTRST_XDP#: length 92.9
  TOP w0.102: RH337.1 v2(12.38,99.75) 12.38,99.31 v1(11.78,98.72)
  TOP w0.127: v1(51.61,91.62) 51.36,91.87 47.33,91.87 v1(47.08,92.13)
  IN2 w0.127: v1(51.61,91.62) 51.61,91.61 53.47,89.75 53.47,83.97 53.33,83.83 53.33,82.86 53.57,82.61 54.1,82.61 54.66,83.17 59.18,83.17 62.06,86.06 64.53,86.06 65.47,87 65.47,89.29 66.62,90.44 73.97,90.44 75.63,88.77 v1(76.52,88.77) ; v1(11.68,93.69) 11.68,97.38 11.35,97.71 11.35,98.29 v1(11.78,98.72) ; v1(17.26,90.2) 17.32,90.13 17.58,90.13 18.61,89.1 20.67,89.1 21.92,90.35 35.8,90.35 37.18,91.73 38.2,91.73 38.9,92.43 46.77,92.43 v1(47.08,92.13)
  IN4 w0.127: v1(17.26,90.2) 15.17,90.2 v1(11.68,93.69)
  BOTTOM w0.127: v1(76.52,88.77) 76.3,88.77 75.78,88.25 75.45,88.25 75.23,88.03 75.23,87.11 75.62,86.72 RC21.1
PM_APWROK: length 257.7
  TOP w0.102: U54.A9 160.61,146.88 v1(160.48,147.02)
  IN2 w0.127: v1(18.53,94.23) 18.53,94.98 17.54,95.97 15.07,95.97 14.55,96.5 14.55,98.13 14.27,98.41 v1(14.1,98.41) 13.57,98.41 12.17,99.82 10.67,99.82 8.28,102.21 8.28,102.87 7.72,103.43 6.97,103.43 4.55,105.86 4.3,105.86 2.4,107.76 2.4,122.26 3.26,123.13 3.26,128.77 3.44,128.95 3.44,136.75 5.12,138.43 7.96,138.43 8.33,138.8 9.8,138.8 10.97,139.97 10.97,140.25 11.94,141.21 11.95,141.21 12.83,142.09 12.83,143.23 15.37,145.78 15.37,146.95 17.12,148.69 20.5,148.69 22.28,150.47 28.01,150.47 30.14,152.59 38.38,152.59 38.96,153.16 39.74,153.16 40.32,153.73 47.08,153.73 47.28,153.94 47.31,153.94 47.39,154.01 66.49,154.01 66.62,153.89 67.04,153.89 67.16,154.01 67.17,154.01 67.4,154.24 67.4,156.57 67.6,156.77 70.85,156.77 72.88,154.74 72.88,154.7 78.42,149.16 80.73,149.16 81.3,148.59 92.12,148.59 92.46,148.26 105.32,148.26 106.59,146.99 110.64,146.99 113.07,149.42 128.76,149.42 130.57,147.61 153.17,147.61 154.79,149.23 158.61,149.23 160.52,147.31 160.52,147.06 v1(160.48,147.02)
  BOTTOM w0.102: v1(18.53,94.23) 18.7,94.4 21.1,94.4 21.84,93.66 v2(23.61,93.66) 24.13,93.66 25.64,92.15 29.73,92.15 30.03,92.46 32.05,92.46 32.87,93.27 32.87,93.61 34.05,94.79 35.81,94.79 36.09,94.51 36.96,94.51 37.18,94.74 37.18,95.78 37.48,96.08 UC4.2 ; v1(14.1,98.41) 13.6,97.92 13.6,96.3 14.05,95.86 RH118.1
PM_APWROK_R: length 51.3
  TOP w0.102: v1(23.01,109.44) 23.01,109.36 22.61,108.96 UH4.L10
  IN2 w0.127: v1(14.07,97.73) 14.07,96.32 14.64,95.75 17.03,95.75 17.89,94.88 v1(17.89,94.23)
  IN4 w0.102: 22.19,105.12 22.19,108.2 22.21,108.23 22.21,108.61 23.01,109.41 v1(23.01,109.44)
  IN4 w0.109: 22.19,105.12 22.19,104.74 20.75,103.3 18.21,103.3 17.3,102.39 17.3,101.78 16.71,101.19 15.23,101.19 13.62,99.59 13.62,98.18 v1(14.07,97.73)
  BOTTOM w0.102: UC4.4 38.6,95.43 38.71,95.31 38.71,94.81 38.2,94.3 37.4,94.3 37.39,94.29 35.85,94.29 v2(35.7,94.43) 35.57,94.56 34.21,94.56 33.23,93.59 33.23,93.21 32.26,92.23 30.19,92.23 29.87,91.91 25.46,91.91 24.18,93.19 21.98,93.19 21,94.17 19.28,94.17 18.86,93.75 18.38,93.75 v1(17.89,94.23) ; RH118.2 v1(14.07,97.73)
PM_DRAM_PWRGD: length 117.8
  TOP w0.102: UC1.2 RC6.2 94.59,88.56 95.96,89.93 95.96,92 v2(85.98,101.98) 85.81,102.15 85,102.15 v1(84.56,101.7)
  TOP w0.127: v1(12.66,110.22) 12.74,110.3 RH320.1
  IN1 w0.109: v1(9.16,99.9) 8.9,99.64 8.9,98.86 11.02,96.74 23.61,96.74 24.36,95.99 33.56,95.99 33.83,95.72 36.02,95.72 36.27,95.97 44.05,95.97 45.1,94.93 46.32,94.93 46.52,95.14 50.96,95.14 51.69,94.41 53.7,94.41 53.81,94.31 53.97,94.15 55.17,94.15 55.74,93.57 61.1,93.57 61.11,93.56 65.59,93.56 69.39,97.36 71.44,97.36 72.38,98.3 72.38,98.82 73.38,99.82 74.26,99.82 75.08,100.65 82.52,100.65 83.55,101.68 84.53,101.68 v1(84.56,101.7)
  IN3 w0.127: v1(12.66,110.22) 12.66,110.15 12.03,109.51 11.2,109.51 10.77,109.08 10.77,106.82 9.85,105.91 9.85,103.43 9.61,103.19 9.61,100.58 9.16,100.13 v1(9.16,99.9)
PM_DRAM_PWRGD_R: length 4.2
  TOP w0.102: RH320.2 v2(15.48,110.3) 16.29,110.3 16.36,110.24 16.99,110.24 17.23,110.48 18.23,110.48 UH4.B13
PM_LANPHY_ENABLE: length 186.5
  TOP w0.102: UH4.C4 18.69,105.89 18.69,105.32 18.5,105.13 18.5,104.97 18.29,104.75 18.25,104.71 v1(18.25,104.6) ; v1(116.37,163.28) 116.52,163.13 R555.1
  IN2 w0.102: 16.36,106.38 16.47,106.38 v1(18.25,104.6)
  IN2 w0.127: v1(118.07,146.83) 116.46,145.21 106.54,145.21 106.24,144.91 93.36,144.91 91.19,147.07 80.67,147.07 80.32,147.42 77.88,147.42 76.49,148.81 72.22,148.81 71.88,149.15 71.88,149.89 70.83,150.94 69.05,150.94 67.92,149.81 67.26,149.81 66.53,150.54 64.14,150.54 62.24,152.44 48.02,152.44 45.59,150.01 39.75,150.01 39.19,150.57 37.79,150.57 36.19,148.97 34.58,148.97 34.15,149.4 24.03,149.4 20.18,145.56 17.53,145.56 16.26,144.28 16.26,141.92 14.48,140.14 14.01,140.14 13.23,139.36 13.23,138.58 9.05,134.4 8.15,134.4 6.5,132.75 6.5,126.73 5.09,125.32 5.09,120.41 4.82,120.14 4.82,113.44 5.57,112.69 5.57,111.38 5.71,111.24 6.31,110.64 6.43,110.64 7.5,109.57 7.5,109.49 9.17,107.82 13.17,107.82 14.62,106.38 16.36,106.38
  BOTTOM w0.102: v1(118.07,146.83) 118.07,146.99 v2(118.46,147.38) 118.62,147.54 118.62,150.41 118.92,150.72 118.92,158.38 117.44,159.86 117.44,160.77 116.99,161.22 116.99,162.85 116.74,163.11 116.55,163.11 v1(116.37,163.28)
POWER_SW#: length 5.1
  TOP w0.102: U18.26 143.57,164.62 142.71,165.48 v2(142.71,166.87) U10.4
POWER_SW#_MB: length 213.3
  TOP w0.102: v1(230.53,82.04) 231.48,82.04 232.45,81.08 242.4,81.08 243.39,82.07 260.78,82.07 263.04,79.81 275.43,79.81 275.89,80.26 276.59,80.26 277.82,81.5 277.82,82.8 280.1,85.08 281.56,85.08 281.82,85.34 281.82,87.06 281.34,87.54 281.34,88.82 282.17,89.65 v1(282.17,89.81) 282.48,90.13 282.48,91.83 282.14,92.18 276.69,92.18 276.49,91.97 JPB1.1
  IN2 w0.127: v1(230.53,82.04) 229.75,82.82 228.1,82.82 227.27,83.65 227.27,84.67 223.7,88.24 222.27,88.24 220.72,89.78 220.72,90.82 219.13,92.41 210.44,92.41 206.3,96.56 206.3,100.02 204.86,101.46 204.04,101.46 203.45,102.05 203.45,103.24 202.6,104.08 202.6,112.43 201.4,113.64 201.4,115.61 200.44,116.56 200.44,139.75 199.31,140.88 199.31,142.94 198.79,143.46 198.79,151.89 197.96,152.72 197.96,153.99 196.95,155 195.43,155 195.05,155.39 192.12,155.39 190.78,154.04 182.35,154.04 180.41,155.97 178.12,155.97 177.91,156.17 170.29,156.17 169.66,155.54 167.57,155.54 167.3,155.26 165.58,155.26 165.06,154.74 164.37,154.74 163.9,154.27 156.41,154.27 v1(156.32,154.18)
  BOTTOM w0.102: v1(156.32,154.18) 156.32,154.28 156.83,154.78 C746.1 157.36,154.75 R811.2 ; v4(282.08,90.98) 282.17,90.89 v1(282.17,89.81) 282.67,89.81 C759.1 282.81,89.95 PWRSW1.1
POWER_SW_IN#: length 36.9
  TOP w0.102: v1(163.46,150.95) 163.46,151.14 163.22,151.38 U54.B67 ; v1(143.36,170.71) U10.2
  IN3 w0.127: v1(160.31,153.47) 160.3,153.47 157.59,156.18 157.59,158.24 156.44,159.39 156.44,159.68 153.86,162.26 152.81,162.26 144.93,170.14 144.93,170.43 144.19,171.17 143.78,171.17 143.36,170.75 v1(143.36,170.71)
  BOTTOM w0.102: v1(163.46,150.95) 163.46,151.04 v2(161.95,152.55) 161.45,153.05 160.73,153.05 v1(160.31,153.47) 158.99,154.78 C757.1 158.34,153.51 R811.1 R810.2
PP: length 3.4
  TOP w0.102: R656.1 170.37,95.88 170.37,97.04 170.21,97.2 U37.7 U39.7
PROCHOT#_EC: length 7.9
  TOP w0.102: Q47.2 175.17,147.78 175.03,147.92 175.03,148.29 175.65,148.9 R1180.1 R1179.2 175.63,149.94 R812.2 174.61,149.92 v2(173.72,149.92) 172.72,149.92 172.68,149.88 U54.A46
PROCHOT_GATE: length 139.2
  TOP w0.102: v1(245.93,18.71) 245.93,17.89 241.7,13.67 227.2,13.67 226.4,14.47 226.4,19.22 v2(223.81,21.81) 222.65,22.96 209.5,22.96 208.51,23.95 208.51,53.66 209.51,54.66 215.07,54.66 215.34,54.93 237.56,54.93 241.34,58.7 241.34,64.42 242.33,65.41 242.33,69.66 242.78,70.11 243.38,70.11 243.83,70.56 244.14,70.56 244.85,71.28 244.85,75.01 243.46,76.41 v1(243.46,76.85)
  BOTTOM w0.102: v1(245.93,18.71) 245.83,18.81 PU903.2 ; v1(243.46,76.85) 243.76,77.15 244.6,77.15 244.74,77.29 R761.2 243.44,77.53 243.01,77.1 243.01,75.88 242.58,75.45 U46.A50
PS2_CLK_TS: length 192.6
  TOP w0.102: JIO1.116 33.5,11.35 33.12,11.73 v1(33.12,11.75) ; v1(81.32,107.02) 81.32,106.61 78.25,103.54 78.25,102.48 78.46,102.27 78.46,98.49 76.55,96.58 68.88,96.58 65.15,92.85 v1(64.29,92.85) ; v1(89.22,108.65) 89.15,108.71 89.15,110.3 88.75,110.71 JKB1.17 JKB1.18
  IN2 w0.127: v1(64.29,92.85) 55.93,92.85 55.62,93.16 38.58,93.16 37.87,92.44 36.89,92.44 35.5,91.05 21.51,91.05 v3(21.18,91.38) ; v1(81.32,107.02) 81.23,106.93 81.23,106.48 81.67,106.03 82.55,106.03 83.68,107.16 87.34,107.16 88.78,108.61 89.18,108.61 v1(89.22,108.65)
  IN4 w0.109: v1(33.12,11.75) 33.11,11.75 32.46,12.4 32.1,12.4 31.77,12.72 31.77,19.04 32.23,19.5 32.42,19.5 33.59,20.67 33.59,27.27 33.47,27.39 33.47,32.29 33.91,32.73 33.91,40.17 30,44.08 30,48.11 26.41,51.69 26.41,56.66 22.12,60.95 12.87,60.95 10.26,63.56 10.26,73.4 17.61,80.75 17.61,82.19 17.12,82.68 17.12,88.39 19.09,90.36 20.17,90.36 v3(21.18,91.38)
PS2_DAT_TS: length 189.2
  TOP w0.102: v1(81.77,106.57) 81.61,106.57 78.48,103.44 78.48,102.57 78.69,102.36 78.69,98.39 76.62,96.33 69.37,96.33 65.23,92.19 v1(64.3,92.19) ; v1(32.99,12.89) 33.88,12 36.15,12 JIO1.114 ; v1(88.53,110.07) 88.26,110.34 88.02,110.34 87.75,110.62 JKB1.15 JKB1.16
  IN2 w0.127: v1(88.53,110.07) 88.81,109.79 88.81,108.96 87.24,107.39 83.54,107.39 82.71,106.57 v1(81.77,106.57) ; v1(21.18,90.74) 21.26,90.82 35.59,90.82 36.99,92.22 38,92.22 38.71,92.93 55.41,92.93 55.73,92.61 63.88,92.61 v1(64.3,92.19)
  IN4 w0.109: v1(32.99,12.89) 32.89,12.99 32.89,19.63 33.82,20.56 33.82,27.37 33.69,27.49 33.69,32.19 34.14,32.63 34.14,40.32 30.22,44.23 30.22,48.2 26.64,51.78 26.64,56.81 22.19,61.27 13.07,61.27 10.51,63.82 10.51,73.33 17.84,80.65 17.84,82.34 17.35,82.83 17.35,88.15 19.35,90.15 20.25,90.15 20.85,90.74 v1(21.18,90.74)
  BOTTOM w0.102: v1(32.99,12.89) 33.16,12.89 v2(33.58,12.47)
PS_ID: length 257.2
  TOP w0.127: v1(167.67,153.33) 167.47,153.14 U54.A55
  IN2 w0.127: v1(4.66,75.32) 4.66,76.44 3.66,77.45 3.66,84.25 2.6,85.31 2.6,100.72 3.78,101.9 3.78,102.79 1.56,105.01 1.56,122.68 2.26,123.38 2.26,124.01 1.61,124.66 1.61,134.39 1.54,134.47 1.54,136.49 4.38,139.33 7.36,139.33 8.06,140.03 9.56,140.03 11.59,142.06 11.59,147.08 13.93,149.42 14.43,149.42 17.93,152.92 28.54,152.92 31.04,155.42 35.61,155.42 40.35,160.16 42.98,160.16 44.43,158.71 49.37,158.71 50.7,160.05 56.15,160.05 57.29,161.19 65.04,161.19 65.29,160.93 74.34,160.93 76.64,158.63 76.64,156.24 83.15,149.73 109.43,149.73 110.06,150.36 110.9,150.36 111.65,151.11 113.6,151.11 113.85,150.85 113.85,150.05 114.25,149.66 119.04,149.66 119.4,150.03 128.94,150.03 129.5,149.47 151.08,149.47 154.01,152.4 161.5,152.4 162.01,152.91 166.76,152.91 167.18,153.33 167.66,153.33 v1(167.67,153.33)
  BOTTOM w0.102: v2(167.51,152.81) 167.67,152.96 v1(167.67,153.33)
  BOTTOM w0.254: v1(4.66,75.32) 4.05,74.72 PU1.4
PSATA_PRX_DTX_N0: length 3.3
  BOTTOM w0.102: C418.1 213.31,89.15 213.31,88.73 212.3,87.73 212.3,87.52 212.18,87.39 U26.4
PSATA_PRX_DTX_N0_C: length 248.3
  TOP w0.102: UH4.AM3 33.14,105 32.83,104.69 32.83,104.41 33.04,104.2 33.24,104.2 33.56,103.89 33.81,103.89 33.97,103.72 33.97,102.97 v1(33.8,102.8)
  IN1 w0.117: v3(175.31,130.76) 175.02,130.47 175.02,130.21 174.62,129.81 173.38,129.81 173.03,130.16 170.14,130.16 168.8,128.81 162.02,128.81 148.82,115.61 140.63,115.61 139.85,116.39 139.63,116.39 137.61,118.41 134.69,118.41 132.67,116.39 130.09,116.39 129.98,116.28 129.98,116.27 128.42,114.71 118.13,114.71 116.97,113.56 114.75,113.56 113.71,112.52 112.58,112.52 112.21,112.15 97.79,112.15 96.27,110.64 94.17,110.64 86.38,102.85 83.22,102.85 82.08,101.71 73.95,101.71 73.3,101.06 72.97,101.06 71.21,99.31 71.03,99.31 70.17,98.45 68.77,98.45 67.7,97.38 65.18,97.38 64.8,97.76 62.95,97.76 61.46,96.27 56.6,96.27 56.36,96.52 54.97,96.52 53.98,97.51 49.56,97.51 49.28,97.79 46.42,97.79 45.96,98.25 40.82,98.25 40.11,98.96 38.25,98.96 35.23,101.98 34.4,101.98 33.96,102.42 33.96,102.65 v1(33.8,102.8)
  BOTTOM w0.102: C418.2 213.12,90.45 213.7,91.04 213.7,91.13 212.83,92 208.14,92 206.04,94.09 206.04,107.29 205.41,107.93 205.41,114.6 205.99,115.19 205.99,123.61 207.99,125.6 207.99,127.69 204.61,131.06 201.4,131.06 201.32,131.14 190.97,131.14 189.27,132.84 180.66,132.84 179.92,133.58 176.03,133.58 175.3,132.85 175.3,131.32 175.03,131.05 175.03,130.67 175.11,130.59 175.23,130.59 175.31,130.67 v3(175.31,130.76)
PSATA_PRX_DTX_N0_RP: length 53
  IN1 w0.117: v1(205.55,41.44) 205.43,41.56 205.06,41.56 204.76,41.87 204.76,44.68 206.44,46.37 206.44,56.54 212.99,63.08 212.99,66.62 217.65,71.28 217.65,75.73 216.99,76.39 216.99,79.09 215.81,80.26 212.5,80.26 212.14,80.62 v3(212.14,81.37)
  BOTTOM w0.102: v1(205.55,41.44) 205.42,41.57 205.42,41.57 204.77,41.57 C385.2 ; v3(212.14,81.37) 212.18,81.41 212.18,82.23 212.18,82.23 U26.12
PSATA_PRX_DTX_P0: length 3.3
  BOTTOM w0.102: U26.5 212.68,87.41 212.57,87.52 212.57,87.62 v1(213.08,88.13) 213.57,88.62 213.57,89.11 C421.1
PSATA_PRX_DTX_P0_C: length 248.3
  TOP w0.102: v1(34.68,102.8) 34.68,102.76 34.53,102.6 34.36,102.6 34.24,102.73 34.24,103.83 33.92,104.15 33.67,104.15 33.51,104.31 33.51,104.67 33.44,104.75 33.27,104.75 33.14,104.62 UH4.AM1
  IN1 w0.117: v3(174.54,130.76) 174.68,130.76 174.79,130.65 174.79,130.39 174.5,130.1 173.49,130.1 173.15,130.44 170.03,130.44 168.68,129.1 161.9,129.1 148.7,115.89 140.75,115.89 139.97,116.68 139.75,116.68 137.73,118.69 134.57,118.69 132.55,116.68 129.97,116.68 129.69,116.4 129.69,116.39 128.3,115 118.01,115 116.86,113.85 114.63,113.85 113.59,112.8 112.46,112.8 112.09,112.43 97.67,112.43 96.16,110.92 94.05,110.92 86.27,103.14 83.1,103.14 81.96,101.99 73.83,101.99 73.18,101.35 72.85,101.35 71.1,99.59 70.92,99.59 70.06,98.74 68.65,98.74 67.58,97.66 65.3,97.66 64.92,98.04 62.83,98.04 61.34,96.56 56.72,96.56 56.48,96.8 55.09,96.8 54.1,97.79 49.68,97.79 49.4,98.07 46.54,98.07 46.08,98.53 40.94,98.53 40.23,99.24 38.37,99.24 35.35,102.27 34.52,102.27 34.24,102.54 34.24,102.98 34.35,103.09 34.62,103.09 34.68,103.02 v1(34.68,102.8)
  BOTTOM w0.102: v3(174.54,130.76) 174.76,130.99 174.76,131.16 175.03,131.43 175.03,132.96 175.92,133.85 180.03,133.85 180.77,133.11 189.38,133.11 191.08,131.41 201.43,131.41 201.51,131.33 204.72,131.33 208.25,127.8 208.25,125.49 206.26,123.5 206.26,115.08 205.67,114.49 205.67,108.04 206.31,107.4 206.31,94.21 208.25,92.27 212.94,92.27 213.15,92.05 213.39,91.82 213.97,91.24 C421.2
PSATA_PRX_DTX_P0_RP: length 53
  IN1 w0.117: v1(212.77,81.37) 212.76,81.37 212.42,81.03 212.42,80.74 212.62,80.55 215.93,80.55 217.27,79.21 217.27,76.51 217.93,75.84 217.93,71.16 213.27,66.5 213.27,62.97 206.73,56.43 206.73,46.25 205.04,44.56 205.04,41.99 205.18,41.85 205.32,41.85 v3(205.55,42.08)
  BOTTOM w0.102: C386.2 204.8,41.83 205.31,41.83 v3(205.55,42.08) ; v1(212.77,81.37) 212.76,81.37 212.44,81.69 212.44,82.11 212.68,82.34 U26.11
PSATA_PTX_DRX_N0: length 3
  BOTTOM w0.102: C422.1 211.25,89.07 211.25,88.69 211.07,88.51 v1(211.07,88.2) 211.07,87.54 211.18,87.42 U26.2
PSATA_PTX_DRX_N0_C: length 259
  TOP w0.102: v1(211.75,91.16) 211.58,91 211.58,89.62 211.35,89.4 211.35,85.89 207.67,82.21 198.77,82.21 196.28,84.7 183.83,84.7 183.63,84.9 180.62,84.9 177.14,88.38 177.14,88.9 174.56,91.48 164.07,91.48 162.47,93.08 162.47,100.07 164.02,101.62 164.02,107.39 165.23,108.6 165.23,130.46 165.47,130.71 165.47,131.53 v3(165.47,131.53) ; UH4.AP7 34.13,107.38 34.34,107.38 v1(34.62,107.1)
  IN1 w0.117: v3(165.47,131.53) 165.48,131.53 165.48,131.09 165.35,130.96 162.64,130.96 162.27,131.32 136.52,131.32 134.44,129.24 134.44,122.64 132.8,121 129.88,121 129.18,120.3 129.18,119.77 126.89,117.48 124.43,117.48 124.26,117.32 115.54,117.32 112.91,114.68 103.96,114.68 103.45,115.19 103.45,116.37 103.01,116.81 102.9,116.81 102.35,117.36 102.35,117.57 101.26,118.66 97.44,118.66 94.21,115.43 90.9,115.43 87.03,111.56 85.58,111.56 84.47,110.45 84.47,108.89 83.68,108.1 82.15,108.1 82.01,108.23 80.53,108.23 80,107.71 73.24,107.71 72.38,106.85 72.38,106.07 69.69,103.38 68.45,103.38 67.62,102.55 63.91,102.55 63.55,102.2 61.89,102.2 61.23,101.53 61.23,101.39 60.49,100.66 56.48,100.66 55.7,101.44 49.18,101.44 48.7,101.92 42.73,101.92 41.46,103.19 41.32,103.19 39.83,104.69 39.28,104.69 37.97,105.99 36.42,105.99 35.32,107.1 v1(34.62,107.1)
  BOTTOM w0.102: C422.2 211.46,90.45 211.3,90.62 211.3,90.97 211.49,91.16 v1(211.75,91.16)
PSATA_PTX_DRX_N0_RP: length 57.8
  IN1 w0.117: v1(211.25,81.33) 210.9,80.98 210.9,80.53 211.83,79.59 215.49,79.59 216.32,78.76 216.32,75.75 217.02,75.05 217.02,72.02 212.36,67.36 212.36,64.53 207.25,59.42 207.25,58.88 204.75,56.38 204.75,52.76 204.46,52.46 204.46,48.66 203.88,48.08 203.88,38.77 204.54,38.11 205.16,38.11 205.26,38.21 v3(205.38,38.33)
  BOTTOM w0.102: C384.2 204.78,38.05 205.1,38.05 v3(205.38,38.33) ; v1(211.25,81.33) 211.22,81.33 210.95,81.61 210.95,82.13 211.18,82.37 U26.14
PSATA_PTX_DRX_P0: length 3
  BOTTOM w0.102: C423.1 210.98,89.19 210.98,88.8 210.8,88.62 210.8,87.5 210.68,87.38 U26.1
PSATA_PTX_DRX_P0_C: length 259.1
  TOP w0.102: v1(166.22,131.53) 166.09,131.53 165.73,131.18 165.73,130.59 165.49,130.35 165.49,108.49 164.29,107.28 164.29,101.51 162.74,99.96 162.74,93.19 164.18,91.75 174.67,91.75 177.4,89.01 177.4,88.49 180.73,85.17 183.74,85.17 183.94,84.96 196.39,84.96 198.88,82.47 207.56,82.47 211.09,86 211.09,89.51 211.31,89.73 211.31,91.09 211.25,91.16 v3(210.91,91.16) ; UH4.AP5 34.16,106.75 34.46,106.45 v1(34.59,106.45)
  IN1 w0.102: 41.34,102.91 41.33,102.92 41.21,102.92 39.71,104.42 39.17,104.42 37.86,105.73 36.31,105.73 35.21,106.83 34.97,106.83 34.67,106.53 34.67,106.53 v1(34.59,106.45)
  IN1 w0.117: 41.34,102.91 42.62,101.63 48.58,101.63 49.06,101.15 55.58,101.15 56.36,100.37 60.61,100.37 61.51,101.28 61.51,101.42 62.01,101.91 63.67,101.91 64.02,102.27 67.74,102.27 68.57,103.1 69.81,103.1 72.66,105.95 72.66,106.73 73.36,107.42 80.12,107.42 80.64,107.95 81.89,107.95 82.03,107.81 83.79,107.81 84.75,108.77 84.75,110.33 85.69,111.28 87.15,111.28 91.01,115.15 94.33,115.15 97.56,118.38 101.14,118.38 102.07,117.45 102.07,117.24 102.78,116.52 102.89,116.52 103.16,116.26 103.16,115.08 103.84,114.4 113.02,114.4 115.66,117.03 124.38,117.03 124.55,117.2 127.01,117.2 129.47,119.65 129.47,120.18 130,120.71 132.92,120.71 134.72,122.52 134.72,129.12 136.64,131.04 162.16,131.04 162.52,130.67 165.47,130.67 165.77,130.98 165.77,131.08 v1(166.22,131.53)
  BOTTOM w0.102: C423.2 210.67,90.45 211.02,90.81 211.02,91.05 v3(210.91,91.16)
PSATA_PTX_DRX_P0_RP: length 57.9
  IN1 w0.117: v3(210.62,81.33) 210.62,80.41 211.72,79.31 215.37,79.31 216.04,78.64 216.04,75.63 216.73,74.93 216.73,72.14 212.07,67.48 212.07,64.65 206.97,59.54 206.97,59 204.46,56.49 204.46,52.87 204.17,52.58 204.17,48.78 203.59,48.2 203.59,38.65 204.42,37.82 205.26,37.82 205.27,37.81 205.27,37.81 v1(205.38,37.69)
  BOTTOM w0.102: v3(210.62,81.33) 210.68,81.39 210.68,82.25 210.68,82.25 U26.15 ; v1(205.38,37.69) 205.29,37.78 204.79,37.78 C383.2
PSID_DISABLE#: length 363.9
  IN1 w0.127: v1(238.54,60.77) 238.42,60.9 238.42,63.06 239.94,64.59 239.94,64.95 239.53,65.36 239.53,66.46 239.28,66.71 238.4,66.71 237.17,67.95 237.17,70.21 237.7,70.74 237.7,78.31 237.42,78.59 237.42,78.59 237.16,78.85 237.03,78.85 236.31,79.58 235.77,79.58 235.47,79.27 235.47,78.87 v1(235.02,78.42)
  IN2 w0.127: v1(166.58,15.98) 166.58,15.74 165.8,14.95 165.01,14.95 164.64,15.32 162.34,15.32 162.16,15.14 162.16,14.75 161.74,14.33 158.32,14.33 156.6,12.61 155.31,12.61 155.2,12.72 131.93,12.72 131.03,11.82 127.66,11.82 126.42,13.06 125.86,13.06 124.95,12.15 120.36,12.15 117.68,14.84 117.21,14.84 116.99,15.06 114.37,15.06 111.33,12.03 110.27,12.03 109.75,11.51 107.67,11.51 104.16,8 35.47,8 34.95,8.52 33.45,8.52 33.35,8.42 31.85,8.42 31.22,9.06 31.22,9.71 30.03,10.9 30.03,18.71 29.11,19.63 29.11,21.98 29.52,22.39 29.52,24.05 28.66,24.91 28.66,25.01 27.89,25.78 27.89,34.96 27.67,35.18 27.67,40.22 28.68,41.22 28.68,45.38 26.38,47.68 26.38,56.69 22.65,60.41 7.86,60.41 v1(4.67,63.6)
  IN3 w0.127: v1(166.58,15.98) 166.62,16.02 166.62,16.56 166.05,17.13 166.05,19.41 164.12,21.34 164.12,40.38 173.82,50.09 177.8,50.09 180.73,53.02 185.46,53.02 186.52,54.08 187.97,54.08 188.76,54.86 188.76,55.82 189.32,56.38 193.69,56.38 194.75,57.44 201.55,57.44 207.69,63.59 221.7,63.59 223.37,61.93 231.55,61.93 232.65,60.83 237.17,60.83 237.79,60.2 238.23,60.2 238.54,60.52 v1(238.54,60.77)
  BOTTOM w0.127: U46.A37 235.08,78.37 v1(235.02,78.42)
  BOTTOM w0.254: v1(4.67,63.6) 4.67,59.59 4.35,59.27 2.91,59.27 2.42,59.75 v2(2.42,60.48) 2.42,60.95 2.88,61.41 PR13.2
PWM3: length 52.6
  IN3 w0.254: v1(50.01,44.32) 49.44,44.9 39.61,44.9 33.71,50.8 33.71,59.85 31.93,61.63 31.93,66.95 32.03,67.06 32.03,68.3 28.74,71.59 28.74,76.91 29.93,78.11 v1(30.71,78.11)
  BOTTOM w0.102: PR715.1 50.91,43.59 v2(51.01,43.7)
  BOTTOM w0.254: v1(50.01,44.32) 50.04,44.3 50.04,43.62 PR715.1 49.98,43.63 PR713.2
PWM3_1: length 2.8
  BOTTOM w0.102: v2(48.01,42.69) PR713.1
  BOTTOM w0.254: PU701.3 47.5,44.14 PR713.1
PWMG2: length 6.9
  TOP w0.102: v1(27.91,87.88) 27.15,87.88 v2(26.97,87.71)
  IN1 w0.508: v1(27.91,87.88) 27.47,87.88 27.02,87.44 27.02,82.87 v1(27.21,82.68)
PWR_SRC_ON: length 5.8
  BOTTOM w0.102: v2(77.35,136.6) 77.64,136.88 Q21.3 77.64,138.7 77.05,139.29 C297.2 R422.2 R423.1
PWRSHARE_EN: length 33.8
  IN1 w0.109: v1(274.7,80.54) 275.12,80.12 275.12,79.07 277.73,76.45 279.3,76.45 280.16,75.59 280.16,71.73 279.63,71.2 v1(279.63,70.68)
  IN4 w0.109: v1(279.63,70.68) 280.14,70.16 282.96,70.16 285.65,67.47 287.34,67.47 287.78,67.02 287.78,63.74 288.26,63.26 288.26,61.81 v1(287.67,61.21)
  BOTTOM w0.102: v1(287.67,61.21) Q55.2 285.35,61.21 R784.2 285.33,60.48 v2(285.04,60.19) ; v1(274.7,80.54) 274.88,80.37 275.09,80.37 275.32,80.59 U2.1
PWRSHARE_EN#: length 43.9
  IN4 w0.109: v1(287.63,62.17) 287.12,61.66 287.12,60.14 286.36,59.37 275.69,59.37 273.66,61.41 263.12,61.41 259.05,65.47 v1(256.26,65.47)
  BOTTOM w0.102: U45.4 290.71,59.39 289.88,60.22 R816.1 289.88,60.93 288.95,61.86 Q55.1 287.93,61.86 v1(287.63,62.17) v2(287.63,63.64) ; v1(256.26,65.47) 255.93,65.14 Q91.2
RBIAS_CPY: length 7.9
  TOP w0.102: UH4.BH21 41.23,114.56 41.64,114.56 42.5,115.42 42.5,115.84 42.77,116.12 44.21,116.12 45.08,115.24 v2(45.08,113.79) 45.08,113.1 RH112.2
RBIAS_SATA3: length 3.6
  TOP w0.102: RH46.1 31.6,101.93 v2(31.32,102.21) 31.32,103.1 31.24,103.18 31.24,104.45 UH4.AH1
RED_CRT: length 18.3
  IN3 w0.127: v1(60.18,159.92) 60.18,159.7 59.36,158.88 55.6,158.88 55.23,158.51 52.11,158.51 v1(51.04,159.58)
  BOTTOM w0.102: U19.33 60.57,156.94 60.07,157.44 60.07,159.8 v1(60.18,159.92) ; v1(51.04,159.58) v2(50.5,159.03) R53.1 C20.1 48.27,159.13 L1.1
RED_CRT_L: length 20.4
  TOP w0.102: v2(49.2,162.66) 48.92,162.94 v1(48.92,163.21) 48.95,163.24 C21.1 48.95,164.86 48.92,164.89 D11.3 48.92,169.13 50.66,170.87 55.29,170.87 56.5,172.07 56.5,172.36 JCRT1.1
  BOTTOM w0.102: v1(48.92,163.21) 49.46,162.67 49.46,160.35 L1.2
RED_DOCK: length 69.2
  IN3 w0.127: v1(56.28,149.95) 56.28,150.69 56.96,151.36 60.04,151.36 60.76,150.64 60.76,147.74 61.71,146.78 65.59,146.78 67.31,145.06 68.57,145.06 68.71,145.2 69.19,145.2 70.56,143.83 72.24,143.83 73.67,142.41 76.63,142.41 77.15,141.89 77.15,139.66 80.81,136 80.81,135 82.42,133.39 84.78,133.39 87.15,131.03 90.13,131.03 92.38,128.78 92.38,126.76 93.87,125.27 94.48,125.27 v1(94.96,124.79)
  BOTTOM w0.102: JDOCK1.53 95.74,120.12 95.93,120.31 95.93,123.81 v1(94.96,124.79) ; v1(56.28,149.95) 56.28,150.7 55.61,151.37 55.43,151.37 55.22,151.59 55.22,152.03 56.11,152.92 57,152.92 v2(57.05,152.97) 57.46,153.39 U19.24
REGCTL_PNP10: length 3
  TOP w0.203: 119.57,160.73 119.68,160.85 120.33,160.85 120.53,160.65 U31.7
  TOP w0.508: 119.57,160.73 118.71,159.87 L29.1
REM_DIODE1_N_4002: length 180.6
  TOP w0.254: C339.1 87.95,63.07 88.13,63.24 Q26.3 88.85,63.88 89,64.03 v1(89,64.62) ; v1(111.58,134.82) 111.58,134.79 111.36,134.58 111.36,132.37 109.02,130.02 108.52,130.02 107.39,128.89 107.39,127.41 107.73,127.06 107.73,124.78 108.06,124.45 108.06,122.13 107.03,121.1 105,121.1 104.29,120.38 104.29,118.36 104.96,117.69 104.96,111.62 106.04,110.54 106.04,100.7 111.06,95.68 111.43,95.68 v1(111.92,96.18) ; U18.35 139.07,164.53 139.26,164.71 C334.1 138.71,165.71 137.79,165.71 137.35,165.27 137.35,164.61 137.12,164.38 v1(137.09,164.38)
  IN1 w0.254: v1(113.27,148.92) 113.92,148.27 117.91,148.27 118.54,148.91 127.25,148.91 128.6,147.56 138.64,147.56 139.41,146.8 139.41,145.25 140.27,144.39 v1(140.27,140.96)
  IN4 w0.254: v1(89,64.62) 89.88,65.5 89.88,67.25 90.91,68.28 90.91,82.53 102.46,94.08 109.83,94.08 v1(111.92,96.18)
  BOTTOM w0.254: v1(113.27,148.92) 113.27,148.1 112.89,147.71 v2(112.89,145.56) 112.89,144.23 114.68,142.44 115.6,142.44 116.14,141.9 116.14,140.86 115.25,139.97 115.25,138.61 111.61,134.96 111.61,134.84 v1(111.58,134.82) ; v1(140.27,140.96) 141.72,142.41 141.72,149.78 141.02,150.48 141.02,151.36 142.02,152.36 142.02,155.75 139.09,158.69 139.09,163.11 138.05,164.15 137.32,164.15 v1(137.09,164.38)
REM_DIODE1_P_4002: length 172.5
  TOP w0.254: v1(137.76,163.64) 137.76,163.92 138.02,164.19 138.02,164.88 C334.2 138.57,164.9 U18.36 ; v1(111.26,96.27) 111.26,96.57 106.55,101.28 106.55,110.96 105.52,111.99 105.52,117.88 104.82,118.58 104.82,120.16 105.26,120.59 107.29,120.59 108.62,121.92 108.62,124.78 108.24,125.16 108.24,127.32 107.95,127.61 107.95,128.73 108.63,129.41 109.26,129.41 111.89,132.04 111.89,134.23 112.2,134.54 v1(112.2,134.67) ; C339.2 87,63 86.83,63.17 Q26.2 86.83,64.37 87.48,65.02 Q26.1 88.81,65.78 88.94,65.91 v1(88.94,65.88)
  IN1 w0.254: v1(114.44,147.69) 114.58,147.55 118.06,147.55 118.64,148.13 127.2,148.13 128.29,147.04 138.33,147.04 138.71,146.66 138.71,144.5 139.47,143.74 v1(139.47,141.08)
  IN4 w0.254: v1(88.94,65.88) 88.94,66.98 89.91,67.96 89.91,82.45 102.06,94.59 109.59,94.59 v1(111.26,96.27)
  BOTTOM w0.254: v1(114.44,147.69) 114.44,147.22 113.74,146.52 113.74,144.44 v2(114.59,143.59) 115.06,143.12 115.75,143.12 116.69,142.18 116.69,140.58 115.84,139.73 115.84,138.47 112.27,134.9 112.27,134.74 v1(112.2,134.67) ; v1(139.47,141.08) 139.65,141.08 141.1,142.53 141.1,149.47 140.45,150.11 140.45,151.56 141.41,152.53 141.41,155.64 138.53,158.52 138.53,162.87 v1(137.76,163.64)
REM_DIODE2_N_4002: length 405.2
  TOP w0.254: v1(134.62,163.46) 135.37,163.46 C344.1 135.72,163.12 136.49,163.12 137.02,162.58 U18.37 ; v1(141.58,151.18) 141.91,150.85 141.91,141.06 151.18,131.79 151.55,131.79 152.92,130.42 152.92,123.81 153.62,123.11 v1(153.88,123.11)
  IN3 w0.254: v1(141.58,151.18) 141.46,151.18 140.42,150.14 136.68,150.14 133.01,153.81 133.01,159.36 133.63,159.98 133.63,162.47 v1(134.62,163.46)
  IN4 w0.254: v1(34.8,93.84) 34.78,93.84 34.38,94.25 33.45,94.25 31.84,92.63 30.55,92.63 30.19,93 27.35,93 25.59,91.24 24.33,91.24 21.87,88.77 19.95,88.77 18.65,87.48 18.65,83.59 19.3,82.94 19.3,80.27 15.68,76.65 15.68,72.86 16.33,72.21 17.93,72.21 18.55,71.59 18.55,67.18 28.29,57.44 28.29,53.63 35.38,46.55 35.38,41.85 36.37,40.86 36.37,33.45 36.03,33.11 36.03,22.62 35.34,21.93 35.34,15.57 35.55,15.37 35.55,14.92 35.67,14.79 35.67,12.88 38.64,9.91 102.14,9.91 105.14,12.9 107.17,12.9 107.3,12.78 109.66,12.78 113.99,17.11 121.22,17.11 v1(121.22,17.11)
  BOTTOM w0.254: v1(34.8,93.84) 34.91,93.73 34.91,92.18 34.52,91.79 C340.2 33.47,90.87 Q17.3 ; v1(121.22,17.11) 121.23,17.12 121.23,17.45 120.1,18.58 120.1,22.75 124.41,27.05 124.41,37.25 122.97,38.68 122.97,53.53 119.84,56.66 119.84,58.19 119.65,58.38 119.65,62.52 122.29,65.16 122.29,76.3 117.33,81.26 117.33,97.36 117.79,97.82 129.86,97.82 133.55,101.51 152.82,101.51 154.79,103.48 v2(154.79,120.97) 154.79,121.64 153.88,122.54 v1(153.88,123.11)
REM_DIODE2_P_4002: length 402.6
  TOP w0.254: v1(134.68,162.34) 134.74,162.4 C344.2 135.65,162.57 136.26,162.57 136.76,162.08 U18.38 ; v1(154.11,124.05) 153.54,124.63 153.54,130.59 151.78,132.36 151.37,132.36 142.57,141.16 142.57,150.94 v1(142.3,151.21)
  IN3 w0.254: v1(134.68,162.34) 134.21,161.87 134.21,159.31 133.64,158.74 133.64,154.08 137.04,150.67 140.21,150.67 141.39,151.86 141.75,151.86 142.3,151.31 v1(142.3,151.21)
  IN4 w0.254: v1(121.85,17.09) 121.85,17.2 121.42,17.63 113.77,17.63 109.42,13.28 107.62,13.28 107.47,13.44 104.95,13.44 101.95,10.44 39.1,10.44 36.63,12.92 36.63,14.73 36.09,15.27 36.09,15.61 35.9,15.8 35.9,21.7 36.57,22.38 36.57,32.47 36.88,32.78 36.88,41.2 35.96,42.11 35.96,46.69 28.8,53.85 28.8,57.71 19.07,67.44 19.07,71.81 18.16,72.72 16.57,72.72 16.19,73.1 16.19,76.35 19.9,80.06 19.9,83.15 19.2,83.85 19.2,87.3 20.1,88.2 22.06,88.2 24.59,90.73 25.8,90.73 27.53,92.46 29.91,92.46 30.24,92.13 32.09,92.13 33.68,93.71 v1(34.09,93.71)
  BOTTOM w0.254: Q17.1 32.61,91.52 Q17.2 33.82,92.17 C340.1 34.39,93.41 v1(34.09,93.71) ; v1(121.85,17.09) 121.85,17.71 120.67,18.89 120.67,22.01 125.21,26.54 125.21,37.71 123.67,39.24 123.67,53.61 120.36,56.92 120.36,58.41 120.15,58.61 120.15,62.15 122.79,64.8 122.79,76.53 117.97,81.36 117.97,96.55 118.65,97.23 130.22,97.23 133.95,100.95 153.1,100.95 155.37,103.23 155.37,116.65 155.62,116.9 v2(155.62,117.54) 155.62,121.68 154.51,122.8 154.51,123.53 154.11,123.93 v1(154.11,124.05)
REM_DIODE3_N_4002: length 42.9
  TOP w0.254: U18.40 135.72,161.08 C346.1 134.83,161.32 v1(134.72,161.21)
  BOTTOM w0.254: v1(134.72,161.21) 134.59,161.21 134.21,160.83 134.21,160.36 134.83,159.74 135.25,159.74 139.05,155.94 139.05,153.87 137.63,152.45 v2(137.63,149.76) 137.63,149.34 138.44,148.53 138.44,144.36 135.72,141.64 135.72,137.06 132.62,133.96 132.62,131.15 C272.2 132.43,130.8 Q14.3
REM_DIODE3_P_4002: length 42.5
  TOP w0.254: v1(134.73,160.57) 134.93,160.37 C346.2 135.69,160.58 U18.41
  BOTTOM w0.254: v1(134.73,160.57) 135.05,160.25 135.47,160.25 v2(138.16,157.56) 139.62,156.1 139.62,153.62 138.16,152.16 138.16,149.57 139.03,148.7 139.03,144.04 136.26,141.28 136.26,136.84 133.13,133.72 133.13,131.04 C272.1 133.08,130.65 Q14.1 133.08,127.99 133.43,127.64 Q14.2
REM_DIODE4_N_4002: length 199
  TOP w0.254: v1(120.94,96.11) 120.94,113.3 125.69,118.05 125.69,119.91 126.41,120.64 126.41,126.43 129.09,129.11 129.09,130.56 129.22,130.68 v1(129.23,130.68) ; U18.43 136.72,159.58 136.05,158.92 135.6,158.92 C335.2 135.33,159.18 v1(134.76,159.18)
  IN1 w0.254: v1(168.78,59.3) 168.38,59.7 168.38,59.72 161.78,66.32 161.78,81.54 159.89,83.43 159.89,94.74 157.62,97.02 144.03,97.02 138.62,91.61 133.3,91.61 129.08,95.82 121.23,95.82 v1(120.94,96.11)
  BOTTOM w0.254: Q15.3 124.45,62.88 C288.2 125.32,64.11 125.32,75.76 119.24,81.84 119.24,94.41 v1(120.94,96.11) ; v1(129.23,130.68) 129.22,130.7 129.22,131.81 133.17,135.76 v2(133.17,145.86) 133.17,153.71 133.96,154.5 133.96,156.78 135.36,158.18 135.36,158.73 134.9,159.18 v1(134.76,159.18) ; v1(168.78,59.3) 169.3,58.78 C294.1 169.3,57.63 169.12,57.46 Q16.2 169.12,55.64 Q16.1
REM_DIODE4_P_4002: length 201.1
  TOP w0.254: v1(128.56,130.7) 128.56,129.53 125.87,126.84 125.87,120.84 125.13,120.1 125.13,118.31 120.31,113.49 120.31,96.6 v1(119.96,96.25) ; v1(134.77,158.53) 134.83,158.53 135.28,158.09 C335.1 135.7,158.31 136.13,158.31 136.9,159.08 U18.44
  IN1 w0.254: v1(168.83,60.06) 162.38,66.52 162.38,81.87 160.46,83.78 160.46,95.21 158.14,97.54 143.68,97.54 138.39,92.24 133.49,92.24 129.3,96.43 122.96,96.43 122.54,96.85 120.56,96.85 v1(119.96,96.25)
  BOTTOM w0.254: v1(119.96,96.25) 118.68,94.97 118.68,81.48 124.75,75.41 124.75,64.48 C288.1 123.32,62.72 123.15,62.55 Q15.2 123.15,60.47 Q15.1 ; v1(134.77,158.53) 134.77,158.32 133.45,157 133.45,154.79 132.62,153.96 132.62,135.95 v2(130.64,133.97) 128.56,131.89 v1(128.56,130.7) ; Q16.3 170.42,58.06 C294.2 170.25,59.14 169.33,60.06 v1(168.83,60.06)
REM_DIODE5_N_4002: length 129.2
  TOP w0.254: v1(143.25,151.11) 143.25,149.83 v2(144.91,148.18) 147.09,145.99 147.09,144.56 147.94,143.71 147.94,138.32 151.88,134.38 152.27,134.38 155.33,131.32 155.33,126.84 157.14,125.03 157.14,123.95 156.65,123.47 156.65,117.6 156.21,117.16 156.21,102.24 156.54,101.91 156.54,99.43 156.11,99 156.11,96.33 156.44,96 156.44,89.19 158.67,86.96 167.97,86.96 168.5,86.42 168.5,82.72 167.38,81.6 167.38,65.26 169.57,63.08 169.57,58.64 169.3,58.37 C349.1 169.12,58.06 Q33.3 ; v1(134.82,156.75) C347.2 135.58,156.66 136.16,156.66 136.32,156.82 136.32,157.29 137.11,158.08 U18.46
  IN3 w0.254: v1(134.82,156.75) 134.6,156.75 134.24,156.39 134.24,155.95 134.6,155.59 138.76,155.59 143.24,151.11 v1(143.25,151.11)
REM_DIODE5_P_4002: length 130.9
  TOP w0.254: U18.47 137.37,157.58 136.89,157.1 136.89,156.35 136.61,156.07 135.75,156.07 C347.1 135.11,155.8 v1(134.81,156.1) ; v1(144.09,151.13) 144.05,151.09 144.05,149.84 147.69,146.2 147.69,145.03 148.51,144.21 v2(148.51,142.49) 148.51,138.48 151.99,135 152.46,135 155.85,131.61 155.85,127.15 157.67,125.34 157.67,123.75 157.19,123.27 157.19,117.22 156.72,116.75 156.72,102.48 157.05,102.15 157.05,99.16 156.68,98.79 156.68,96.5 156.98,96.19 156.98,89.5 159,87.48 168.31,87.48 169.02,86.77 169.02,82.41 167.89,81.28 167.89,65.48 170.1,63.27 170.1,58.37 C349.2 170.42,58.06 Q33.2 169.77,56.24 Q33.1
  IN3 w0.254: v1(134.81,156.1) 139.3,156.1 144.05,151.35 144.05,151.17 v1(144.09,151.13)
RES_BIAS: length 5
  TOP w0.102: U31.12 121.08,158.33 120.98,158.23 120.98,157.65 120.05,156.72 120.05,155.78 v2(119.66,155.39) 119.28,155 R562.1
RESET_OUT#: length 237.1
  TOP w0.102: v1(170.53,144.53) 170.53,144.67 171,145.13 U54.B39 ; Q52.2 178.77,148.48 R843.2 178.74,148.4 179.69,147.45 v1(179.69,147.26)
  IN2 w0.127: v1(7.59,113.22) 7.35,113.46 7.35,113.89 6.18,115.06 6.18,115.06 5.97,115.27 5.97,119.36 7.45,120.84 7.45,121.55 8.61,122.71 8.61,124.1 7.71,125.01 7.71,132.34 8.51,133.15 12.15,133.15 13.27,134.26 13.27,136.8 17.93,141.45 18.73,141.45 20.67,143.4 32.95,143.4 34.99,141.35 35.65,141.35 36.07,140.93 36.07,140.62 36.1,140.59 36.1,140.59 36.98,139.71 38.92,139.71 39.95,140.74 41.27,140.74 41.33,140.69 43.45,140.69 43.72,140.96 43.72,142.01 44.18,142.47 49.04,142.47 49.05,142.46 49.24,142.27 49.55,142.27 50.34,141.48 50.72,141.48 51.09,141.48 52.06,142.45 52.57,142.45 61.7,142.45 62.32,143.07 63.38,143.07 63.89,143.57 65.81,143.57 66.1,143.86 68.03,143.86 68.67,143.22 70.86,143.22 71.37,142.71 73.09,142.71 73.37,142.43 73.37,141.55 73.57,141.35 73.57,140.46 74.04,139.99 74.72,139.99 75.13,139.59 79.2,139.59 82.9,143.28 85.46,143.28 86.68,142.05 91.44,142.05 92.29,142.9 108.04,142.9 108.42,143.28 118.47,143.28 119.23,144.03 128.17,144.03 129.13,143.07 130.31,143.07 130.63,143.38 132.85,143.38 133.17,143.07 145.48,143.07 148.84,139.7 154.29,139.7 155.02,138.98 158.7,138.98 159.57,138.1 164.65,138.1 165.87,136.88 165.87,135.93 166.11,135.69 166.93,135.69 167.19,135.94 167.19,136.67 168.03,137.52 168.93,137.52 169.78,138.37 171.47,138.37 171.79,138.68 171.79,139.53 172.22,139.96 v1(172.22,140.07)
  IN4 w0.109: v1(170.53,144.53) 171.73,145.72 171.73,148.06 172.31,148.64 173.39,148.64 173.73,148.3 175.41,148.3 176.91,146.8 179.23,146.8 v1(179.69,147.26)
  BOTTOM w0.102: v1(172.22,140.07) 172.22,140.32 171.84,140.7 v2(171.84,140.89) 169.92,142.81 169.92,143.94 170.51,144.53 v1(170.53,144.53) ; v1(7.59,113.22) 8.22,113.84 10.24,113.84 RH117.1 10.74,112.37 RH321.1
REXT: length 3.7
  BOTTOM w0.102: U26.20 v2(208.35,85.9) 207.6,85.9 R51.2 207.33,86.98 R84.1
REXT3: length 2.7
  TOP w0.102: U9.27 v1(40.57,148.67)
  BOTTOM w0.102: v2(41.46,149.45) R74.2 40.49,148.81 40.57,148.72 v1(40.57,148.67)
RF_+V1.05S_VCCPP: length 3.4
  BOTTOM w0.102: PR506.1 v2(58.06,27.52)
  BOTTOM w0.254: PR506.1 57.38,25.84 57.38,25.08 57.61,24.85 PU501.5
RF_+V1.05SP: length 4.2
  TOP w0.102: v2(1.95,154.5) 2.15,154.69 PU401.5
  TOP w0.254: PR406.1 3.05,155.51 3.53,155.51 3.71,155.33 PU401.5
RGB_PNL_DET: length 7.7
  TOP w0.102: v2(44.27,165.78) R341.2 44.89,165.48 Q88.1 46.33,165.96 46.11,166.18 45.96,166.18 45.11,167.03 45.11,168.14 44.88,168.36 U627.2
RGB_PNL_DET#: length 20.4
  TOP w0.102: JEDP1.18 58.74,157.04 58.9,157.2 58.9,158.73 58.37,159.26 54.43,159.26 53.73,159.96 52.93,159.96 51.56,161.33 48.72,161.33 v2(47.22,162.83) R340.2 47.22,166.42 46.98,166.66 Q88.2
RSMRST#: length 6.9
  BOTTOM w0.102: U4.3 178.31,142.78 179.73,144.2 v2(180.44,144.2) 180.96,144.2 181.68,144.91 R1622.1 181.68,146.15 181.71,146.19 U7.2
RSMRST#_XDP: length 2.8
  TOP w0.102: JXDP2.46 v2(65.57,101.07) 65.57,100.73 65.51,100.67 RH24.2
RUN_GFX_ON: length 530.5
  TOP w0.254: v1(26.74,95.11) 26.74,95.02 27.15,94.62 QH2.2 ; v1(243.61,72.68) 243.5,72.57 243.5,72.03 243.2,71.73 242.67,71.73 241.5,70.56 241.5,65.27 239.33,63.09 236.35,63.09 235.93,62.68 231.39,62.68 231.25,62.54 223.98,62.54 222.3,64.21 206.79,64.21 202.37,68.63 199.32,68.63 197.84,70.1 197.84,77.84 195.76,79.92 v2(195.62,79.92) v1(195.06,80.48)
  IN1 w0.254: v1(156.34,13.07) 156.25,12.98 156.25,12.93 155.47,12.15 154.67,12.15 154.01,11.5 132.79,11.5 132.04,10.74 122.4,10.74 120,8.34 109,8.34 107.7,7.04 35.53,7.04 34.06,8.51 31.7,8.51 30.96,9.25 30.96,10.06 27.14,13.88 27.14,17.95 27.53,18.34 27.53,21.22 27.06,21.69 27.06,23.7 24.93,25.83 24.93,34.58 27.2,36.86 27.2,39.52 28.57,40.89 28.57,44.55 27.07,46.05 27.07,56.97 24.34,59.7 13.87,59.7 8.1,65.47 8.1,72.78 9.24,73.92 9.24,83.22 12.58,86.56 12.58,93.73 12.14,94.17 12.14,95.43 12.95,96.24 23.39,96.24 24.52,95.11 v1(26.74,95.11) ; v1(183.65,173.15) 184.76,172.05 184.76,166.31 185.65,165.42 189.2,165.42 190.64,163.98 190.64,162.87 191.2,162.31 191.2,158.66 194.08,155.78 194.35,155.78 195.92,154.2 195.92,153.8 197.74,151.98 197.74,129.34 198.42,128.66 198.42,126.54 199.36,125.6 199.36,119.32 196.95,116.9 196.95,108.73 195.72,107.5 195.72,104.77 195.53,104.57 195.53,101.89 195.18,101.55 194.18,101.55 194,101.37 194,100.34 v1(194.07,100.28)
  IN3 w0.254: v1(156.34,13.07) 156.34,13.31 157.5,14.48 157.5,16.21 162.19,20.89 162.19,42.22 163.47,43.5 163.47,45.4 164.06,45.99 165.54,45.99 174.99,55.44 181.95,55.44 182.36,55.84 182.36,55.86 182.48,55.98 182.48,56.33 186.04,59.88 190.28,59.88 193.09,62.69 193.09,78.02 195.03,79.96 195.03,80.46 v1(195.06,80.48) 195.03,80.51 195.03,80.9 194.28,81.65 194.28,83.44 193.5,84.23 193.5,86.84 193.8,87.15 193.8,90.31 195.1,91.61 195.1,92.34 192.7,94.74 192.7,98.92 193.88,100.11 193.88,100.1 v1(194.07,100.28)
  BOTTOM w0.127: v1(243.61,72.68) 243.34,72.95 U46.A55
  BOTTOM w0.254: R301.1 193.36,79.08 C362.1 194.92,79.06 195.17,79.31 Q294.2 195.17,80.1 195.06,80.21 v1(195.06,80.48) ; v1(243.61,72.68) 244.35,71.95 246.6,71.95 C749.2 ; Q87.2 v1(183.65,173.15)
RUN_GFX_ON#: length 186.7
  TOP w0.254: 192.24,165.92 191.93,166.22 189.88,166.22 189.44,165.78 Q50.2 189.44,164.27 188.87,163.7 v1(187.43,163.7) ; 192.24,165.92 192.24,166.05 192.47,166.28 195.46,166.28 196.37,167.18 196.37,168.06 196.78,168.48 204.89,168.48 205.36,168.01 v1(206.96,168.01) ; 192.24,165.92 Q36.2 ; Q48.2 v2(149.13,174.24) 149.78,174.24 150.07,173.95 150.07,170.23 154.93,165.38 v1(154.93,165.37)
  IN1 w0.254: v1(187.43,163.7) 186.62,164.5 185.13,164.5 184.26,165.37 v1(154.93,165.37)
  IN3 w0.254: v1(196.99,77.34) 197.31,77.66 197.31,78.78 198.03,79.5 198.03,83.6 196.81,84.82 196.81,90.25 196.89,90.32 196.89,93.85 197.48,94.44 197.48,94.97 198.04,95.52 198.04,96.13 198.52,96.61 199.96,96.61 200.17,96.82 200.17,97.49 200.23,97.54 200.23,98.96 201.38,100.12 201.38,100.86 201.2,101.04 201.2,101.44 200.3,102.34 200.3,104.64 200.89,105.22 202.67,105.22 203.05,105.6 203.05,106.74 203.94,107.63 205.24,107.63 207.28,109.67 208.41,109.67 211.25,112.51 213.03,112.51 213.36,112.18 v1(213.82,112.18)
  IN4 w0.254: v1(206.96,168.01) 207.2,167.77 207.2,161.31 209.41,159.09 211.58,159.09 213.2,157.47 213.2,114.19 213.16,114.15 213.16,112.71 213.69,112.18 v1(213.82,112.18)
  BOTTOM w0.254: v1(196.99,77.34) 196.94,77.29 196.38,77.29 195.73,76.65 195.34,76.65 195.05,76.94 195.05,77.46 195.17,77.58 Q294.5 195.17,78.35 195.06,78.46 194.7,78.46 194.52,78.28 Q294.6 194.54,77.84 194.54,77.28 194.39,77.13 193.54,77.13 193.36,77.31 R294.2
RUN_ON: length 487.3
  TOP w0.102: v1(38.28,35.55) 37.88,35.15 37.26,35.15 37.06,35.35 JIO1.36 ; v1(213.97,78.46) 214.52,78.46 214.84,78.14 214.84,74.61 218.27,71.18 218.27,67.68 219.37,66.59 219.37,66.26 219.62,66 219.74,66 219.76,65.98 225.76,65.98 226.41,66.64 231.77,66.64 233.96,64.45 v1(234.29,64.45) ; v1(182.78,55.55) 182.78,56.18 R1621.1 ; R762.1 48.42,125.7 48.42,120.37 49.49,119.31 49.49,118.75 50.29,117.95 50.29,117.16 51.76,115.69 51.76,114.8 v1(51.66,114.69)
  IN2 w0.102: v1(17.36,104.28) 17.74,104.28 18.83,103.19
  IN2 w0.127: v1(49.03,97.31) 48.7,97.64 41.14,97.64 40.53,97.03 38.36,97.03 38.04,96.71 36.09,96.71 35.92,96.89 34.56,96.89 34.49,96.83 32.95,96.83 32.61,96.48 28.33,96.48 27.44,97.37 24.8,97.37 22.88,99.28 22.88,99.44 22.46,99.86 21.71,99.86 19.82,101.75 19.82,102.2 18.83,103.19
  IN3 w0.127: v1(17.36,104.28) 17.05,104.28 16.59,103.81 16.58,103.79 16.17,103.37 16.17,101.64 13.41,98.88 13.41,97 12.44,96.03 12.44,84.19 13.38,83.25 13.38,75.96 11.66,74.23 11.66,66.1 12.42,65.34 24.1,65.34 31.08,58.36 31.08,48.76 32.26,47.58 32.26,46.01 33.04,45.23 33.04,43.33 34.14,42.24 34.14,36.78 35.9,35.01 37.74,35.01 v1(38.28,35.55) ; v1(213.97,78.46) 213.55,78.88 212.63,78.88 212.43,78.68 212.43,78.29 212.12,77.98 208.78,77.98 207.51,79.25 199.76,79.25 198.46,77.95 198.46,68.85 199.34,67.97 199.34,61.37 198.66,60.69 191.52,60.69 190.14,59.32 185.89,59.32 183.08,56.51 183.08,55.86 v1(182.78,55.55)
  IN4 w0.109: v1(38.28,35.55) 38.28,34.46 38.67,34.06 38.91,34.06 39.29,33.68 40.68,32.3 40.68,31.18 43.21,28.64 45.04,28.64 48.12,25.57 48.42,25.57 51.46,22.53 51.46,16.19 52.81,14.85 64.66,14.85 66.55,12.95 87.37,12.95 97.9,23.48 104.11,23.48 v1(104.75,24.12) 104.75,26.03 114.48,35.76 119.66,35.76 120.48,34.94 120.48,33.28 120.95,32.8 120.95,30.12 120.54,29.7 120.54,19.97 121.03,19.48 122.55,19.48 123.14,18.88 130.68,18.88 133.47,16.09 150.2,16.09 151.7,17.59 154.14,17.59 154.7,18.16 155.22,18.16 160.5,23.43 160.5,23.9 162.1,25.5 162.1,33.09 162.1,33.09 162.1,38.98 166.37,43.24 166.37,44.47 168.22,46.32 169.44,46.32 176.89,53.77 179.2,53.77 180.74,55.31 182.54,55.31 v1(182.78,55.55)
  BOTTOM w0.102: U46.A11 235.58,65.08 R786.1 v1(234.29,64.45) ; v1(49.03,97.31) 49.15,97.31 52.22,94.23 58.71,94.23 59.22,94.74 59.22,96.15 v4(59.42,96.36) 59.42,100.98 61.45,103.01 61.45,111.24 58.94,113.75 52.56,113.75 51.73,114.58 51.73,114.63 v1(51.66,114.69) ; v1(104.75,24.12) PR304.1
  BOTTOM w0.127: PR314.1 214.22,78.21 v1(213.97,78.46)
RUN_ON_CPU1.5VS3: length 55.3
  TOP w0.254: v1(126.47,80) 125.22,78.75 v2(123.15,78.75) QC4.2 ; QC5.3 118.39,50.24 RC73.2 RC79.1 118.26,51.61 CC71.1 118.26,53.85 118.71,54.29 QC3.4 120.18,54.29 121.09,53.38 121.09,51.12 121.02,51.04 v1(121.02,50.98)
  IN4 w0.254: v1(121.02,50.98) 121.02,51.86 120.32,52.56 120.32,63.12 127.38,70.18 127.38,79.11 126.49,80 v1(126.47,80)
RUN_ON_CPU1.5VS3#: length 254.2
  TOP w0.102: 114.69,48.94 114.6,49.03 114.6,49.47 114.73,49.59 QC5.5 ; 114.69,48.94 QC5.6 ; 114.69,48.94 114.43,48.68 114.43,47.94 ; v1(110.8,48.03) 110.89,47.94 114.43,47.94 ; 114.43,47.94 114.55,47.82 RC76.2 ; Q71.2 125.72,77 126.62,77.9 126.62,77.95 v1(126.71,78.04) 126.71,78.19 126.91,78.4 126.91,80.26 126.62,80.56 108.1,80.56 106.3,82.36 98.78,82.36 98.38,81.96 QC1.2
  IN4 w0.109: v1(126.71,78.04) 126.71,78.02 126.73,77.99 126.73,70.28 119.81,63.36 119.81,62.87 119.81,62.87 119.81,50.9 120.79,49.92 132.81,49.92 136.36,53.47 141.44,53.47 142.2,52.71 148.23,52.71 149.73,54.2 156.45,54.2 157.41,55.17 166.46,55.17 167.05,55.77 168.93,55.77 177.17,64.01 178.03,64.01 179.25,62.79 190.63,62.79 192.68,64.85 202.11,64.85 207.36,59.59 220.05,59.59 221.73,61.27 236.09,61.27 v1(237.3,60.06)
  IN4 w0.127: v1(126.71,78.04) 113.78,78.04 111.36,75.63 111.36,48.59 v1(110.8,48.03)
  BOTTOM w0.102: v1(237.3,60.06) 237.36,60.06 237.7,59.72 237.7,57.96 238.02,57.65 v2(238.02,57.16) 238.02,56.77 237.91,56.66 235.47,56.66 235.28,56.46 Q72.2
RUN_ON_ENABLE#: length 528.4
  TOP w0.102: v1(43.92,130.9) 43.92,130.89 43.18,130.15 43.18,125.36 44.19,124.35 44.21,124.35 44.54,124.02 R909.2 45.57,124.62 Q304.5 45.57,125.76 45.69,125.88 46.15,125.88 46.23,125.81 46.23,125.36 Q304.6 ; v1(153.81,150.33) 153.88,150.26 Q45.2 153.88,147.7 153.68,147.5 153.68,140.08 157.4,136.37 157.75,136.37 158.94,135.18 158.94,131.27 159.87,130.34 159.87,112.98 v2(159.08,112.19) 158.37,111.48 v1(158.37,106.57)
  IN1 w0.109: v1(203.49,51.58) 203.49,52.82 203.82,53.15 203.82,56.78 206.25,59.21 206.25,59.88 211.25,64.88 211.25,67.81 215.41,71.97 215.41,77.89 215.32,77.98 211.71,77.98 211.48,78.21 211.48,78.59 209.99,80.07 209.99,81.37 211.01,82.39 214.51,82.39 218.15,86.02 218.15,89.7 217.12,90.73 v1(217.12,91.28)
  IN2 w0.127: v1(217.12,91.28) 216.44,91.95 210.25,91.95 205.84,96.37 205.84,98.98 204.77,100.05 202.68,100.05 201.08,101.65 199.45,101.65 197.83,103.28 197.83,104.22 197.3,104.74 197.3,107.13 196.77,107.66 196.77,110.41 192.89,114.3 192.89,128.35 192.95,128.41 192.95,139.7 188.57,144.08 188.57,149.27 188.06,149.78 v1(187.43,149.78) 187.37,149.84 175.78,149.84 175.49,150.13 171.97,150.13 171.41,149.57 165.02,149.57 164.15,150.44 158.62,150.44 157.99,151.08 154.77,151.08 153.92,150.23 153.91,150.23 v1(153.81,150.33) ; v1(158.37,106.57) 157.86,106.06 143.86,106.06 143.72,105.92 131.8,105.92 130.08,107.63 128.98,107.63 128.14,108.47 122.91,108.47 122.49,108.89 102.81,108.89 101.79,109.91 101.79,111.2 99.91,113.08 94.47,113.08 92.1,115.46 86.54,115.46 86.44,115.35 74.19,115.35 73.68,115.86 72.59,115.86 67.52,120.93 67.52,129.96 64.47,133.01 63.88,133.01 63.68,133.22 62.58,133.22 62.43,133.38 55.55,133.38 55.03,133.9 52.57,133.9 51.12,132.45 47.14,132.45 46.56,131.86 44.94,131.86 43.98,130.9 v1(43.92,130.9)
  IN3 w0.127: v1(290.3,53.02) 290.3,48.25 296.06,42.48 296.06,23.28 294.98,22.2 274.59,22.2 266.3,13.92 251.05,13.92 248.64,16.33 248.64,22.51 243.4,27.75 219.23,27.75 207.9,39.08 207.9,51.5 206.01,53.39 205.31,53.39 v1(203.49,51.58)
  BOTTOM w0.102: v1(43.92,130.9) 43.92,130.86 44.18,130.59 Q70.2 ; Q67.2 217.23,91.39 v1(217.12,91.28) ; Q59.2 291.75,53.8 291.56,53.98 Q69.2 290.82,53.55 v1(290.3,53.02) ; v1(187.43,149.78) Q68.2 ; v1(203.49,51.58) 204.11,51.58 204.96,50.73 208.17,50.73 208.52,51.08 Q61.2
RUNPWROK: length 291.5
  TOP w0.102: Q45.1 v1(154.53,147.87) ; v1(165.23,136.75) 165.76,136.22 165.76,132.88 164.59,131.71 164.59,108.84 163.17,107.42 163.17,101.65 161.85,100.33 161.85,92.8 164.07,90.58 171.33,90.58 174.01,87.9 174.01,87.2 177.36,83.86 178.92,83.86 187.34,75.44 187.34,71.7 v1(188.7,70.35) ; v1(166.72,143.37) U54.B26 ; v1(98.93,85.7) 98.93,86.98 98.37,87.54 95.5,87.54 95.24,87.28 UC1.1
  IN1 w0.109: v1(154.53,147.87) 155.78,146.62 155.78,140.51 v1(156.01,140.28) ; v1(166.72,143.37) 166.72,142.75 166.08,142.1 166.08,140.42 165.25,139.6 165.25,136.78 v1(165.23,136.75)
  IN3 w0.127: v1(223.38,64.03) 223.9,63.51 224.89,63.51 225.14,63.77 233.34,63.77 233.79,64.22 233.79,64.68 234.57,65.46 234.57,66.08 234.91,66.43 235.66,66.43 236.09,66.85 238.19,66.85 v1(239.08,65.96)
  IN4 w0.109: v1(188.7,70.35) 188.28,70.35 187.51,71.12 183.94,71.12 182.07,69.25 180.52,69.25 167.7,82.07 161.69,82.07 160.44,83.33 154.1,83.33 152.65,84.78 151.63,84.78 151.13,84.28 151.13,83.96 150.67,83.51 144.62,83.51 144.07,84.06 135.74,84.06 135.09,83.41 130.26,83.41 117.5,96.18 113.22,96.18 109.36,92.32 104.26,92.32 98.93,86.99 v1(98.93,85.7)
  BOTTOM w0.102: v1(239.08,65.96) U46.A4 ; v1(188.7,70.35) 189.89,69.15 202.74,69.15 205.04,66.85 216,66.85 218.82,64.03 v1(223.38,64.03) ; v1(165.23,136.75) 165.23,136.45 162.96,134.19 157.67,134.19 155.83,136.03 v4(155.83,138.74) 155.83,140.11 v1(156.01,140.28) 156.06,140.34 157.3,140.34 R799.2
S3_1.5V: length 3.9
  BOTTOM w0.203: PR214.2 v2(233.96,47.59) 233.96,46.42 233.47,45.93 PU201.7
S5_1.5V: length 4.5
  BOTTOM w0.203: 233.99,45.87 234.6,45.87 PC213.1 ; 233.99,45.87 233.93,45.87 233.59,45.53 PU201.8 ; 233.99,45.87 v2(233.97,45.85)
  BOTTOM w0.254: PC213.1 PR226.2 PR210.2
SATA3_COMP: length 2.4
  TOP w0.102: UH4.AB13 28.16,110.64 27.84,110.31 ; v3(27.7,110.31) 27.84,110.31 ; 27.84,110.31 27.85,110.31 28.18,109.98 UH4.AB12
  BOTTOM w0.102: v3(27.7,110.31) 27.72,110.34 RH42.1
SATA_ACT#: length 264.7
  TOP w0.102: v1(25.1,102.43) 24.97,102.43 24.5,102.91 24.5,103.36 24.55,103.41 24.55,104.66 24.33,104.88 24.33,105.32 UH4.P3
  IN1 w0.109: v1(221.64,66.56) 221.45,66.37 221.45,56.99 223.05,55.39 234.19,55.39 234.68,55.88 v1(234.68,56.46)
  IN2 w0.127: v1(25.1,102.43) 25.48,102.43 25.92,102.87 26.33,102.87 27.12,102.08 27.9,102.08 28.77,101.21 29.74,101.21 30.49,101.96 31.2,101.96 31.88,102.63 32.38,102.63 32.71,102.3 35.96,102.3 37.36,103.69 42.2,103.69 42.87,103.02 47.42,103.02 47.55,102.9 51.16,102.9 52.79,104.52 55.76,104.52 56.94,105.7 61.42,105.7 69.8,97.32 73.44,97.32 73.9,97.78 73.9,98.67 74.67,99.44 78.56,99.44 79.07,98.93 82.15,98.93 82.79,99.57 108.63,99.57 109.85,98.35 128.79,98.35 131.6,101.17 149.15,101.17 150.75,99.57 172.8,99.57 174.66,97.71 174.66,96.06 175.31,95.41 175.31,95.41 177.99,92.74 179.63,92.74 181.3,91.07 181.97,91.07 183.91,89.13 183.91,85.64 186.58,82.97 186.58,69.87 190.15,66.29 200.8,66.29 202.02,65.08 202.89,65.08 203.81,64.16 214.27,64.16 217.87,67.76 220.78,67.76 221.31,67.22 221.64,66.89 v1(221.64,66.56)
  BOTTOM w0.102: v1(221.64,66.56) v2(221.64,65.96) ; Q74.4 234.43,56.72 v1(234.68,56.46)
SATA_COMP: length 4.3
  TOP w0.102: UH4.Y11 27.5,108.98 v3(27.69,108.98) 27.36,108.65 UH4.Y10
  BOTTOM w0.102: v3(27.69,108.98) 28.26,109.55 28.88,109.55 29.13,109.3 29.13,108.51 29.21,108.43 RH40.1
SATA_LED: length 258
  TOP w0.102: v1(37.49,17.46) 37.43,17.46 37.31,17.35 JIO1.96
  IN1 w0.109: v1(169.58,15.15) 167.79,13.36 159.42,13.36 156.22,16.56 152.28,16.56 149.99,14.26 128.36,14.26 127.87,14.76 119.88,14.76 117.84,16.8 113.87,16.8 111.2,14.12 109.88,14.12 108.96,13.21 108.36,13.21 107.85,12.7 105.03,12.7 102.3,9.97 37.86,9.97 33.3,14.53 33.3,16.85 33.81,17.36 37.33,17.36 37.43,17.46 v1(37.49,17.46)
  IN3 w0.127: v1(230.62,60.03) 230.6,60.03 230.08,60.55 224.22,60.55 224.2,60.54 222.74,60.54 221.07,62.22 208.94,62.22 201.06,54.34 193.8,54.34 193.55,54.09 193.55,54.08 190.66,51.19 187.88,51.19 187.29,50.6 182.03,50.6 180.13,48.69 174.37,48.69 166.51,40.84 166.51,35.52 165.89,34.89 165.89,24.53 169.58,20.83 v1(169.58,15.15)
  BOTTOM w0.102: v1(230.62,60.03) 230.68,60.1 230.68,60.94 R934.2 ; v2(35.99,16.84) 36.61,17.46 v1(37.49,17.46)
SATA_NVR_PRX_DTX_N2: length 2.7
  TOP w0.102: C448.2 32.36,144.05 32.36,144.72 31.94,145.14 31.94,145.38 31.82,145.5 U12.23
