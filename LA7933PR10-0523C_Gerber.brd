# Allegro board LA7933PR10-0523C_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_C_N5: length 201.9
  TOP w0.089: JCPU1.K31 70.02,50.45 v1(70.5,49.97)
  IN3 w0.089: v1(70.5,49.97) 70.5,49.97 70.1,50.37 68.63,50.37 68.61,50.36 68.11,50.36 67.71,50.76 67.71,51.12 67.46,51.37 67.05,51.37 67.04,51.38 66.71,51.38 66.7,51.37 66.2,51.37 66.19,51.38 65.96,51.38 65.9,51.32 65.04,51.32 64.63,51.73 64.63,54.15 65.06,54.58 65.53,54.58 65.75,54.8 65.75,55.18 66.13,55.56 66.47,55.56 66.72,55.81 66.72,72.27 66.8,72.35 66.8,73.45 66.72,73.53 66.72,75.35 66.88,75.51 66.88,78.37 66.83,78.42 66.83,78.55
  IN3 w0.14: v1(199.97,135.94) 199.73,135.7 197.77,135.7 195.43,133.35 195.43,129.99 183.6,118.16 183.5,118.16 183.5,118.16 179.49,118.16 177.7,116.37 175.51,116.37 175.37,116.51 175.37,116.59 175.11,116.85 174.57,116.85 174.3,116.59 174.3,116.51 174.1,116.31 173.33,116.31 173.13,116.51 173.13,116.58 172.85,116.85 172.2,116.85 171.92,116.58 171.92,116.43 171.8,116.31 171.35,116.31 171.23,116.43 171.23,116.59 170.95,116.87 169.62,116.87 169.12,116.37 164.55,116.37 160.24,112.07 121.1,112.07 118.37,109.33 97.83,109.33 87.81,99.31 84.65,99.31 81.69,96.36 78.32,96.36 75.04,93.08 74.65,93.08 70.94,89.37 70.94,87.94 70.59,87.59 70.37,87.59 69.58,86.81 69.58,86.43 69.65,86.37 69.65,82.71 66.83,79.89 66.83,78.55
  BOTTOM w0.109: CC38.2 200.58,135.79 200.13,135.79 v1(199.97,135.94)
PEG_CTX_GRX_C_N6: length 208.8
  TOP w0.089: JCPU1.K28 72.9,50.62 72.55,50.97 v3(72.53,50.97)
  IN3 w0.089: 74.41,78.02 74.39,77.99 74.2,77.99 73.8,77.59 73.8,66.04 73.79,66.04 73.79,64.72 73.8,64.72 73.8,53.29 72.94,52.43 72.94,51.37 v3(72.53,50.97)
  IN3 w0.14: 74.41,78.02 74.95,78.55 75.46,79.07 75.46,79.33 75.93,79.8 75.93,81.31 77.8,83.18 77.8,83.26 88.2,93.65 89.82,93.65 99.5,103.33 120.04,103.33 122.62,105.91 130.11,105.91 130.76,105.26 144.06,105.26 144.44,105.65 147.66,105.65 148.05,105.26 151.18,105.26 151.83,105.91 169.92,105.91 170.05,106.04 170.05,107.92 170.33,108.19 171.21,108.19 171.49,107.92 171.49,106.07 171.62,105.94 172.06,105.94 172.19,106.07 172.19,107.85 172.46,108.13 176.44,108.13 176.72,107.85 176.72,105.91 176.85,105.78 177.48,105.78 177.61,105.91 177.61,107.52 177.88,107.8 178.62,107.8 178.89,107.52 178.89,106.9 179.02,106.77 180.21,106.77 181.13,107.69 181.13,109.11 181.4,109.39 182.27,109.39 182.56,109.09 182.56,108.1 182.69,107.98 183.27,107.98 183.42,108.13 183.42,109.11 184.92,110.6 187.26,110.6 191.23,114.57 191.23,117.51 194.13,120.41 196.81,120.41 200.32,123.92 200.32,124.73 201.78,126.19 201.78,127.05 201.71,127.12 201.71,131.13 202.34,131.76 202.98,131.76 204.19,132.97 204.19,135.72 203.62,136.29 203.62,137.49 203.92,137.8 204.15,137.8 v1(204.42,138.06)
  BOTTOM w0.109: v1(204.42,138.06) 204.63,137.85 204.97,137.85 CC39.2
PEG_CTX_GRX_C_N7: length 209.6
  TOP w0.089: v1(71.51,48.92) 71.51,48.96 71.02,49.45 JCPU1.J30
  IN3 w0.089: v1(71.51,48.92) 71.51,48.96 71.11,49.36 69.32,49.36 69.08,49.12 69.08,48.67 68.75,48.34 66.12,48.34 65.71,48.75 65.71,49.69 64.1,51.29 64.1,54.95 64.76,55.61 65.51,55.61 65.71,55.81 65.71,60.8 65.71,60.81 65.71,61.13 65.71,61.13 65.71,71.79 65.71,75.28 66.19,75.76 66.19,77.92 66.04,78.07 66.04,78.47
  IN3 w0.14: v3(199.97,139.38) 199.72,139.13 197.35,139.13 197.01,138.78 197.01,138.06 197.33,137.73 197.73,137.73 197.84,137.63 197.84,136.86 197.09,136.12 196.2,136.12 194.54,134.46 194.54,130.22 184.02,119.7 183.99,119.7 183.23,118.94 179.17,118.94 177.87,117.64 168.32,117.64 167.87,117.18 164.22,117.18 159.87,112.84 120.78,112.84 118.07,110.12 97.52,110.12 87.49,100.09 84.28,100.09 81.41,97.22 78.01,97.22 74.67,93.88 73.42,93.88 71.93,92.39 71.93,92.14 69.56,89.77 69.56,88.55 69.42,88.41 69.42,88.08 68.38,87.03 68.38,84.85 67.8,84.28 67.8,81.97 66.04,80.2 66.04,78.47
  BOTTOM w0.109: CC40.2 200.59,139.23 200.13,139.23 v3(199.97,139.38)
PEG_CTX_GRX_C_N8: length 205.7
  TOP w0.089: v1(72.53,49.98) 72.53,49.97 72.9,49.6 JCPU1.J28
  IN3 w0.089: 69.74,78.53 69.74,78.52 69.76,78.49 69.76,78.44 69.79,78.41 69.79,77.49 69.87,77.4 69.87,76.74 69.79,76.66 69.79,55.82 69.55,55.58 69.1,55.58 68.81,55.28 68.81,53.42 68.79,53.4 68.79,52.75 69.13,52.41 69.65,52.41 69.86,52.2 69.86,51.8 70.28,51.38 70.67,51.38 71.49,50.56 72.02,50.56 72.22,50.36 72.5,50.36 72.62,50.24 72.62,50.06 v1(72.53,49.98)
  IN3 w0.14: 69.74,78.53 69.74,79.52 72.66,82.43 72.66,83.19 72.96,83.49 72.96,84.33 73.43,84.8 73.43,85.91 75.78,88.25 76.86,88.25 77.25,88.65 77.25,90.09 79.16,91.99 79.16,92.79 80.11,93.74 83.32,93.74 86.46,96.88 88.66,96.88 98.79,107.01 103.22,107.01 103.72,106.5 118.83,106.5 122.01,109.68 148.38,109.68 148.95,109.11 150.38,109.11 150.98,109.72 161.45,109.72 165.28,113.54 178.16,113.54 179.47,114.85 185.9,114.85 186.66,115.61 186.66,117.69 194.18,125.21 196.57,125.21 197.17,125.81 197.17,129.42 200.49,132.74 200.49,138.91 200.75,139.17 200.96,139.17 201.09,139.29 201.09,139.73 200.96,139.85 200.4,139.85 200.35,139.9 199.8,139.9 199.53,140.18 199.53,140.71 199.8,140.98 200.31,140.98 200.43,141.1 200.44,141.1 v3(200.62,141.29)
  BOTTOM w0.109: CC41.2 201.12,141.11 200.8,141.11 v3(200.62,141.29)
PEG_CTX_GRX_C_N9: length 206.2
  TOP w0.089: v3(72.53,48.94) 72.53,48.93 72.52,48.93 72.38,48.93 71.9,48.45 JCPU1.H29
  IN3 w0.089: 76.76,78.55 76.76,78.51 76.07,77.82 75.35,77.82 74.79,77.26 74.79,68.12 74.88,68.03 74.88,50.71 73.76,49.59 73.75,49.59 73.72,49.56 72.95,49.56 72.73,49.35 72.73,49.14 v3(72.53,48.94)
  IN3 w0.14: v1(204.42,142.81) 204.23,142.62 204.1,142.62 203.76,142.28 203.76,141.8 204.11,141.44 204.11,139.73 205.05,138.79 205.05,132.68 203.05,130.67 203.05,128.46 202.55,127.97 202.55,125.87 201.14,124.46 201.14,123.65 197.81,120.32 197.81,119.88 196.98,119.05 194.46,119.05 192.07,116.67 192.07,114.31 187.58,109.82 185.24,109.82 184.3,108.89 184.3,107.54 183.87,107.11 181.91,107.11 180.27,105.47 180.27,105.12 180.06,104.9 175.95,104.9 175.71,105.14 158.46,105.14 158.17,104.85 158.17,104.63 158.03,104.49 157.61,104.49 157.47,104.63 157.47,104.85 157.19,105.14 156.56,105.14 156.27,104.85 156.27,104.63 156.13,104.49 155.71,104.49 155.57,104.63 155.57,104.85 155.28,105.14 154.65,105.14 154.36,104.85 154.36,104.63 154.22,104.49 153.93,104.49 153.78,104.64 153.78,104.88 153.52,105.14 152.15,105.14 151.5,104.49 147.7,104.49 147.46,104.72 144.66,104.72 144.42,104.49 122.3,104.49 120.35,102.54 99.81,102.54 90.14,92.88 88.52,92.88 79.29,83.65 79.29,83.08 78.64,82.42 78.28,82.42 76.76,80.91 76.76,78.55
  BOTTOM w0.109: v1(204.42,142.81) 204.54,142.69 204.98,142.69 CC42.2
PEG_CTX_GRX_C_N10: length 217
  TOP w0.089: v3(74.45,48.02) 73.9,47.47 JCPU1.G27
  IN3 w0.089: 77.87,78.55 77.87,78.16 76.68,76.96 76.31,76.96 75.99,76.64 75.99,68.54 75.61,68.16 75.61,50.61 74.09,49.09 74.09,48.39 74.45,48.03 v3(74.45,48.02)
  IN3 w0.14: 77.87,78.55 77.87,79.48 78.26,79.86 78.53,79.86 79.32,80.65 79.32,81.54 80.38,82.6 80.38,83.28 88.89,91.8 90.68,91.8 100.33,101.45 120.71,101.45 121.81,102.55 123.33,102.55 123.62,102.83 123.62,103.33 123.75,103.46 124.34,103.46 124.48,103.32 124.48,102.73 124.76,102.45 125.41,102.45 125.69,102.73 125.69,103.32 125.83,103.46 145.64,103.46 146.08,103.02 150.46,103.02 150.89,103.46 160.21,103.46 160.5,103.75 160.5,103.98 160.62,104.11 162.97,104.11 163.1,103.98 163.1,103.75 163.39,103.46 164.02,103.46 164.31,103.75 164.31,103.98 164.43,104.11 164.88,104.11 165.01,103.98 165.01,103.75 165.29,103.46 165.92,103.46 166.21,103.75 166.21,103.98 166.34,104.11 166.78,104.11 166.91,103.98 166.91,103.75 167.2,103.46 167.83,103.46 168.12,103.75 168.12,103.98 168.24,104.11 168.69,104.11 168.82,103.98 168.82,103.75 169.1,103.46 169.73,103.46 170.02,103.75 170.02,103.98 170.15,104.11 172.5,104.11 172.63,103.98 172.63,103.75 172.91,103.46 173.54,103.46 173.83,103.75 173.83,103.98 173.96,104.11 174.4,104.11 174.53,103.98 174.53,103.75 174.82,103.46 177.57,103.46 177.71,103.32 177.71,103.17 177.99,102.9 178.64,102.9 178.92,103.17 178.92,103.32 179.06,103.46 180.94,103.46 181.45,103.97 181.45,104.97 181.76,105.28 182.58,105.28 182.71,105.16 182.71,103.74 182.98,103.46 183.96,103.46 184.24,103.74 184.24,105.14 185.18,106.08 186.26,106.08 186.51,106.33 186.51,108.28 186.79,108.56 187.78,108.56 193.14,113.92 193.14,116.16 194.93,117.96 197.35,117.96 198.86,119.47 198.86,119.91 203.73,124.78 203.96,124.78 204.47,125.29 204.47,128.08 205.08,128.69 205.08,131.24 206.08,132.25 206.08,139.27 205.33,140.02 205.33,144 205.33,144.21 204.95,144.59 204.59,144.59 204.58,144.58 204.56,144.58 v1(204.42,144.72)
  BOTTOM w0.109: v1(204.42,144.72) 204.54,144.59 204.98,144.59 CC43.2
PEG_CTX_GRX_C_N11: length 217.3
  TOP w0.089: JCPU1.E29 72.1,45.45 72.44,45.11 v1(72.44,44.96)
  IN3 w0.089: 78.79,78.55 78.79,78.54 78.81,78.51 78.81,78.41 77.56,77.15 77.43,77.15 76.79,76.51 76.79,72.44 76.79,50.98 76.02,50.21 76.02,49.76 75.81,49.55 75.22,49.55 74.92,49.25 74.92,47.74 74.73,47.55 73.21,47.55 72.85,47.19 72.85,45.37 72.44,44.96 v1(72.44,44.96)
  IN3 w0.14: 78.79,78.55 78.79,79.3 80.01,80.52 80.01,81.1 81.29,82.38 81.29,83.46 89.08,91.25 90.87,91.25 100.55,100.93 120.93,100.93 121.89,101.89 126.26,101.89 127.31,102.94 145.31,102.94 145.74,102.5 150.87,102.5 151.31,102.94 160.5,102.94 160.69,103.12 162.82,103.12 163,102.94 169.78,102.94 169.95,102.77 172.12,102.77 172.52,102.38 180.74,102.38 181.31,102.94 186.21,102.94 186.84,103.57 186.84,105.76 187.86,106.77 187.86,107.36 188.87,108.37 190.6,108.37 191.46,109.23 191.46,111.5 193.5,113.54 195.07,113.54 199.68,118.15 199.68,120 203.83,124.14 204.06,124.14 205.01,125.1 205.01,127.89 205.6,128.48 205.6,131.01 206.6,132.02 206.6,139.48 206.09,139.99 206.09,144.23 205.04,145.28 203.59,145.28 203.21,145.66 203.21,146.39 203.52,146.7 204.15,146.7 204.46,147 v3(204.47,147)
  BOTTOM w0.109: CC44.2 205.09,146.86 204.61,146.86 v3(204.47,147)
PEG_CTX_GRX_C_N12: length 225.4
  TOP w0.089: JCPU1.F27 73.74,46.45 73.48,46.19 v1(73.48,45.92)
  IN3 w0.089: 79.87,78.55 79.87,78.05 78,76.19 78,68.48 77.55,68.02 77.55,50.47 76.88,49.8 76.88,49.16 75.81,48.08 75.81,47.92 75.81,47.44 74.57,46.21 73.71,46.21 73.48,45.97 v1(73.48,45.92)
  IN3 w0.14: v3(209.9,144.97) 209.65,144.72 209.65,143.3 209.37,143.03 208.65,143.03 208.53,142.9 208.53,142.46 208.65,142.33 209.68,142.33 209.95,142.05 209.95,141.23 209.68,140.96 208.52,140.96 208.39,140.83 208.39,140.39 208.52,140.26 209.73,140.26 210.01,139.98 210.01,139.28 209.73,139 208.92,139 208.8,138.88 208.8,138.47 208.92,138.34 209.34,138.34 209.65,138.02 209.65,137.24 209.47,137.06 209.47,133.42 206.64,130.59 206.64,123.94 205.98,123.28 204.65,123.28 204.52,123.15 204.52,122.56 204.65,122.43 206.38,122.43 206.66,122.15 206.66,121.46 206.38,121.18 202.32,121.18 200.76,119.62 200.76,117.73 195.08,112.05 194.38,112.05 194.02,112.41 193.82,112.41 193.53,112.11 193.53,111.91 193.88,111.56 193.88,111.16 192.61,109.88 192.61,108.48 192.44,108.32 192.44,107.24 191.92,106.72 191.52,106.72 191,107.24 190.82,107.24 190.5,106.93 190.5,106.75 191.02,106.23 191.02,105.82 188,102.8 187.73,102.8 186.42,101.49 182.23,101.49 182.14,101.58 181.79,101.58 181.16,100.94 178.73,100.94 178.34,101.33 172.02,101.33 171.64,101.71 167.97,101.71 167.77,101.91 164.03,101.91 163.68,101.56 151.62,101.56 151.42,101.36 144.88,101.36 144.33,101.91 127.76,101.91 126.71,100.86 122.32,100.86 121.32,99.86 100.94,99.86 91.26,90.18 89.47,90.18 82.32,83.03 82.32,81.13 80.9,79.71 80.68,79.71 79.87,78.89 79.87,78.55
  BOTTOM w0.109: CC45.2 210.16,145.87 209.75,145.47 209.75,145.12 v3(209.9,144.97)
PEG_CTX_GRX_C_N13: length 225.7
  TOP w0.089: v3(72.44,43.89) 72.48,43.89 72.9,44.31 JCPU1.D28
  IN3 w0.089: v3(72.44,43.89) 72.59,43.89 72.66,43.82 72.67,43.82 72.71,43.78 72.71,43.78 73.17,43.33 73.93,43.33 74.3,43.7 74.3,45.33 75.19,46.21 75.24,46.21 75.25,46.22 75.58,46.22 75.59,46.21 76.46,46.21 76.88,46.64 76.88,47.26 76.99,47.37 77.54,47.37 77.93,47.75 77.93,49.34 79.01,50.42 79.01,67.37 79,67.38 79,76.21 80.46,77.67 80.63,77.67 81.24,78.28 81.24,78.45 81.32,78.53
  IN3 w0.14: v1(207.36,149.04) 207.37,149.03 208.67,149.03 210.78,146.91 210.78,136.89 210.29,136.4 210.29,122.13 205.82,117.67 202.6,117.67 201.27,116.33 201.27,114.08 200.47,113.28 198.5,113.28 195.41,110.2 195.41,108.52 191.29,104.4 191.29,103.84 187.31,99.86 185.7,99.86 185.49,99.64 178.74,99.64 178.26,100.13 172.08,100.13 171.28,100.93 167.65,100.93 167.46,101.12 164.35,101.12 163.94,100.71 152.3,100.71 152.11,100.52 144.51,100.52 143.91,101.12 128.16,101.12 127.08,100.04 125.96,100.04 124.41,98.49 109.09,98.49 108.55,99.04 101.21,99.04 91.55,89.37 90.22,89.37 84.25,83.4 84.06,83.4 83.58,82.92 83.58,80.49 83.01,79.92 82.71,79.92 81.32,78.53
  BOTTOM w0.109: CC46.2 206.89,148.84 207.17,148.84 v1(207.36,149.04)
PEG_CTX_GRX_C_N14: length 228
  TOP w0.089: v1(75.42,45.82) 74.9,46.34 JCPU1.F26
  IN3 w0.089: 82.83,78.48 82.82,78.47 82.82,78.45 82.83,78.44 82.78,78.39 82.78,78.35 82.13,77.71 81.19,77.71 79.8,76.32 79.8,65.6 80.39,65.01 80.39,54.99 79.51,54.11 79.51,49.91 78.73,49.12 78.73,47.77 78.46,47.51 78.08,47.51 77.74,47.16 77.74,45.78 77.58,45.62 76,45.62 75.86,45.48 75.69,45.48 75.42,45.75 v1(75.42,45.82)
  IN3 w0.14: 82.83,78.48 84.1,79.75 84.1,81.79 86.35,84.04 87.36,84.04 91.33,88.01 91.33,88.42 100.79,97.88 127.3,97.88 129.55,100.13 143.63,100.13 144.01,99.75 171.63,99.75 171.85,99.52 177.4,99.52 177.8,99.12 185.74,99.12 185.95,99.34 187.53,99.34 191.95,103.76 191.95,104.24 196.72,109.02 196.72,109.22 196.32,109.62 196.32,110.01 196.78,110.47 197.17,110.47 197.74,109.91 197.92,109.91 198.33,110.32 198.33,110.5 197.89,110.94 197.89,111.38 198.59,112.08 201.4,112.08 201.84,112.51 201.84,115.74 202.34,116.24 205.63,116.24 210.81,121.42 210.81,135.73 211.3,136.22 211.3,148.43 211.16,148.58 210.15,148.58 209.24,149.49 209.24,150.92 209.52,151.19 210.24,151.19 210.51,150.92 210.51,150.04 210.65,149.9 210.93,149.9 v3(211.07,150.04)
  BOTTOM w0.109: CC47.2 210.15,150.34 210.58,149.91 210.95,149.91 v3(211.07,150.04)
PEG_CTX_GRX_C_N15: length 227.9
  TOP w0.089: v5(76.38,45) 76.25,45 75.9,45.35 JCPU1.E25
  IN3 w0.089: 83.17,77.51 82.43,76.77 81.41,76.77 81.02,76.38 81.02,66.53 81.39,66.16 81.39,55.27 81.7,54.96 81.7,53.92 80.44,52.66 80.44,48.7 79.98,48.24 79.98,47.57 79.75,47.33 79.2,47.33 78.94,47.08 78.94,45.62 78.68,45.36 78.26,45.36 78,45.11 78,43.69 77.67,43.36 76.13,43.36 75.78,43.71 75.78,44.31 76.38,44.91 v5(76.38,45)
  IN3 w0.14: v3(211.05,152.08) 211.18,151.95 211.19,151.95 211.2,151.96 211.94,151.96 212.44,151.45 212.44,126.98 212.02,126.56 212.02,117.84 210.7,116.52 210.7,115 208.76,113.06 204.05,113.06 199.96,108.97 198.65,108.97 198.09,108.41 197.6,108.41 196.01,106.82 196.01,106.11 195.23,105.33 194.52,105.33 193.14,103.94 193.14,103.45 187.98,98.3 186.37,98.3 186.17,98.1 177.3,98.1 176.98,98.42 171.36,98.42 171.06,98.72 143.52,98.72 143.19,99.05 130.3,99.05 128.04,96.79 101.15,96.79 92.36,88 92.36,87.59 85.88,81.1 85.88,80.07 85.8,80 84.18,78.37 83.31,77.51 83.17,77.51
  BOTTOM w0.109: v3(211.05,152.08) 210.86,151.9 210.56,151.9 CC48.2
PEG_CTX_GRX_C_P0: length 184.4
  TOP w0.089: v1(72.52,52.96) 72.52,52.67 72.74,52.45 JCPU1.M28
  IN3 w0.089: 74.08,78.42 73.65,77.99 73.3,77.99 72.93,77.62 72.93,76.91 73,76.84 73,54.61 72.72,54.33 72.31,54.33 72.04,54.07 72.04,53.26 71.96,53.18 71.96,53.01 72.03,52.93 72.5,52.93 v1(72.52,52.96)
  IN3 w0.14: 74.08,78.42 74.93,79.27 74.93,79.54 75.36,79.97 75.36,81.48 76.34,82.46 76.34,83.03 76.62,83.31 77.07,83.31 78.74,84.99 78.74,86.24 79.15,86.65 80.46,86.65 87.99,94.18 89.62,94.18 99.31,103.87 119.85,103.87 122.41,106.43 130.33,106.43 130.98,105.79 143.78,105.79 144.18,106.19 147.89,106.19 148.29,105.79 150.97,105.79 152.24,107.06 159.51,107.06 159.67,106.9 163.98,106.9 164.48,107.39 165.72,107.39 167.86,109.54 170.5,109.54 170.9,109.13 171.85,109.13 172.04,108.94 175.77,108.94 176.06,109.23 176.06,109.8 176.18,109.93 176.52,109.93 176.65,109.8 176.65,109.19 177,108.84 179,108.84 179.13,108.71 180,108.71 180.61,109.31 180.61,109.33 181.19,109.91 181.2,109.91 181.21,109.92 182.81,109.92 184.92,112.03 186.96,112.03 188.17,113.25 189.17,113.25 190.71,114.78 190.71,117.94 193.86,121.1 196.75,121.1 199.74,124.08 199.74,125.56 200.62,126.44 201,126.44 v3(201.14,126.29)
  BOTTOM w0.109: v3(201.14,126.29) 201.32,126.47 201.32,126.47 201.64,126.47 CC49.2
PEG_CTX_GRX_C_P1: length 183.7
  TOP w0.089: JCPU1.M33 67.84,52.45 v3(67.3,52.99)
  IN3 w0.089: 68.7,78.43 68.76,78.37 68.76,67.38 68.81,67.34 68.81,55.85 68.52,55.57 68.12,55.57 67.8,55.25 67.8,54.15 67.75,54.1 67.75,53.36 67.88,53.23 67.88,53.12 67.74,52.99 v3(67.3,52.99)
  IN3 w0.14: 68.7,78.43 68.59,78.54 68.59,79.47 71.72,82.59 71.72,85.31 72.11,85.7 72.11,86.57 72.68,87.14 73.15,87.14 73.53,87.52 73.53,88.32 76.23,91.02 77.08,91.02 78.34,92.28 78.34,93.21 79.83,94.69 82.35,94.69 85.35,97.69 88.38,97.69 98.47,107.78 119.01,107.78 121.72,110.49 160.9,110.49 165.16,114.75 178.27,114.75 179.28,115.76 183.77,115.76 183.89,115.88 183.89,116.32 184.16,116.6 184.82,116.6 185.09,116.32 185.09,115.88 185.21,115.76 185.64,115.76 185.89,116.01 185.89,118.06 194.38,126.56 196.21,126.56 196.39,126.74 196.39,127.14 196.27,127.25 196.12,127.25 v1(195.93,127.06)
  BOTTOM w0.109: CC50.2 196.48,127.32 196.19,127.32 v1(195.93,127.06)
PEG_CTX_GRX_C_P2: length 195.9
  TOP w0.089: JCPU1.M30 70.68,52.45 70.48,52.64 70.48,52.89 v1(70.47,52.91)
  IN3 w0.089: 71.18,78.44 71.18,78.14 70.98,77.93 70.98,55.7 70.67,55.39 70.29,55.39 70,55.1 70,53.3 69.94,53.25 69.94,52.94 70.04,52.85 70.39,52.85 70.46,52.91 v1(70.47,52.91)
  IN3 w0.14: 71.18,78.44 71.91,79.17 72.49,79.17 73.32,80 73.32,80.15 73.77,80.61 73.77,82.61 74.53,83.38 74.53,85.34 75.14,85.95 76.15,85.95 78.54,88.34 78.54,89.86 81.38,92.71 84.09,92.71 87.16,95.78 89.03,95.78 98.72,105.47 119.26,105.47 122.36,108.58 130.38,108.58 131.6,107.35 141.91,107.35 143.14,108.59 147.72,108.59 148.96,107.35 150.34,107.35 151.65,108.66 160.47,108.66 160.62,108.51 163.18,108.51 163.97,109.3 164.17,109.3 164.32,109.15 164.71,109.15 165.17,109.62 165.17,110.01 165.02,110.15 165.02,110.35 165.32,110.65 165.52,110.65 165.72,110.44 166.11,110.44 166.58,110.9 166.58,111.3 166.71,111.43 168.22,111.43 168.53,111.74 168.53,112.32 168.65,112.45 175.01,112.45 175.15,112.31 175.15,111.78 175.44,111.49 176.07,111.49 176.35,111.78 176.35,112.37 176.48,112.5 177.3,112.5 177.43,112.37 177.43,111.81 177.71,111.53 178.53,111.53 178.8,111.81 178.8,112.7 178.98,112.88 180.01,112.88 180.29,113.16 180.29,113.69 180.41,113.82 180.78,113.82 180.91,113.69 180.91,111.96 181.19,111.68 181.78,111.68 182.05,111.96 182.05,113.1 182.17,113.22 183.05,113.22 183.65,113.82 186.33,113.82 187.3,114.8 187.74,114.8 188.8,115.85 188.8,118.37 193.86,123.43 196.82,123.43 198.19,124.8 198.19,128.81 198.73,129.34 v3(199.6,129.34)
  BOTTOM w0.109: CC51.2 200.11,129.52 199.8,129.52 199.8,129.52 199.78,129.52 v3(199.6,129.34)
PEG_CTX_GRX_C_P3: length 196.5
  TOP w0.089: v1(69.44,51.98) 69.47,51.95 69.47,51.79 69.81,51.45 JCPU1.L31
  IN3 w0.089: v1(69.44,51.98) 69.44,51.97 69.7,51.72 69.7,51.49 69.62,51.41 69.07,51.41 67.9,52.58 66.26,52.58 66.03,52.81 66.03,54.04 66.28,54.29 66.66,54.29 66.97,54.6 66.97,55.15 67.19,55.37 67.49,55.37 67.99,55.87 67.99,67.49 67.92,67.57 67.92,78.52 67.95,78.55
  IN3 w0.14: v3(199.97,132.96) 199.81,133.12 198.28,133.12 198.02,133.39 198.02,133.62 197.89,133.74 197.29,133.74 197.17,133.62 197.17,132.17 197.31,132.03 197.83,132.03 198.11,131.75 198.11,131.1 197.83,130.82 197.31,130.82 197.17,130.68 197.17,130.2 184.1,117.13 184.03,117.13 184.03,117.13 183.18,117.13 179.92,117.13 178.05,115.27 164.93,115.27 160.69,111.02 121.52,111.02 118.8,108.3 98.26,108.3 88.19,98.24 85.16,98.24 82.19,95.26 79.48,95.26 77.15,92.94 77.15,92.05 76.66,91.56 75.25,91.56 72.6,88.91 72.6,88.06 71.29,86.75 71.29,86.42 71.19,86.32 71.19,82.81 67.95,79.56 67.95,78.55
  BOTTOM w0.109: v3(199.97,132.96) 200.18,133.16 200.62,133.16 CC52.2
PEG_CTX_GRX_C_P4: length 200.8
  TOP w0.089: JCPU1.L28 72.9,51.61 v1(72.52,51.99)
  IN3 w0.089: v1(72.52,51.99) 72.24,51.99 71.64,52.59 71.25,52.59 71.09,52.75 71.09,53.19 71.02,53.26 71.02,55.11 71.26,55.35 71.71,55.35 71.99,55.63 71.99,76.37 71.82,76.54 71.82,77.56 71.98,77.72
  IN3 w0.14: 71.98,77.72 72.23,77.72 73.06,78.55 74.12,79.6 74.12,79.83 74.55,80.26 74.55,81.86 75.53,82.84 75.53,83.34 76.27,84.09 76.71,84.09 77.96,85.34 77.96,86.65 78.89,87.58 79.46,87.58 80.2,88.32 80.2,90.42 81.56,91.78 84.5,91.78 87.72,95.01 89.35,95.01 99.01,104.67 119.55,104.67 122.09,107.21 130.65,107.21 131.3,106.56 143.25,106.56 143.82,107.14 148.04,107.14 148.62,106.56 150.64,106.56 151.97,107.89 159.99,107.89 160.19,107.68 163.59,107.68 164.14,108.24 165.47,108.24 167.75,110.52 168.45,110.52 168.53,110.44 169.38,110.44 169.65,110.72 169.65,111.53 169.79,111.67 170.21,111.67 170.35,111.53 170.35,110.73 170.63,110.45 171.28,110.45 171.56,110.73 171.56,111.53 171.7,111.67 172.12,111.67 172.26,111.53 172.26,111.01 172.54,110.72 173.17,110.72 173.46,111.01 173.46,111.53 173.59,111.66 174.03,111.66 174.16,111.53 174.16,111.01 174.45,110.72 182.52,110.72 183.67,111.87 183.67,112.64 184.07,113.04 186.65,113.04 187.62,114.02 188.06,114.02 189.57,115.53 189.57,118.05 194.17,122.64 197.21,122.64 198.97,124.41 198.97,125.91 200.51,127.45 200.51,129.08 200.65,129.22 200.9,129.22 201.19,129.51 201.19,130.14 200.9,130.43 200.65,130.43 200.51,130.57 200.51,131.13 200.66,131.28 201.01,131.28 201.74,132 201.74,133.93 201.91,134.1 202.91,134.1 203.11,134.3 203.43,134.3 v1(203.55,134.18)
  BOTTOM w0.109: v1(203.55,134.18) 203.8,134.42 203.98,134.42 CC53.2
PEG_CTX_GRX_C_P5: length 201.9
  TOP w0.089: JCPU1.K30 70.75,50.45 70.5,50.7 v1(70.5,50.98)
  IN3 w0.089: v1(70.5,50.98) 70.75,50.73 70.75,50.52 70.64,50.41 70.35,50.41 70.18,50.58 68.55,50.58 68.53,50.56 68.2,50.56 67.96,50.8 67.96,50.8 67.94,50.82 67.94,51.2 67.57,51.58 67.55,51.58 67.54,51.59 67.48,51.59 67.47,51.58 67.14,51.58 67.13,51.59 66.63,51.59 66.62,51.58 66.29,51.58 66.28,51.59 65.88,51.59 65.81,51.52 65.13,51.52 64.83,51.82 64.83,54.07 65.14,54.38 65.61,54.38 65.95,54.72 65.95,55.1 66.21,55.36 66.56,55.36 66.91,55.71 66.91,72.18 66.99,72.26 66.99,73.55 66.91,73.62 66.91,75.26 67.08,75.42 67.08,78.55
  IN3 w0.14: 67.08,78.55 67.08,79.79 69.9,82.61 69.9,86.47 69.84,86.54 69.84,86.7 70.47,87.34 70.7,87.34 71.19,87.83 71.19,89.26 74.75,92.82 75.14,92.82 78.42,96.1 81.8,96.1 84.76,99.06 87.92,99.06 97.93,109.08 118.48,109.08 121.21,111.81 160.35,111.81 164.65,116.12 169.23,116.12 169.72,116.61 170.84,116.61 170.97,116.48 170.97,116.33 171.25,116.05 171.9,116.05 172.18,116.33 172.18,116.47 172.3,116.6 172.75,116.6 172.88,116.47 172.88,116.4 173.23,116.05 174.21,116.05 174.56,116.4 174.56,116.48 174.67,116.6 175,116.6 175.12,116.48 175.12,116.4 175.41,116.12 177.81,116.12 179.6,117.91 183.5,117.91 183.5,117.91 183.71,117.91 195.68,129.88 195.68,133.25 197.88,135.45 199.83,135.45 v3(199.97,135.31)
  BOTTOM w0.109: CC54.2 200.65,135.53 200.2,135.53 v3(199.97,135.31)
PEG_CTX_GRX_C_P6: length 208.8
  TOP w0.089: v1(73.56,50.97) 73.58,50.97 73.9,50.64 JCPU1.K27
  IN3 w0.089: v1(73.56,50.97) 73.42,50.83 73.23,50.83 73.14,50.91 73.14,52.34 74,53.21 74,64.63 74,64.8 74,64.81 74,65.95 74,65.96 74,77.51 74.28,77.79 74.54,77.79 75.3,78.55
  IN3 w0.14: 75.3,78.55 75.72,78.96 75.72,79.22 76.19,79.69 76.19,81.2 78.06,83.08 78.06,83.15 88.3,93.4 89.93,93.4 99.6,103.07 120.15,103.07 122.73,105.66 130.01,105.66 130.66,105.01 144.16,105.01 144.55,105.4 147.56,105.4 147.94,105.01 151.29,105.01 151.93,105.66 170.03,105.66 170.31,105.93 170.31,107.81 170.43,107.94 171.11,107.94 171.24,107.81 171.24,105.97 171.51,105.69 172.17,105.69 172.44,105.97 172.44,107.75 172.57,107.87 176.34,107.87 176.46,107.75 176.46,105.8 176.74,105.52 177.59,105.52 177.86,105.8 177.86,107.42 177.99,107.54 178.51,107.54 178.64,107.42 178.64,106.79 178.91,106.52 180.31,106.52 181.38,107.58 181.38,109 181.51,109.13 182.16,109.13 182.31,108.99 182.31,108 182.58,107.72 183.37,107.72 183.68,108.03 183.68,109 185.02,110.34 187.37,110.34 191.48,114.46 191.48,117.41 194.23,120.16 196.91,120.16 200.57,123.81 200.57,124.63 202.03,126.09 202.03,127.16 201.96,127.23 201.96,131.02 202.45,131.51 203.08,131.51 204.44,132.87 204.44,135.83 203.87,136.4 203.87,137.39 204.02,137.54 204.3,137.54 v3(204.42,137.43)
  BOTTOM w0.109: CC55.2 204.95,137.64 204.63,137.64 v3(204.42,137.43)
PEG_CTX_GRX_C_P7: length 209.6
  TOP w0.089: v3(71.52,49.95) 71.45,49.88 71.45,49.64 71.64,49.45 JCPU1.J29
  IN3 w0.089: 66.29,78.55 66.29,78.12 66.39,78.02 66.39,75.68 65.91,75.2 65.91,72.21 65.91,71.71 65.91,71.7 65.91,61.22 65.92,61.21 65.92,60.72 65.91,60.72 65.91,55.72 65.6,55.41 64.85,55.41 64.31,54.86 64.31,51.38 65.91,49.77 65.91,48.83 66.2,48.54 68.67,48.54 68.83,48.71 68.83,49.3 69.09,49.56 71.2,49.56 71.35,49.42 71.68,49.42 71.78,49.52 71.78,49.76 71.59,49.95 v3(71.52,49.95)
  IN3 w0.14: v1(199.97,138.75) 199.85,138.88 197.46,138.88 197.26,138.68 197.26,138.16 197.44,137.99 197.84,137.99 198.09,137.73 198.09,136.76 197.2,135.87 196.3,135.87 194.79,134.35 194.79,130.11 184.12,119.44 184.1,119.44 183.34,118.68 179.28,118.68 177.98,117.39 168.43,117.39 167.97,116.93 164.32,116.93 159.98,112.59 120.89,112.59 118.17,109.87 97.63,109.87 87.6,99.84 84.38,99.84 81.51,96.97 78.12,96.97 74.78,93.62 73.52,93.62 72.18,92.29 72.18,92.04 69.81,89.66 69.81,88.44 69.67,88.31 69.67,87.97 68.63,86.93 68.63,84.74 68.06,84.17 68.06,81.86 66.29,80.1 66.29,78.55
  BOTTOM w0.109: CC56.2 200.64,138.98 200.2,138.98 v1(199.97,138.75)
PEG_CTX_GRX_C_P8: length 205.7
  TOP w0.089: JCPU1.J27 73.9,49.64 73.58,49.96 v3(73.56,49.96)
  IN3 w0.089: v3(73.56,49.96) 73.54,49.98 73.19,49.98 72.61,50.57 72.31,50.57 72.11,50.76 71.58,50.76 70.75,51.59 70.36,51.59 70.07,51.88 70.07,52.36 69.83,52.6 69.22,52.6 68.98,52.84 68.98,53.24 69,53.25 69,55.16 69.21,55.37 69.64,55.37 69.98,55.72 69.98,76.56 70.08,76.65 70.08,77.49 69.99,77.57 69.99,78.53
  IN3 w0.14: 69.99,78.53 69.99,79.41 72.91,82.33 72.91,83.08 73.21,83.39 73.21,84.23 73.68,84.7 73.68,85.8 75.88,88 76.96,88 77.51,88.54 77.51,89.98 79.41,91.88 79.41,92.68 80.21,93.49 83.43,93.49 86.57,96.62 88.77,96.62 98.9,106.75 103.11,106.75 103.61,106.25 118.94,106.25 122.11,109.42 148.27,109.42 148.84,108.85 150.48,108.85 151.09,109.46 161.56,109.46 165.38,113.28 178.26,113.28 179.57,114.59 186,114.59 186.92,115.51 186.92,117.59 194.29,124.96 196.67,124.96 197.42,125.7 197.42,129.31 200.75,132.64 200.75,138.81 200.85,138.91 201.07,138.91 201.34,139.19 201.34,139.83 201.07,140.11 200.51,140.11 200.46,140.16 199.91,140.16 199.78,140.28 199.78,140.6 199.91,140.73 200.55,140.73 v1(200.62,140.65)
  BOTTOM w0.109: CC57.2 201.18,140.9 200.87,140.9 v1(200.62,140.65)
PEG_CTX_GRX_C_P9: length 206.2
  TOP w0.089: JCPU1.H28 73,48.45 73.48,48.93 v1(73.48,48.97)
  IN3 w0.089: 77.02,78.55 77.02,78.48 76.16,77.62 75.44,77.62 74.99,77.17 74.99,68.2 75.08,68.11 75.08,50.62 73.82,49.36 73.03,49.36 72.93,49.26 72.93,48.98 73.02,48.9 73.4,48.9 v1(73.48,48.97)
  IN3 w0.14: v3(204.42,142.18) 204.33,142.27 204.18,142.27 204.01,142.1 204.01,141.9 204.37,141.55 204.37,139.84 205.31,138.9 205.31,132.58 203.3,130.57 203.3,128.36 202.8,127.86 202.8,125.76 201.4,124.36 201.4,123.54 198.07,120.22 198.07,119.78 197.09,118.8 194.56,118.8 192.33,116.56 192.33,114.21 187.69,109.57 185.34,109.57 184.55,108.78 184.55,107.44 183.97,106.86 182.02,106.86 180.53,105.37 180.53,105.02 180.16,104.65 175.84,104.65 175.61,104.88 158.57,104.88 158.43,104.74 158.43,104.52 158.14,104.24 157.51,104.24 157.22,104.52 157.22,104.74 157.08,104.88 156.66,104.88 156.52,104.74 156.52,104.52 156.23,104.24 155.6,104.24 155.32,104.52 155.32,104.74 155.18,104.88 154.76,104.88 154.62,104.74 154.62,104.52 154.33,104.24 153.83,104.24 153.53,104.53 153.53,104.77 153.42,104.88 152.26,104.88 151.61,104.24 147.59,104.24 147.36,104.47 144.76,104.47 144.53,104.24 122.4,104.24 120.45,102.29 99.91,102.29 90.25,92.62 88.62,92.62 79.54,83.54 79.54,82.97 78.74,82.17 78.38,82.17 77.02,80.8 77.02,78.55
  BOTTOM w0.109: v3(204.42,142.18) 204.44,142.18 204.7,142.43 204.98,142.43 CC58.2
PEG_CTX_GRX_C_P10: length 217.1
  TOP w0.089: v1(73.48,47.96) 73.43,47.96 72.92,47.45 JCPU1.G28
  IN3 w0.089: 77.62,78.55 77.62,78.54 77.65,78.51 77.65,78.46 77.67,78.43 77.67,78.24 76.59,77.16 76.22,77.16 75.78,76.72 75.78,68.62 75.41,68.25 75.41,50.69 73.89,49.17 73.89,48.27 73.96,48.2 73.96,48.03 73.89,47.96 v1(73.48,47.96)
  IN3 w0.14: v3(204.42,144.08) 204.67,144.34 204.85,144.34 205.08,144.1 205.08,139.91 205.83,139.16 205.83,132.35 204.82,131.35 204.82,128.8 204.21,128.19 204.21,125.4 203.85,125.03 203.62,125.03 198.6,120.01 198.6,119.57 197.24,118.21 194.83,118.21 192.89,116.27 192.89,114.02 187.68,108.81 186.69,108.81 186.26,108.38 186.26,106.44 186.16,106.34 185.07,106.34 183.98,105.25 183.98,103.84 183.86,103.72 183.09,103.72 182.96,103.84 182.96,105.26 182.69,105.54 181.66,105.54 181.2,105.08 181.2,104.08 180.84,103.72 178.95,103.72 178.66,103.43 178.66,103.28 178.54,103.15 178.09,103.15 177.96,103.28 177.96,103.43 177.68,103.72 174.92,103.72 174.78,103.85 174.78,104.09 174.51,104.36 173.85,104.36 173.58,104.09 173.58,103.85 173.44,103.72 173.02,103.72 172.88,103.85 172.88,104.09 172.6,104.36 170.04,104.36 169.77,104.09 169.77,103.85 169.63,103.72 169.21,103.72 169.07,103.85 169.07,104.09 168.79,104.36 168.14,104.36 167.86,104.09 167.86,103.85 167.72,103.72 167.3,103.72 167.16,103.85 167.16,104.09 166.89,104.36 166.23,104.36 165.96,104.09 165.96,103.85 165.82,103.72 165.4,103.72 165.26,103.85 165.26,104.09 164.98,104.36 164.33,104.36 164.05,104.09 164.05,103.85 163.91,103.72 163.49,103.72 163.35,103.85 163.35,104.09 163.08,104.36 160.52,104.36 160.24,104.09 160.24,103.85 160.1,103.72 150.79,103.72 150.35,103.28 146.19,103.28 145.75,103.72 125.72,103.72 125.43,103.43 125.43,102.83 125.31,102.71 124.86,102.71 124.73,102.83 124.73,103.43 124.45,103.72 123.64,103.72 123.37,103.44 123.37,102.94 123.23,102.8 121.7,102.8 120.61,101.7 100.23,101.7 90.58,92.05 88.79,92.05 80.12,83.38 80.12,82.71 79.06,81.65 79.06,80.76 78.43,80.12 78.15,80.12 77.62,79.58 77.62,78.55
  BOTTOM w0.109: v3(204.42,144.08) 204.67,144.34 205.07,144.34 CC59.2
PEG_CTX_GRX_C_P11: length 217.3
  TOP w0.089: v3(73.5,44.91) 72.96,45.45 JCPU1.E28
  IN3 w0.089: v3(73.5,44.91) 73.44,44.86 73,44.86 72.91,44.95 72.91,45.13 73.05,45.27 73.05,47.11 73.29,47.35 74.82,47.35 75.12,47.66 75.12,49.17 75.3,49.35 75.9,49.35 76.23,49.68 76.23,50.13 77,50.9 77,71.38 77,76.43 77.52,76.95 77.65,76.95 79.04,78.35 79.04,78.55
  IN3 w0.14: v1(204.47,146.37) 204.39,146.44 203.63,146.44 203.47,146.28 203.47,145.76 203.69,145.54 205.15,145.54 206.35,144.34 206.35,140.1 206.86,139.59 206.86,131.91 205.85,130.91 205.85,128.37 205.27,127.79 205.27,124.99 204.16,123.89 203.93,123.89 199.93,119.89 199.93,118.04 195.18,113.28 193.6,113.28 191.72,111.39 191.72,109.13 190.7,108.12 188.98,108.12 188.11,107.25 188.11,106.67 187.09,105.65 187.09,103.47 186.31,102.69 181.42,102.69 180.85,102.12 172.41,102.12 172.02,102.51 169.84,102.51 169.67,102.69 162.9,102.69 162.71,102.87 160.79,102.87 160.61,102.69 151.41,102.69 150.98,102.25 145.64,102.25 145.2,102.69 127.41,102.69 126.36,101.64 122,101.64 121.03,100.67 100.66,100.67 90.98,91 89.19,91 81.55,83.35 81.55,82.27 80.26,80.99 80.26,80.42 79.04,79.2 79.04,78.55
  BOTTOM w0.109: CC60.2 205.21,146.65 204.75,146.65 v1(204.47,146.37)
PEG_CTX_GRX_C_P12: length 225.5
  TOP w0.089: v3(73.49,46.94) 73,46.45 JCPU1.F28
  IN3 w0.089: 79.61,78.55 79.61,78.54 79.64,78.51 79.64,78.46 79.67,78.43 79.67,78.14 77.81,76.28 77.81,68.57 77.35,68.11 77.35,50.55 76.68,49.88 76.68,49.25 75.6,48.17 75.6,48 75.6,47.53 74.48,46.41 73.5,46.41 73.46,46.46 73.46,46.9 v3(73.49,46.94)
  IN3 w0.14: v1(209.27,144.97) 209.4,144.84 209.4,143.41 209.27,143.28 208.55,143.28 208.27,143.01 208.27,142.35 208.55,142.08 209.57,142.08 209.7,141.95 209.7,141.34 209.57,141.21 208.41,141.21 208.14,140.94 208.14,140.28 208.41,140.01 209.62,140.01 209.75,139.88 209.75,139.38 209.62,139.26 208.82,139.26 208.54,138.98 208.54,138.36 208.82,138.08 209.23,138.08 209.4,137.92 209.4,137.34 209.22,137.16 209.22,133.53 206.39,130.7 206.39,124.05 205.87,123.53 204.54,123.53 204.27,123.26 204.27,122.45 204.54,122.17 206.28,122.17 206.41,122.05 206.41,121.56 206.28,121.43 202.21,121.43 200.51,119.73 200.51,117.83 194.98,112.3 194.48,112.3 194.13,112.66 193.72,112.66 193.27,112.21 193.27,111.81 193.63,111.45 193.63,111.27 192.35,109.99 192.35,108.59 192.19,108.42 192.19,107.34 191.82,106.98 191.62,106.98 191.1,107.5 190.71,107.5 190.25,107.03 190.25,106.64 190.77,106.12 190.77,105.93 187.9,103.05 187.62,103.05 186.31,101.75 182.33,101.75 182.25,101.83 181.68,101.83 181.05,101.19 178.84,101.19 178.45,101.59 172.12,101.59 171.74,101.97 168.07,101.97 167.88,102.17 163.92,102.17 163.57,101.82 151.52,101.82 151.32,101.61 144.99,101.61 144.43,102.17 127.65,102.17 126.6,101.12 122.21,101.12 121.21,100.11 100.83,100.11 91.16,90.44 89.37,90.44 82.07,83.14 82.07,81.23 80.79,79.96 80.58,79.96 79.61,79 79.61,78.55
  BOTTOM w0.109: CC61.2 209.54,145.49 209.54,145.24 v1(209.27,144.97)
PEG_CTX_GRX_C_P13: length 225.6
  TOP w0.089: v1(73.48,43.97) 73.48,44.25 73.68,44.45 JCPU1.D27
  IN3 w0.089: v1(73.48,43.97) 73.48,44.06 73.26,44.29 73.04,44.29 72.86,44.11 72.86,43.93 73.25,43.53 73.85,43.53 74.1,43.78 74.1,45.41 75.1,46.41 75.15,46.41 75.17,46.43 75.67,46.43 75.68,46.41 76.37,46.41 76.68,46.72 76.68,47.34 76.91,47.57 77.46,47.57 77.72,47.84 77.72,49.42 78.8,50.5 78.8,67.64 78.81,67.65 78.81,76.38 80.32,77.89 80.56,77.89 80.99,78.32 80.99,78.55
  IN3 w0.14: 80.99,78.55 81.06,78.62 81.06,78.63 82.61,80.18 82.9,80.18 83.32,80.6 83.32,83.02 83.95,83.66 84.14,83.66 90.11,89.62 91.44,89.62 101.1,99.29 108.65,99.29 109.2,98.74 124.3,98.74 125.85,100.29 126.97,100.29 128.05,101.37 144.02,101.37 144.62,100.78 152,100.78 152.19,100.97 163.84,100.97 164.24,101.37 167.57,101.37 167.76,101.18 171.39,101.18 172.19,100.38 178.36,100.38 178.84,99.9 185.38,99.9 185.6,100.11 187.21,100.11 191.04,103.95 191.04,104.5 195.16,108.62 195.16,110.3 198.39,113.54 200.36,113.54 201.01,114.19 201.01,116.44 202.5,117.92 205.71,117.92 210.03,122.24 210.03,136.5 210.53,137 210.53,146.81 208.56,148.77 207.81,148.77 207.43,148.4 v1(207.36,148.4)
  BOTTOM w0.109: CC62.2 206.8,148.63 207.13,148.63 v1(207.36,148.4)
PEG_CTX_GRX_C_P14: length 228
  TOP w0.089: v3(75.35,44.95) 75.35,45.28 75.17,45.45 JCPU1.E26
  IN3 w0.089: v3(75.35,44.95) 75.35,44.94 75.69,45.28 75.69,45.28 75.94,45.28 76.08,45.42 77.66,45.42 77.94,45.7 77.94,47.08 78.17,47.31 78.55,47.31 78.93,47.69 78.93,49.04 79.72,49.82 79.72,54.03 80.59,54.9 80.59,65.1 80,65.69 80,76.23 81.28,77.51 82.22,77.51 83.01,78.3
  IN3 w0.14: 83.01,78.3 84.36,79.65 84.36,81.69 86.45,83.78 87.46,83.78 91.59,87.91 91.59,88.32 100.9,97.63 127.41,97.63 129.66,99.87 143.52,99.87 143.9,99.49 171.52,99.49 171.74,99.27 177.29,99.27 177.69,98.87 185.84,98.87 186.06,99.09 187.63,99.09 192.2,103.65 192.2,104.14 196.98,108.91 196.98,109.32 196.58,109.73 196.58,109.91 196.89,110.22 197.07,110.22 197.63,109.66 198.02,109.66 198.58,110.21 198.58,110.6 198.14,111.04 198.14,111.27 198.69,111.82 201.51,111.82 202.09,112.41 202.09,115.63 202.45,115.99 205.74,115.99 211.06,121.31 211.06,135.62 211.56,136.12 211.56,148.54 211.26,148.83 210.26,148.83 209.5,149.59 209.5,150.81 209.62,150.94 210.13,150.94 210.26,150.81 210.26,149.93 210.54,149.66 210.8,149.66 210.86,149.6 210.88,149.6 v1(211.07,149.4)
  BOTTOM w0.109: CC63.2 210.47,149.67 210.47,149.67 210.5,149.7 210.78,149.7 v1(211.07,149.4)
PEG_CTX_GRX_C_P15: length 227.9
  TOP w0.089: v3(76.37,43.97) 76.37,43.95 75.9,44.42 JCPU1.D25
  IN3 w0.089: v3(76.37,43.97) 76.72,43.97 76.91,44.16 76.91,44.55 76.83,44.63 76.54,44.63 76.41,44.5 76.26,44.5 75.98,44.23 75.98,43.79 76.21,43.56 77.58,43.56 77.8,43.78 77.8,45.2 78.17,45.57 78.6,45.57 78.74,45.71 78.74,47.16 79.11,47.54 79.67,47.54 79.78,47.65 79.78,48.32 80.24,48.78 80.24,52.74 81.49,54 81.49,54.88 81.19,55.19 81.19,66.08 80.82,66.45 80.82,76.47 81.33,76.98 82.29,76.98 83.07,77.75 83.2,77.75 84,78.55
  IN3 w0.14: 84,78.55 84.43,78.98 85.62,80.18 85.62,81.2 92.11,87.69 92.11,88.1 101.05,97.04 127.94,97.04 130.2,99.3 143.3,99.3 143.63,98.97 171.17,98.97 171.47,98.67 177.08,98.67 177.4,98.35 186.06,98.35 186.27,98.55 187.88,98.55 192.88,103.56 192.88,104.05 194.41,105.58 195.12,105.58 195.76,106.21 195.76,106.92 197.5,108.66 197.99,108.66 198.55,109.22 199.86,109.22 203.95,113.31 208.66,113.31 210.45,115.1 210.45,116.62 211.77,117.95 211.77,126.67 212.19,127.09 212.19,151.34 211.83,151.7 211.3,151.7 v1(211.05,151.45)
  BOTTOM w0.109: v1(211.05,151.45) 210.81,151.69 210.49,151.69 CC64.2
PEG_CTX_GRX_N0: length 8.9
  TOP w0.109: JMXM1.176 206.59,126.52 206.73,126.38 207.1,126.38 v3(207.28,126.56)
  BOTTOM w0.109: v3(207.28,126.56) 207.04,126.31 206.62,126.31 206.27,126.66 205.6,126.66 205.37,126.43 205.37,125.18 205.26,125.08 204.93,125.08 204.82,125.18 204.82,126.43 204.59,126.66 203.42,126.66 CC33.1
PEG_CTX_GRX_N1: length 8.9
  TOP w0.109: JMXM1.170 204.99,128.02 204.85,127.88 204.69,127.88 204.35,128.22 201.79,128.22 201.75,128.25 200.56,128.25 200.28,127.97 199.75,127.97 v1(199.55,128.17)
  BOTTOM w0.109: CC34.1 197.81,127.95 198.22,127.53 198.39,127.53 198.81,127.95 199.34,127.95 v1(199.55,128.17)
PEG_CTX_GRX_N2: length 4.8
  TOP w0.109: v3(202.44,129.99) 202.78,129.64 204.84,129.64 204.95,129.52 JMXM1.164
  BOTTOM w0.109: CC35.1 201.82,129.78 202.23,129.78 v3(202.44,129.99)
PEG_CTX_GRX_N3: length 4.3
  TOP w0.109: v1(202.89,133.61) 203.12,133.38 204.85,133.38 204.99,133.52 JMXM1.156
  BOTTOM w0.109: v1(202.89,133.61) 202.7,133.41 202.33,133.41 CC36.1
PEG_CTX_GRX_N4: length 4.6
  TOP w0.109: JMXM1.150 206.63,135.02 206.81,134.85 207.5,134.85 v3(207.68,135.02)
  BOTTOM w0.109: CC37.1 205.7,134.66 206.2,134.66 206.35,134.81 207.47,134.81 v3(207.68,135.02)
PEG_CTX_GRX_N5: length 4.6
  TOP w0.109: v1(202.91,136.02) 203.13,135.8 204.14,135.8 204.72,136.38 204.85,136.38 204.99,136.52 JMXM1.144
  BOTTOM w0.109: CC38.1 202.35,135.81 202.7,135.81 202.91,136.01 v1(202.91,136.02)
PEG_CTX_GRX_N6: length 4.6
  TOP w0.109: JMXM1.138 206.57,138.02 206.73,137.86 208.02,137.86 v3(208.21,138.05)
  BOTTOM w0.109: v3(208.21,138.05) 207.99,137.82 206.73,137.82 CC39.1
PEG_CTX_GRX_N7: length 4.3
  TOP w0.109: v1(202.89,139.44) 203.01,139.31 204.1,139.31 204.18,139.39 204.79,139.39 204.85,139.34 205,139.34 205.18,139.52 JMXM1.132
  BOTTOM w0.109: v1(202.89,139.44) 202.71,139.26 202.38,139.26 CC40.1
PEG_CTX_GRX_N8: length 3.8
  TOP w0.109: JMXM1.126 204.99,141.02 204.85,140.88 204.35,140.88 204.19,141.03 203.66,141.03 v1(203.45,141.25)
  BOTTOM w0.109: CC41.1 202.54,141.54 202.98,141.1 203.3,141.1 v1(203.45,141.25)
PEG_CTX_GRX_N9: length 3.7
  TOP w0.109: v3(207.71,142.75) 207.52,142.56 207.24,142.56 207.05,142.38 206.93,142.38 206.79,142.52 JMXM1.120
  BOTTOM w0.109: v3(207.71,142.75) 207.54,142.58 206.8,142.58 CC42.1
PEG_CTX_GRX_N10: length 5.3
  TOP w0.109: v3(208.38,144.34) 208.15,144.11 207.11,144.11 206.88,143.88 206.79,143.88 206.65,144.02 JMXM1.114
  BOTTOM w0.109: CC43.1 206.67,144.62 206.93,144.62 207.46,144.08 208.13,144.08 v3(208.38,144.34)
PEG_CTX_GRX_N11: length 5.8
  TOP w0.109: v3(208.44,146.07) 208.23,145.86 207.57,145.86 207.1,145.39 206.78,145.39 206.65,145.52 JMXM1.108
  BOTTOM w0.109: v3(208.44,146.07) 208.27,145.9 208.01,145.9 207.85,146.07 207.85,146.57 207.51,146.92 206.78,146.92 CC44.1
PEG_CTX_GRX_N12: length 5.6
  TOP w0.109: v3(207.87,147.89) 207.78,147.8 207.33,147.8 207.03,147.5 207.03,147.17 207.03,147.05 206.86,146.88 206.73,146.88 206.58,147.02 JMXM1.102
  BOTTOM w0.109: v3(207.87,147.89) 208,147.77 209.52,147.77 209.8,147.49 209.8,147.2 CC45.1
PEG_CTX_GRX_N13: length 5.1
  TOP w0.109: v1(203.47,149.02) 203.66,148.83 204.68,148.83 204.89,148.63 204.89,148.43 204.94,148.38 205.04,148.38 205.19,148.52 JMXM1.96
  BOTTOM w0.109: v1(203.47,149.02) 203.62,148.87 205.07,148.87 CC46.1
PEG_CTX_GRX_N14: length 3.7
  TOP w0.109: JMXM1.90 206.79,150.02 206.94,149.87 208.01,149.87 v3(208.25,150.11)
  BOTTOM w0.109: CC47.1 208.77,149.94 208.43,149.94 v3(208.25,150.11)
PEG_CTX_GRX_N15: length 3.9
  TOP w0.109: JMXM1.84 206.63,151.52 206.78,151.38 206.94,151.38 207.4,151.83 207.97,151.83 v3(208.23,152.08)
  BOTTOM w0.109: CC48.1 208.77,151.93 208.38,151.93 v3(208.23,152.08)
PEG_CTX_GRX_P0: length 9
  TOP w0.109: v1(207.28,125.92) 207.04,126.17 206.72,126.17 206.58,126.02 JMXM1.178
  BOTTOM w0.109: CC49.1 203.42,126.45 204.5,126.45 204.61,126.34 204.61,125.1 204.86,124.85 v1(205.07,124.85) 205.33,124.85 205.58,125.1 205.58,126.34 205.69,126.45 206.18,126.45 206.53,126.1 207.1,126.1 v1(207.28,125.92)
PEG_CTX_GRX_P1: length 8.9
  TOP w0.109: v3(199.55,127.53) 199.77,127.75 200.36,127.75 200.65,128.04 201.67,128.04 201.7,128.01 204.26,128.01 204.6,127.66 204.85,127.66 204.99,127.52 JMXM1.172
  BOTTOM w0.109: v3(199.55,127.53) 199.55,127.55 199.35,127.74 198.9,127.74 198.47,127.32 198.19,127.32 CC50.1
PEG_CTX_GRX_P2: length 4.9
  TOP w0.109: v1(202.44,129.35) 202.51,129.43 204.75,129.43 205.15,129.02 JMXM1.166
  BOTTOM w0.109: v1(202.44,129.35) 202.26,129.53 201.92,129.53 CC51.1
PEG_CTX_GRX_P3: length 4.3
  TOP w0.109: JMXM1.158 204.99,133.02 204.85,133.16 203.09,133.16 v3(202.89,132.97)
  BOTTOM w0.109: CC52.1 202.33,133.16 202.7,133.16 v3(202.89,132.97)
PEG_CTX_GRX_P4: length 4.7
  TOP w0.109: JMXM1.152 206.64,134.52 206.76,134.64 207.41,134.64 207.68,134.37 v3(207.68,134.36)
  BOTTOM w0.109: CC53.1 205.7,134.45 206.29,134.45 206.44,134.6 207.44,134.6 v3(207.68,134.36)
PEG_CTX_GRX_P5: length 4.6
  TOP w0.109: JMXM1.146 205.08,136.02 204.93,136.16 204.81,136.16 204.23,135.59 203.11,135.59 v3(202.91,135.38)
  BOTTOM w0.109: CC54.1 202.35,135.59 202.7,135.59 v3(202.91,135.38)
PEG_CTX_GRX_P6: length 4.7
  TOP w0.109: v3(208.21,137.41) 208.02,137.61 206.81,137.61 206.73,137.52 JMXM1.140
  BOTTOM w0.109: CC55.1 206.32,137.36 206.57,137.61 208.02,137.61 v3(208.21,137.41)
PEG_CTX_GRX_P7: length 4.4
  TOP w0.109: JMXM1.134 205.1,139.02 205.02,139.1 204.79,139.1 204.71,139.18 204.26,139.18 204.18,139.1 203.2,139.1 v3(202.89,138.8)
  BOTTOM w0.109: v3(202.89,138.8) 202.69,139 202.38,139 CC56.1
PEG_CTX_GRX_P8: length 3.9
  TOP w0.109: v3(203.45,140.61) 203.66,140.82 204.1,140.82 204.26,140.66 204.85,140.66 204.99,140.52 JMXM1.128
  BOTTOM w0.109: CC57.1 202.51,140.54 202.84,140.88 203.18,140.88 v3(203.45,140.61)
PEG_CTX_GRX_P9: length 3.7
  TOP w0.109: JMXM1.122 206.79,142.02 206.93,142.16 207.14,142.16 207.32,142.35 207.47,142.35 v3(207.71,142.11)
  BOTTOM w0.109: CC58.1 206.63,142.37 207.45,142.37 v3(207.71,142.11)
PEG_CTX_GRX_P10: length 5.2
  TOP w0.109: JMXM1.116 206.68,143.52 206.82,143.67 206.97,143.67 207.2,143.9 208.18,143.9 v3(208.38,143.7)
  BOTTOM w0.109: CC59.1 206.68,144.4 206.84,144.4 207.37,143.87 208.21,143.87 v3(208.38,143.7)
PEG_CTX_GRX_P11: length 5.9
  TOP w0.109: JMXM1.110 206.63,145.02 206.77,145.16 207.17,145.16 207.65,145.65 208.23,145.65 v1(208.44,145.44)
  BOTTOM w0.109: v1(208.44,145.44) 208.18,145.69 207.92,145.69 207.62,146 v1(207.62,146.27) 207.62,146.51 207.42,146.71 206.78,146.71 CC60.1
PEG_CTX_GRX_P12: length 5.6
  TOP w0.109: JMXM1.104 206.79,146.52 206.93,146.66 206.94,146.66 207.24,146.96 207.24,147.13 207.24,147.26 207.24,147.26 207.24,147.41 207.42,147.59 207.54,147.59 v3(207.87,147.26)
  BOTTOM w0.109: v3(207.87,147.26) 208.17,147.55 209.44,147.55 209.59,147.4 209.59,147.02 209.41,146.84 CC61.1
PEG_CTX_GRX_P13: length 5.2
  TOP w0.109: v3(203.47,148.39) 203.7,148.62 204.6,148.62 204.68,148.54 204.68,148.34 204.86,148.16 205,148.16 205.14,148.02 JMXM1.98
  BOTTOM w0.109: v3(203.47,148.39) 203.72,148.64 205.12,148.64 CC62.1
PEG_CTX_GRX_P14: length 3.7
  TOP w0.109: v3(208.25,149.48) 208.07,149.66 206.93,149.66 206.79,149.52 JMXM1.92
  BOTTOM w0.109: CC63.1 208.83,149.73 208.5,149.73 v3(208.25,149.48)
PEG_CTX_GRX_P15: length 3.9
  TOP w0.109: v3(208.23,151.45) 208.06,151.62 207.48,151.62 207.03,151.16 206.79,151.16 206.64,151.02 JMXM1.86
  BOTTOM w0.109: v3(208.23,151.45) 208.48,151.7 208.79,151.7 CC64.1
PEQ: length 3.8
  TOP w0.102: v1(47.17,146.31) U9.8
  BOTTOM w0.102: R69.2 46.9,146.05 v1(47.17,146.31) 47.37,146.11 v2(47.89,146.11) R70.2
PGOOD: length 4.7
  TOP w0.203: PU702.19 28.47,75.81 29.16,75.12 29.61,75.12 30.03,74.7 30.12,74.7 v1(30.26,74.56)
  BOTTOM w0.254: v1(30.26,74.56) 30.9,74.56 v2(30.95,74.51) 31.35,74.11 PR734.1
PGOODG: length 3.4
  TOP w0.203: PU702.36 26.87,82.14
  TOP w0.254: 26.87,82.14 26.71,82.3 26.71,83.2 26.59,83.31 v2(26.59,83.49) 26.59,83.99 PR707.1
PHASE1: length 13.4
  IN3 w1.016: 34.64,63.18 33.5,64.33 33.5,72.84 31.22,75.12
  vias: v1(30.64,76.52) v1(31.28,76.45) v1(35.03,62.34) v1(35.08,56.92) v1(35.06,56.29) v1(35.66,62.34) v2(35.36,62.79)
PHASE1G: length 5
  IN4 w1.016: 33.88,80.33 31.85,82.36 29.69,82.36
  vias: v1(28.61,83.31) v1(28.61,82.68) v1(34.77,79.74) v1(35.53,79.74) v2(35.44,80.32)
PHASE2: length 4.9
  IN3 w1.016: 33.54,75.72 33.54,79.15 32.49,80.2
  vias: v1(30.9,80.26) v1(31.53,80.26) v1(34.9,74.41) v1(35.14,68.56) v1(35.66,74.41) v1(35.77,68.58) v2(34.67,68.28)
PHASE2G: length 5.1
  IN1 w0.635: v1(31.22,89.41) 32.42,89.41 33.95,87.88 33.95,87.31 34.57,86.69 34.86,86.69
  vias: v1(30.48,89.42) v1(35.01,86.41) v1(35.66,86.41) v2(31.2,90.36)
PHASE3:
  vias: v1(44.83,47.75) v1(45.46,47.75) v1(50.65,47.86) v1(50.65,47.1) v2(43.97,46.24)
PLTRST_GPU#: length 224.1
  TOP w0.102: U16.2 210.03,135.32 209.79,135.56 209.07,135.56 208.76,135.26 208.76,134.53 208.2,133.97 208.2,132.66 207.43,131.89 202.08,131.89 201.16,132.81 201.16,133.61 200.14,134.63 v1(199.24,134.63) ; v1(15.45,102.22) 15.4,102.17 RH343.1
  IN1 w0.109: v1(178.09,132.21) 178.08,132.21 174.83,128.96 170.03,128.96 169.17,128.1 162.42,128.1 156.12,121.79 156.12,121.29 149.41,114.58 133.42,114.58 133.06,114.95 131.62,114.95 130.76,114.08 118.39,114.08 116.19,111.89 113.1,111.89 112.69,111.48 101.34,111.48 101.33,111.48 98.01,111.48 96.53,110.01 94.43,110.01 86.61,102.19 83.45,102.19 82.34,101.08 74.65,101.08 73.96,100.39 73.25,100.39 71.54,98.68 71.36,98.68 70.5,97.82 69.03,97.82 67.45,96.24 67.07,96.24 66.18,95.35 62.81,95.35 62.52,95.64 59.84,95.64 59.64,95.44 57.54,95.44 57.02,94.92 56.26,94.92 55.74,95.44 54.5,95.44 53.51,96.43 46.23,96.43 45.47,97.18 36.23,97.18 35.84,97.57 33.16,97.57 32.52,96.94 25.41,96.94 23.98,98.37 23.98,99.02 23.93,99.07 23.93,100.14 22.77,101.29 16.38,101.29 v1(15.45,102.22)
  IN4 w0.109: v1(199.24,134.63) 199.01,134.86 196.57,134.86 196.12,134.42 187.3,134.42 186.76,134.95 184.28,134.95 181.51,132.18 178.14,132.18 178.12,132.21 v1(178.09,132.21)
  BOTTOM w0.102: v1(199.24,134.63) v2(198.46,134.63)
PLTRST_LAN#: length 206.6
  TOP w0.102: U31.36 127.5,163.05 128.94,164.49 131,164.49 v2(131.76,163.73) 132.8,162.69 132.8,161.43 132.26,160.88 v1(132.26,160.12) ; RH338.1 v1(9.08,102.17)
  IN1 w0.109: v1(132.26,160.12) 132.21,160.07 130.05,160.07 128.87,161.25 128.87,169.04 127.97,169.93 112.22,169.93 107.71,165.42 107.71,162.99 104.89,160.17 104.89,159.49 103.71,158.31 101.56,158.31 100.4,157.15 100.4,154.87 93.56,148.03 80.47,148.03 80.1,148.4 75.97,148.4 75.56,148.81 72.21,148.81 71.91,149.11 71.91,149.48 70.32,151.07 68.2,151.07 66.19,153.07 49.63,153.07 47.69,151.13 47.69,150.57 45.24,148.12 40.03,148.12 37.64,150.51 34.18,150.51 32.94,149.27 24.38,149.27 21.2,146.09 21.2,144.04 19.5,142.34 15.61,142.34 14.93,141.67 14.12,141.67 v1(14.11,141.68)
  IN4 w0.109: v1(9.08,102.17) 7.81,103.44 7.81,105.17 7.35,105.63 7.35,106.76 6.92,107.19 6.04,107.19 4.37,108.86 4.37,121.81 3.91,122.26 3.91,127.13 5.47,128.69 5.47,129.93 9.76,134.23 9.76,134.77 11.97,136.98 11.97,139.55 v1(14.11,141.68)
PLTRST_MMI#: length 133.1
  TOP w0.127: RH336.1 v1(9.12,103.19) ; v3(30.67,46.73) 30.67,46.05 30.54,45.92 30.2,45.92 30.07,46.05 30.07,47.98 30.2,48.11 31.16,48.11 31.29,47.98 31.29,46.08 31.42,45.95 31.82,45.95 31.95,46.08 31.95,47.38 32.07,47.51 32.33,47.51 32.45,47.38 32.45,46.48 32.58,46.36 33.92,46.36 34.05,46.23 34.05,45.99 33.92,45.86 32.93,45.86 32.8,45.73 32.8,45.35 32.93,45.23 33.26,45.23 33.39,45.1 33.39,44.84 33.26,44.72 32.93,44.72 32.8,44.59 32.8,44.36 32.93,44.23 33.26,44.23 33.39,44.11 33.39,43.89 33.26,43.76 32.21,43.76 32.08,43.63 32.08,43.38 32.21,43.25 33.07,43.25 33.2,43.12 33.2,42.32 33.07,42.2 32.24,42.2 32.12,42.07 32.12,41.82 32.24,41.69 33.07,41.69 33.2,41.56 33.2,40.31 33.07,40.18 32.31,40.18 32.18,40.05 32.18,39.8 32.31,39.67 33.07,39.67 33.2,39.54 33.2,39.13 33.07,39.01 32.93,39.01 32.8,38.88 32.8,38.62 32.93,38.5 33.07,38.5 33.2,38.37 33.2,38.12 33.07,37.99 32.93,37.99 32.8,37.86 32.8,37.61 32.93,37.48 33.07,37.48 33.2,37.35 33.2,35.84 33.07,35.71 32.78,35.71 32.65,35.84 32.65,36.25 32.52,36.37 32.22,36.37 32.1,36.25 32.1,35.2 32.22,35.08 34.83,35.08 34.96,35.2 34.96,35.6 34.83,35.73 33.97,35.73 33.84,35.85 33.84,36.14 33.97,36.27 34.86,36.27 34.99,36.4 34.99,36.68 34.86,36.81 33.97,36.81 33.84,36.93 33.84,37.3 33.97,37.43 34.22,37.43 34.35,37.55 34.35,37.87 34.22,38 33.97,38 33.84,38.13 33.84,43 33.97,43.13 34.33,43.13 34.45,43 34.45,39.37 34.58,39.24 34.92,39.24 35.05,39.37 35.05,43.02 35.18,43.15 JIO1.10
  IN3 w0.127: v1(9.12,103.19) 8.11,102.18 8.11,98.8 8.05,98.74 8.05,91 7.09,90.03 7.09,88.6 7.24,88.44 7.24,68.14 11.59,63.79 11.59,63.78 12.79,62.57 14.18,62.57 14.57,62.18 25.02,62.18 29.53,57.67 29.53,47.86 v3(30.67,46.73)
PLTRST_USH#: length 235
  TOP w0.102: v1(110.17,17.07) 110.17,17.13 110.82,17.78 110.82,22.11 112.62,23.91 112.62,29.59 112.83,29.8 JUSH1.15 ; v1(2.86,102.39) 4.84,102.39 5.73,101.5 6.92,101.5 7.35,101.07 9.7,101.07 RH335.1
  IN2 w0.127: v1(2.86,102.39) 1.15,100.69 1.15,80.58 1.79,79.95 1.79,77.86 1.11,77.18 1.11,64.13 7.7,57.54 23.23,57.54 24.75,56.02 24.75,45.56 26.4,43.9 26.41,43.89 26.41,42.48 26.39,42.46 26.39,41.12 25.78,40.51 25.17,40.51 24.03,39.37 24.03,26.77 27.24,23.55 27.24,23.52 27.27,23.5 27.27,22.19 27.26,22.19 27.26,21.21 27.37,21.1 27.37,16.29 26.86,15.79 26.86,14.59 26.19,13.92 v3(25.75,13.92)
  IN3 w0.127: v3(25.75,13.92) 25.89,13.92 27.18,12.64 27.18,8.4 27.79,7.79 31.19,7.79 31.82,8.42 35.76,8.42 36.52,7.66 103.22,7.66 106.74,11.18 107.02,11.18 110.29,14.44 110.29,16.97 110.18,17.07 v1(110.17,17.07)
